# Allegro board LA8821PR30_MB-1113.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VS on BOTTOM (solid shape): 174.68,51.14 176.71,51.14 176.84,51.02 176.84,50 176.59,49.75 174.81,49.75 174.43,49.36 174.3,49.36 174.07,49.14 174.07,49.09 174.07,49.08 174.05,48.96 174.07,48.83 174.07,48.83 174.07,48.25 173.9,48.07 173.54,48.07 173.41,48.2 173.41,51.14 173.54,51.27 174.56,51.27
+3VS on BOTTOM (solid shape): 168.74,45.72 168.74,44.8 168.45,44.51 165.99,44.51 165.9,44.61 165.9,44.95 166.01,44.97 166.1,45.03 166.12,45.04 166.13,45.04 166.21,45.12 166.21,45.16 166.22,45.17 166.25,45.33 166.22,45.48 166.21,45.49 166.21,45.77 166.39,45.95 168.5,45.95
+3VS on BOTTOM (solid shape): 124.67,78.19 124.74,78.16 124.77,78.09 124.86,77.86 125.08,77.74 125.13,77.73 125.13,75.22 125.08,75.17 124.47,75.17 124.11,74.81 123.57,74.81 123.5,74.88 123.5,77.12 123.59,77.21 124.19,77.21 124.26,77.28 124.26,78.14 124.31,78.19
+3VS on IN2 (solid shape): 113.6,50.51 113.6,49.75 113.34,49.49 111.31,49.49 111.06,49.75 111.06,49.98 111.92,49.98 111.92,49.92 111.93,49.87 111.94,49.82 111.97,49.78 112,49.73 112.03,49.7 112.08,49.67 112.12,49.64 112.17,49.63 112.22,49.62 112.28,49.62 112.33,49.63 112.38,49.64 112.42,49.67 112.46,49.7 112.5,49.73 112.53,49.78 112.56,49.82 112.57,49.87 112.58,49.92 112.58,49.98 112.57,50.03 112.56,50.08 112.53,50.12 112.5,50.16 112.46,50.2 112.42,50.23 112.38,50.26 112.33,50.27 112.28,50.28 112.22,50.28 112.17,50.27 112.12,50.26 112.08,50.23 112.03,50.2 112,50.16 111.97,50.12 111.94,50.08 111.93,50.03 111.92,49.98 111.06,49.98 111.06,50.63 111.18,50.76 113.34,50.76
+3VS on IN2 (solid shape): outline of 6288 points within 16.57,48.6 99.09,84.92
+3VS on VCC (solid shape): outline of 19244 points within 94.29,31.2 204.4,78.19
+3VS on TOP: 202.6,72.1 200.46,72.1 200.29,72.28 200.29,73.37 200.3,73.38 200.3,75.41 201.51,76.62 201.51,77.28 201.92,77.7 207.93,77.7 208.25,77.38 208.25,76.39 207.94,76.09 203.25,76.09 202.98,75.82 202.98,72.48
+3VS_WLAN on TOP (solid shape): 178.11,43.78 178.11,43.65 178.24,43.52 178.75,43.52 178.87,43.4 178.87,42.51 178.75,42.38 178.37,42.38 178.25,42.5 178.25,42.91 178.16,43 177.49,43 177.35,42.87 177.35,42.38 177.1,42.13 176.59,42.13 176.46,42.25 176.46,43.65 176.79,43.98 176.8,43.98 176.89,44.04 176.97,44.13 176.98,44.16 177.73,44.16
+3VS_WLAN on TOP (solid shape): 178.9,55.84 178.9,54.6 178.75,54.44 178.49,54.44 178.37,54.32 178.37,53.81 178.29,53.73 176.53,53.73 176.53,53.83 176.32,54.04 175.84,54.29 176.09,53.81 176.17,53.73 176,53.73 175.75,53.48 174.63,53.48 174.43,53.28 173.74,53.28 173.67,53.35 173.67,54.67 173.77,54.78 174.38,54.78 175.62,56.02 178.72,56.02
+3VS_WLAN on BOTTOM (solid shape): 181.08,43.9 181.08,42.79 180.93,42.63 179.18,42.63 178.9,42.35 178.39,42.35 178.26,42.48 178.26,43.4 178.95,44.08 180.91,44.08
+3VS_WLAN on VCC (solid shape): outline of 2227 points within 175.19,22.95 182.88,57.37
+5V_CHGUSB on TOP (solid shape): outline of 134 points within 213.29,53.15 217.76,58
+5V_CHGUSB on BOTTOM (solid shape): 218.16,34.66 218.16,34.64 218.25,34.44 218.4,34.26 218.4,33.19 218.14,32.69 218.27,32.15 217.51,31.38 217.51,31.19 217.5,31.18 217.33,30.7 217.5,30.22 217.51,30.21 217.51,30.04 218.23,29.31 220.3,29.31 221.07,28.64 222.1,28.61 222.19,28.6 222.23,28.51 222.23,28.03 221.98,27.77 221.98,26.53 221.74,26.29 220.24,26.29 219.96,26.01 219.93,26.01 219.72,26.02 219.51,25.95 219.5,25.95 219.33,25.95 219.31,25.95 219.16,26.01 219,26.03 218.86,26 218.74,25.95 218.4,25.95 217.61,26.73 217.61,28.41 217.01,29.01 215.95,29.01 215.83,29.12 215.83,35.18 215.86,35.2 217.61,35.2
+5V_CHGUSB on IN1 (solid shape): outline of 433 points within 214.56,21.42 221.64,55.6
+5V_CHGUSB on VCC (solid shape): outline of 1407 points within 214.7,21.1 221.84,55.8
+5V_USB_P0 on TOP (solid shape): 216.16,61.48 216.16,60.07 215.83,59.73 213.43,59.73 213.26,59.9 213.26,61.43 213.51,61.68 215.96,61.68
+5V_USB_P0 on BOTTOM (solid shape): 217.58,65.85 217.58,63.36 217.57,63.35 217.57,62.99 216.6,62.02 216.58,62.02 216.39,61.92 216.29,61.71 216.21,61.63 216.21,60.16 215.96,59.91 215.2,59.91 214.94,60.16 214.94,62.93 215.65,63.64 215.65,65.82 215.83,66 217.43,66
+5V_USB_P0 on IN2 (solid shape): outline of 318 points within 212.78,50.76 219.51,61.81
+5V_USB_P0 on IN3 (solid shape): outline of 273 points within 214.51,51.4 219.51,61.81
+5VALW on TOP (solid shape): 172.68,66.05 172.68,63.89 172.42,63.64 171.43,63.64 171.1,63.97 171.1,65.44 171.27,65.61 171.6,65.61 172.12,66.13 172.6,66.13
+5VALW on TOP (solid shape): outline of 159 points within 205.43,56.2 212.66,71.63
+5VALW on BOTTOM (solid shape): 173.4,65.23 173.4,64.36 174.3,63.46 174.3,62.83 174.05,62.57 171.63,62.57 171.09,63.12 171.09,65.58 171.13,65.62 173.01,65.62
+5VALW on BOTTOM (solid shape): 207.79,71.13 211.64,71.13 212.02,70.75 212.02,69.56 205.52,69.56 205.5,69.58 205.5,71.36 205.62,71.49 207.44,71.49
+5VALW on BOTTOM (solid shape): 111.63,85.62 113.02,85.62 113.13,85.56 113.26,85.55 113.66,85.08 114.12,84.65 114.12,84.11 113.96,83.96 113.61,83.96 112.77,84.8 111.56,84.8 111.39,84.62 111.28,84.62 111.21,84.7 111.21,85.61 111.31,85.71 111.54,85.71
+5VALW on VCC (solid shape): outline of 3102 points within 169.73,57.87 214.42,72.1
+5VALW on IN3 (solid shape): 172.52,65.24 172.52,63.72 172.4,63.59 171.13,63.59 170.87,63.84 170.87,65.37 171.13,65.62 172.14,65.62
+5VALW on IN3 (solid shape): outline of 2485 points within 205.37,1.12 231.58,71.48
+5VS on TOP (solid shape): 172.02,33.62 172.02,32.85 171.89,32.73 170.54,32.73 169.25,34.02 169.25,34.48 169.43,34.66 170.97,34.66
+5VS on TOP (solid shape): 179.25,62.32 179.25,61.43 179,61.18 176.21,61.18 176.08,61.3 176.08,62.19 176.46,62.57 179,62.57
+5VS on TOP (solid shape): 8.63,20.76 8.63,19.6 8.46,19.42 7.23,19.42 7.04,19.61 7.04,20.76 7.21,20.93 8.46,20.93
+5VS on TOP (solid shape): 175.11,47.46 175.11,45.56 175.1,45.55 175.04,45.44 175.01,45.32 175.01,45.3 174.81,45.1 173.97,45.1 173.67,45.4 173.67,47.54 173.77,47.64 174.94,47.64
+5VS on TOP (solid shape): outline of 105 points within 169.6,67.27 179.76,74.05
+5VS on BOTTOM (solid shape): 158.81,35.39 158.81,32.09 158.43,31.71 156.88,31.71 156.65,31.95 156.65,35.39 156.9,35.65 158.55,35.65
+5VS on BOTTOM (solid shape): 171.52,83.91 171.52,82.82 171.36,82.65 170.57,82.65 170.39,82.83 170.39,83.91 170.58,84.1 171.33,84.1
+5VS on BOTTOM (solid shape): 14.74,25.29 14.74,24.16 14.54,23.96 13.29,23.96 13.08,24.18 13.08,25.05 13.4,25.36 14.66,25.36
+5VS on BOTTOM (solid shape): 14.61,21.35 14.61,20.61 14.74,20.49 14.74,19.44 14.56,19.27 13.65,19.27 13.14,19.77 13.14,21.09 13.05,21.19 13.05,21.65 13.33,21.93 14.03,21.93
+5VS on BOTTOM (solid shape): 9.59,21.65 9.59,21.41 9.51,21.33 9.51,19.36 9.32,19.17 7.4,19.17 7.1,19.48 7.1,21.32 7.69,21.91 9.33,21.91
+5VS on BOTTOM (solid shape): 181.51,84.13 181.51,84.03 181.46,83.98 181.34,83.75 181.4,83.49 181.43,83.46 181.45,83.43 181.54,83.34 181.54,82.23 181.62,82.16 181.62,81.37 181.59,81.3 181.52,81.27 181.43,81.25 181.35,81.22 181.11,80.82 181.43,80.48 181.44,80.43 181.41,80.38 181.39,80.35 181.39,79.08 181.34,79.03 180.68,79.03 180.6,79.11 180.6,80.3 180.5,80.4 180.5,83.63 180.52,83.65 180.52,84.28 180.55,84.31 181.33,84.31
+5VS on BOTTOM (solid shape): outline of 87 points within 170.09,67.65 173.78,72.12
+5VS on IN2 (solid shape): 171,34.12 171,32.98 169.73,31.71 156.9,31.71 156.65,31.97 156.65,32.37 159.06,32.37 159.06,32.32 159.08,32.27 159.1,32.22 159.12,32.17 159.16,32.13 159.2,32.09 159.24,32.06 159.29,32.04 159.34,32.02 159.39,32.02 159.44,32.02 159.5,32.02 159.55,32.04 159.6,32.06 159.64,32.09 159.68,32.13 159.71,32.17 159.74,32.22 159.76,32.27 159.77,32.32 159.77,32.37 159.77,32.43 159.76,32.48 159.74,32.53 159.71,32.57 159.68,32.61 159.64,32.65 159.6,32.68 159.55,32.7 159.5,32.72 159.44,32.73 159.39,32.73 159.34,32.72 159.29,32.7 159.24,32.68 159.2,32.65 159.16,32.61 159.12,32.57 159.1,32.53 159.08,32.48 159.06,32.43 159.06,32.37 156.65,32.37 156.65,33.24 156.9,33.49 168.33,33.49 169.35,34.51 170.62,34.51
+5VS on IN3 (solid shape): outline of 11307 points within 23.43,44.03 173.54,80.1
+5VS on IN4 (solid shape): 171.83,84.2 171.83,82.89 171.63,82.7 170.83,82.7 170.26,83.27 170.26,84.32 170.5,84.56 171.47,84.56
+5VS on IN4 (solid shape): 181.29,83.74 181.29,82.99 181.08,82.79 179.85,82.79 179.51,83.13 179.51,83.69 179.76,83.95 181.08,83.95
+5VS on IN4 (solid shape): 176.71,47.97 176.71,46.95 176.31,46.55 175.91,46.55 175.89,46.57 175.57,46.77 175.25,46.57 175.24,46.55 174.32,46.55 173.72,47.15 173.72,47.76 174.05,48.09 176.59,48.09
+5VS on IN4 (solid shape): outline of 3268 points within 6.84,18.67 30.05,51.02
+5VS_KBL on BOTTOM (solid shape): 164.01,35.52 164.01,33.24 164.9,32.35 168.21,32.35 168.71,32.85 168.71,33.24 168.97,33.49 171.89,33.49 172.4,32.98 172.4,29.43 172.14,29.17 170.88,29.17 169.55,30.51 170.36,30.51 170.37,30.45 170.38,30.4 170.39,30.34 170.42,30.29 170.45,30.25 170.49,30.21 170.54,30.17 170.58,30.15 170.64,30.13 170.69,30.11 170.75,30.11 170.8,30.11 170.86,30.13 170.91,30.15 170.96,30.17 171,30.21 171.04,30.25 171.07,30.29 171.1,30.34 171.12,30.4 171.13,30.45 171.13,30.51 171.12,30.56 171.11,30.62 171.09,30.67 171.06,30.71 171.02,30.76 170.98,30.8 170.93,30.83 170.88,30.85 170.83,30.87 170.77,30.87 170.72,30.87 170.66,30.87 170.61,30.85 170.56,30.83 170.51,30.8 170.47,30.76 170.44,30.71 170.41,30.67 170.38,30.62 170.37,30.56 170.36,30.51 169.55,30.51 169.08,30.98 163.19,30.98 161.73,32.44 161.73,35.39 161.98,35.65 163.89,35.65
+V1.05S_VCCPP_B+ on TOP (solid shape): 115.06,46.75 115.06,44.68 115.55,44.18 115.55,43.04 115.56,43.03 115.56,42.77 115.93,42.41 117.94,42.41 118.24,42.1 118.24,41.03 117.86,40.65 115.73,40.65 115.73,41.29 115.63,41.39 114.38,41.39 114.15,41.16 114.15,40.65 111.46,40.65 111.16,40.96 109.35,40.96 109.28,41.03 109.28,41.8 109.29,41.81 109.29,45.56 109.3,45.66 109.29,45.75 109.29,46.1 110.01,46.82 114.98,46.82
+VCC_CORE on TOP (solid shape): outline of 601 points within 54.34,72.22 73.97,84.52
+VCC_CORE on BOTTOM (solid shape): 38.79,76.67 38.79,74.38 38.03,73.62 38.03,73.14 37.95,73.06 37.95,71.56 37.85,71.46 33.08,71.46 32.68,71.07 31.31,71.07 30.95,70.72 30.95,68.45 30.39,67.88 29.27,67.88 29.17,67.98 29.17,70.47 29.12,70.52 28.4,70.52 28.38,70.5 28.38,68.01 28.25,67.88 26.84,67.88 26.62,68.1 26.62,72.07 30.71,76.16 30.71,76.33 31.31,76.92 38.54,76.92
+VCC_CORE on BOTTOM (solid shape): outline of 1595 points within 50.86,73.09 73.59,86.35
+VCC_CORE on IN1 (solid shape): outline of 5484 points within 31.43,70.95 73.59,86.32
+VCC_CORE on IN2 (solid shape): outline of 2546 points within 32.57,71.16 73.59,85.18
+VCC_GFXCORE_AXG on TOP (solid shape): 52,73.37 58.1,73.37 58.1,73.37 58.87,73.37 59.32,72.92 59.32,69.72 58.87,69.27 58.26,69.27 58.1,69.1 58.1,68.67 57.84,68.41 57.08,68.41 56.83,68.16 56.83,67.5 55.58,66.26 46.46,66.26 46.26,66.45 42.42,66.45 41.97,66 41.97,64.6 38.67,61.3 36.89,61.3 36.63,61.56 36.63,68.97 36.67,69.05 36.74,69.08 36.88,69.1 37.01,69.17 37.08,69.2 37.15,69.17 37.65,69.18 37.65,69.68 37.62,69.75 37.75,70.07 37.62,70.38 37.65,70.45 37.75,70.68 37.68,70.92 37.65,70.95 39.54,72.85 45.57,72.85 46.21,73.49 51.87,73.49
+VCC_GFXCORE_AXG on BOTTOM (solid shape): outline of 1698 points within 18.42,49.95 60.66,74.28
+VCC_GFXCORE_AXG on IN1 (solid shape): outline of 662 points within 36.51,61.81 60,73.57
+VCC_GFXCORE_AXG on VCC (solid shape): outline of 1434 points within 36.53,61.94 59.75,75.65
+VCC_GFXCORE_AXG on IN4 (solid shape): outline of 881 points within 36.51,61.81 60,73.57
+VCCA_DPLL_L on BOTTOM (solid shape): 87.45,72.69 87.45,72.08 88.24,71.29 88.24,69.6 88.18,69.54 86.93,69.54 86.84,69.63 86.84,69.93 86.8,69.97 85.62,69.97 85.4,70.19 85.4,70.95 85.53,71.08 85.53,72.48 85.78,72.73 87.41,72.73
+VCCAFDI_VRM on BOTTOM (solid shape): 102.12,64.33 102.12,63.46 101.95,63.29 101.91,63.31 101.77,63.33 101.65,63.27 101.63,63.26 101.61,63.26 101.25,62.9 100.97,62.9 100.85,63.02 100.85,63.08 100.85,63.12 100.85,63.48 100.85,63.55 100.85,63.62 100.85,63.92 100.85,63.99 100.85,64.06 100.85,64.2 101.18,64.53 101.91,64.53
+VCCP on TOP (solid shape): 101.71,49.62 101.71,47.64 101.99,47.36 105.37,47.36 105.54,47.54 105.54,49.44 105.72,49.62 106.74,49.62 106.86,49.49 106.86,41.36 106.74,41.24 105.98,41.24 105.51,41.71 105.51,41.96 105.21,42.25 100.26,42.25 99.89,42.62 98.09,42.62 97.9,42.81 97.9,43.22 98.25,43.57 99.98,43.57 100.24,43.83 100.57,43.83 100.77,44.03 100.77,49.62 100.9,49.75 101.58,49.75
+VCCP on BOTTOM (solid shape): 91.62,71.33 91.62,69.66 91.88,69.4 91.88,67.29 91.61,67.02 91.61,66.13 91.65,66.09 91.96,66.09 92.15,65.9 92.15,65.51 91.88,65.24 91.88,64.73 91.63,64.48 90.81,64.48 90.61,64.68 90.61,65.75 90.1,66.26 90.1,66.94 90.25,67.08 90.43,67.08 90.43,67.19 90.61,67.37 90.61,68.77 90.43,68.95 90.36,68.95 90.33,68.97 90.23,68.97 90.13,69.07 90.13,70.98 90.61,71.46 91.49,71.46
+VCCP on BOTTOM (solid shape): outline of 187 points within 87.54,42.05 106.92,47.08
+VCCP on VCC (solid shape): outline of 20662 points within 49.71,42 112.45,80.23
+VCCSA on TOP (solid shape): outline of 1553 points within 70.92,70.75 94.38,86.19
+VCCSA on BOTTOM (solid shape): 92.61,86.1 92.61,85.46 92.61,85.46 92.61,85.08 92.62,85.08 92.62,84.82 93.17,84.26 94.47,84.26 95.39,85.19 95.5,85.21 95.57,85.12 95.57,84.82 95.92,84.82 95.92,84.32 95.57,84.32 95.57,83.62 95.92,83.62 95.92,83.12 95.57,83.12 95.57,82.35 95.92,82.35 95.92,81.84 95.64,81.56 92.19,81.56 92.17,81.58 91.64,82.08 91.02,82.48 91.01,82.49 90.53,82.97 88.68,82.97 88.63,82.92 85.33,82.92 85.15,83.1 85.15,85.94 85.4,86.19 92.51,86.19
+VCCSA_BT on TOP (solid shape): 107.4,84.61 107.4,82.23 107.3,82.13 106.38,82.13 106.28,82.23 106.28,83.35 106.64,83.71 106.64,84.59 106.76,84.72 107.28,84.72
+VCCSA_BT on BOTTOM (solid shape): 107.37,84.59 108.64,84.59 108.69,84.54 108.69,84.42 108.57,84.29 107.6,84.29 107.35,84.04 107.35,83.76 107.12,83.53 106.89,83.53 106.74,83.68 106.74,83.91 106.89,84.06 106.89,84.7 106.92,84.72 107.25,84.72
+VCCSA_PHASE on BOTTOM (solid shape): 106.59,84.7 106.59,83.5 106.74,83.35 107.2,83.35 107.61,83.77 107.61,83.82 107.63,83.83 107.63,84.01 107.73,84.11 108.58,84.11 108.72,83.97 108.72,81.94 107.19,80.42 104.78,80.42 104.43,80.77 104.43,84.7 104.53,84.8 106.48,84.8
+VCCSA_PWR_SRC on BOTTOM (solid shape): 113.44,82.51 113.44,82.28 113.72,82 116.9,82 117.09,82.19 117.12,82.18 117.5,82.18 117.69,82.51 117.72,82.58 117.79,82.61 119.9,82.61 119.95,82.56 119.95,80.38 119.88,80.3 119.69,80.3 119.64,80.35 119.64,80.61 119.18,81.06 117.99,81.06 116.72,79.79 112.96,79.79 112.43,80.32 111.76,80.32 111.6,80.48 111.6,81.09 111.69,81.18 111.69,81.76 111.51,81.94 111.51,82.96 111.64,83.08 112.87,83.08
GND on TOP (solid shape): 23.85,59.19 23.85,57.38 23.59,57.12 22.3,57.12 22.21,57.21 22.21,59.25 22.27,59.31 23.73,59.31
GND on TOP (solid shape): 53.75,20.21 53.75,18.94 53.55,18.73 51.24,18.73 51.14,18.83 51.14,20.26 51.37,20.49 53.47,20.49
GND on TOP (solid shape): 32.19,54.55 32.19,51.14 31.77,50.72 30.32,50.72 29.98,51.07 29.98,54.57 30.2,54.79 31.95,54.79
GND on TOP (solid shape): 11.58,23.87 11.58,22.58 11.44,22.44 9.85,22.44 9.33,22.96 5.62,22.96 5.39,23.19 5.39,24.85 5.77,25.23 10.22,25.23
GND on TOP (solid shape): 100.41,51.08 100.41,44.23 100.29,44.11 98.31,44.11 97.75,44.67 97.75,51.19 97.99,51.43 100.06,51.43
GND on TOP (solid shape): 164.9,51.63 166.71,51.63 166.94,51.4 166.94,49.49 166.68,49.24 164.4,49.24 163.51,50.13 163.51,51.27 163.89,51.65 164.88,51.65
GND on TOP (solid shape): 184.13,78.47 184.13,77.71 183.24,76.82 183.24,76.16 183.17,76.09 182.56,76.09 182.46,76.19 182.46,76.92 182.68,77.15 182.68,78.75 182.76,78.83 183.78,78.83
GND on TOP (solid shape): 104.86,51.27 105.21,51.27 105.34,51.14 105.34,47.74 105.21,47.61 102.04,47.61 101.87,47.78 101.87,49.15 104.02,51.3 104.83,51.3
GND on TOP (solid shape): 188.63,61.89 188.63,60.07 188.47,59.91 187.21,59.91 186.94,60.19 186.15,60.19 185.91,60.42 185.91,61.94 186.04,62.06 188.45,62.06
GND on TOP (solid shape): 100.13,42 105.18,42 105.29,41.88 105.29,39.03 104.96,38.7 98.74,38.7 98.17,39.27 98.17,41.05 98.05,41.16 98.05,42.28 98.14,42.37 99.77,42.37
GND on TOP (solid shape): 132.74,43.58 132.74,36.8 132.61,36.66 129.6,36.66 129.47,36.79 129.47,38.19 130.49,39.2 130.49,40.22 131.38,41.11 131.38,43.52 131.63,43.78 132.54,43.78
GND on TOP (solid shape): 205.77,61.86 206.38,61.86 206.48,61.76 206.48,61.05 206.48,61.05 206.48,60.09 206.22,59.83 204.39,59.83 204.3,59.92 204.3,62.01 204.55,62.27 205.37,62.27
GND on TOP (solid shape): 55.94,81.98 55.94,81.5 55.73,81.29 52.43,81.29 52.25,81.11 52.25,80.73 52.13,80.61 51.99,80.61 51.49,81.11 51.49,81.62 51.24,81.87 51.24,82.13 51.49,82.38 55.53,82.38
GND on TOP (solid shape): 60.26,59.35 60.26,58.64 60.15,58.53 59.4,58.53 59.37,58.51 59.11,58.51 58.48,57.87 58.48,57.06 58.2,56.78 57.72,56.78 57.72,59.27 57.92,59.47 60.13,59.47
GND on TOP (solid shape): 95.79,50.03 95.79,49.23 95.1,48.54 94.66,48.54 94.55,48.65 93.58,48.65 93.43,48.8 93.43,49.06 94.14,49.77 94.14,49.88 94.34,50.08 95.74,50.08
GND on TOP (solid shape): 192.75,80.99 192.75,80.14 192.38,79.77 192.38,76.38 192.16,76.16 189.86,76.16 189.73,76.29 189.73,77.65 190.22,78.13 190.22,79.58 191.03,80.39 191.03,80.92 191.22,81.11 192.63,81.11
GND on TOP (solid shape): 209.42,64.57 209.42,62.26 209.75,61.94 210.24,61.94 210.5,61.68 210.5,61.18 210.37,61.05 208.46,61.05 208.34,60.92 207.93,60.92 207.8,61.05 207.8,64.45 208.08,64.73 209.26,64.73
GND on TOP (solid shape): 171.53,42.74 171.53,40.7 171.43,40.6 170.97,40.6 170.77,40.4 170.77,38.54 170.72,38.49 169.2,38.49 169.04,38.65 169.04,41.08 169.17,41.21 169.63,41.21 169.93,41.52 169.93,42.99 170.01,43.07 171.2,43.07
GND on TOP (solid shape): 195.26,66.89 195.26,65.32 195.08,65.14 195.08,64.17 194.49,63.59 193.62,63.59 193.1,64.11 192.21,64.11 192.08,64.24 192.08,66.64 192.59,67.14 195,67.14
GND on TOP (solid shape): 140.27,30.63 140.27,30.16 140.6,29.83 140.6,29.57 141.28,28.88 141.28,28.14 140.77,27.62 138.14,27.62 137.92,27.84 137.92,30.68 138.23,30.99 139.91,30.99
GND on TOP (solid shape): 89.97,67.02 89.97,66.26 89.72,66 87.94,66 87.69,66.26 87.69,66.76 87.31,67.14 85.02,67.14 84.51,67.65 84.51,68.25 84.53,68.26 84.6,68.33 84.64,68.41 84.64,68.42 84.77,68.54 88.45,68.54
GND on TOP (solid shape): 45.91,66.25 46.16,66.25 46.27,66.14 49.25,66.14 49.55,65.84 49.55,64.67 49.55,64.67 49.55,63.82 49.23,63.49 47.56,63.49 46.62,64.43 42.27,64.43 42.19,64.52 42.19,66 42.44,66.26 45.91,66.26
GND on TOP (solid shape): 205.08,68.04 205.08,67.12 204.75,66.79 203.47,66.79 203.08,66.4 203.08,65.7 203,65.62 201.56,65.62 199.88,63.94 199.88,63.69 199.8,63.61 199.04,63.61 198.99,63.67 198.99,65.04 199.5,65.54 199.5,67.97 199.75,68.22 204.9,68.22
GND on TOP (solid shape): 72.45,64.6 72.45,63.72 72.7,63.46 72.96,63.46 73.08,63.33 73.08,62.7 72.83,62.45 70.29,62.45 70.03,62.7 70.03,63.72 70.16,63.84 71.18,63.84 71.9,64.57 71.93,64.57 71.93,64.59 72.07,64.73 72.32,64.73
GND on TOP (solid shape): 149.07,39.14 149.07,38.56 149.36,38.27 150.06,38.27 150.17,38.15 150.17,37.55 150.64,37.08 150.64,36.5 150.55,36.41 146.92,36.41 146.64,36.69 146.64,39.27 146.7,39.33 148.88,39.33
GND on TOP (solid shape): 25.86,70.19 26.6,70.19 26.98,69.81 26.98,66.13 26.73,65.87 24.7,65.87 24.24,65.42 24.24,64.71 24.06,64.53 23.43,64.53 23.25,64.71 23.25,68.41 23.32,68.49 24.29,68.49 24.77,68.97 24.79,68.97 24.95,69.13 24.95,69.15 25,69.2 25,69.99 25.2,70.19 25.66,70.19 25.66,70.19 25.86,70.19
GND on TOP (solid shape): 50.05,74.71 52.2,74.71 52.53,74.38 53.4,74.38 53.52,74.26 53.52,73.75 53.4,73.62 46,73.62 45.42,73.05 39.79,73.05 39.55,73.28 39.55,74 40.44,74.89 45.78,74.89 46.36,75.48 48.85,75.48 48.88,75.48 49.28,75.48
GND on TOP (solid shape): 179.48,35.39 179.73,35.39 179.76,35.37 179.8,35.37 179.88,35.33 179.9,35.24 179.89,35.13 179.93,35.03 179.94,35.01 179.94,34.81 179.86,34.73 176.99,34.73 176.71,35.01 176.71,35.47 177.22,35.98 178.9,35.98
GND on TOP (solid shape): 173.36,56.96 173.36,56.05 173.35,56.03 173.35,55.11 173.49,54.97 173.49,52.95 173.72,52.72 174.38,52.72 174.45,52.64 174.45,52.51 174.4,52.46 173.64,52.46 173.49,52.31 173.49,51.37 173.44,51.32 172.6,51.32 172.5,51.42 172.5,51.9 172.5,51.9 172.5,53.31 172.5,53.31 172.5,53.9 172.5,53.9 172.5,54.11 170.29,56.32 170.29,56.96 170.44,57.11 173.21,57.11
GND on TOP (solid shape): 111.03,84.52 111.03,84.1 111.37,83.76 114.45,83.76 114.64,83.57 114.64,83.53 114.56,83.46 114.56,83.27 114.41,83.27 114.41,83.02 114.38,82.99 114.38,82.52 114.38,82.22 113.81,81.65 113.47,81.65 113.29,81.83 111.65,81.83 111.51,81.69 111.5,81.69 111.5,81.68 111.26,81.43 108.97,81.43 108.95,81.46 108.95,83.55 108.44,84.06 108.44,84.67 108.54,84.77 110.78,84.77
GND on TOP (solid shape): 96.29,80.9 96.29,78.54 95.94,78.19 93.45,78.19 93.21,78.44 93.21,78.46 93.15,79.75 92.7,80.96 92.7,81.06 92.78,81.11 96.07,81.11
GND on TOP (solid shape): 231.2,29.8 231.73,29.58 231.95,29.05 231.95,26.29 232.34,25.9 232.34,20.04 232.13,19.82 231.49,19.82 231.28,20.03 231.28,26.19 230.92,26.56 229.83,26.56 229.66,26.72 229.66,28.83 229.46,29.03 229.46,29.8
GND on TOP (solid shape): 167.95,68.54 168.84,68.54 169.86,67.53 171.36,67.53 171.66,67.22 173.11,67.22 173.26,67.37 173.26,68.14 173.31,68.19 173.39,68.19 173.46,68.11 173.46,67.37 173.62,67.22 175.11,67.22 175.7,66.64 177.73,66.64 177.86,66.51 177.86,65.75 177.6,65.49 175.95,65.49 175.14,66.31 172.09,66.31 171.79,66 171.38,66 171,65.62 170.34,65.62 170.01,65.29 169.78,65.29 168.56,66.51 167.44,66.51 167.19,66.76 167.19,67.4 166.94,67.65 166.94,68.67 167.06,68.8 167.7,68.8
GND on TOP (solid shape): 155.25,64.55 155.25,60.76 155.58,60.43 156.33,60.43 156.65,60.74 156.65,61.18 156.9,61.43 157.16,61.43 157.41,61.18 157.41,59.91 157.27,59.77 154.76,59.77 154.49,60.03 154.49,63.9 154.51,63.92 154.62,64.12 154.51,64.33 154.49,64.34 154.49,64.45 154.51,64.47 154.56,64.53 154.59,64.6 154.64,64.66 155.15,64.66
GND on TOP (solid shape): 59.62,53.52 59.62,52.29 59.87,52.03 60.01,52.03 60.01,51.5 60.08,51.44 60.55,51.26 60.4,51.74 60.39,51.75 60.39,52.03 62.92,52.03 63.05,51.9 63.05,51.02 62.85,50.81 59.44,50.81 59.44,50.81 58.61,50.81 58.4,51.03 58.4,52.34 58.73,52.67 58.73,53.33 58.97,53.57 59.57,53.57
GND on TOP (solid shape): 26.2,82.4 26.2,81.73 25.92,81.45 25.92,79.92 25.79,79.8 24.85,79.8 24.34,79.69 24.78,79.42 24.98,79.42 25.2,79.2 25.2,78.96 25.46,78.7 25.84,78.7 25.97,78.57 25.97,78.07 25.84,77.94 21.15,77.94 20.99,78.1 20.99,79.32 21.42,79.76 21.42,81.78 21.62,81.98 22.03,81.98 22.69,82.64 25.97,82.64
GND on TOP (solid shape): 71.84,71.56 72.45,71.56 72.5,71.51 72.5,71.04 72.49,71.02 72.35,70.88 71.66,70.88 71.56,70.78 71.56,70.51 71.42,70.37 71.39,70.37 71.13,70.1 71.44,69.87 71.52,69.85 71.56,69.77 71.56,69.51 71.67,69.4 71.67,69.39 71.72,69.31 71.8,69.26 71.81,69.26 72.52,68.54 72.52,68.14 72.37,67.98 72.19,67.98 71.89,68.29 60.64,68.29 60.38,68.54 60.38,71.84 60.64,72.1 71.3,72.1
GND on TOP (solid shape): 118.33,50.71 118.32,50.18 118.66,50.58 118.84,50.76 119.44,50.76 119.65,50.55 119.65,50.03 119.98,50.44 119.98,50.51 120.48,50.51 121.55,49.44 121.55,48.65 122.14,48.06 122.14,47.89 121.93,47.68 118.12,47.68 117.91,47.88 117.91,50.63 118.04,50.76 118.38,50.76
GND on TOP (solid shape): 212.19,55.68 212.45,55.68 212.66,55.47 212.66,54.55 212.65,54.54 212.63,54.43 212.65,54.33 212.66,54.32 212.66,54.09 212.65,54.08 212.6,53.93 212.65,53.79 212.66,53.77 212.66,53.59 212.65,53.58 212.6,53.43 212.65,53.29 212.66,53.27 212.66,53.05 212.65,53.04 212.63,52.93 212.65,52.83 212.55,52.73 211.77,52.73 211.65,52.85 211.66,52.98 211.6,53.09 211.57,53.17 211.69,53.42 211.62,53.61 211.59,53.68 211.62,53.75 211.69,53.94 211.57,54.2 211.6,54.27 211.65,54.52 211.44,54.66 211.3,54.66 211.13,54.83 211.13,55.71 211.26,55.84 212.02,55.84
GND on TOP (solid shape): outline of 121 points within 150.02,31.08 170.49,34.89
GND on TOP (solid shape): 225.23,70.48 225.3,70.39 225.3,68.06 224.81,67.22 225.55,66.6 230.75,66.6 231.28,66.38 231.5,65.85 231.5,63.4 231.27,62.87 230.73,62.65 229.59,62.65 229.59,63.42 230.73,63.42 230.73,65.83 227.65,65.83 227.55,66.04 227.4,66.22 226,66.22 225.85,66.04 225.75,65.83 225.55,65.83 224.14,66.81 224.53,68.48 224.53,70.22 224.55,70.25 224.59,70.27 224.71,70.27 224.93,70.32 225.12,70.45
GND on TOP (solid shape): 221.68,63.8 222.9,63.77 226.14,63.77 226.5,63.42 226.5,62.65 222.96,62.65 222.12,63.14 221.5,62.4 221.5,48.8 222.12,48.06 222.96,48.55 226.79,48.55 226.79,47.78 226.79,47.78 226.23,47.23 222.13,47.23 222.06,47.3 221.28,47.63 220.81,48.34 221.12,49.17 220.84,50.02 220.54,50.02 220.41,50.15 220.41,50.52 220.76,50.87 221.27,51.61 220.73,52.34 220.73,52.86 221.28,53.6 220.73,54.34 220.73,54.88 221.25,55.6 220.73,56.32 220.73,56.86 221.28,57.6 220.73,58.34 220.73,58.86 221.28,59.6 220.73,60.34 220.73,60.98 221.17,61.93 220.83,62.92
GND on TOP (solid shape): 197.8,83.55 198.15,82.7 199,82.35 202.5,82.35 203.06,82.11 203.3,81.55 203.3,80.05 203.65,79.2 204.5,78.85 213.06,78.85 213.83,79.11 214.26,79.81 217,82.05 219.74,79.81 220.16,79.12 220.92,78.85 230.75,78.85 231.31,78.61 231.55,78.05 231.55,76.8 231.5,76.8 231.5,76.75 231.28,76.22 230.75,76 225.55,76 224.81,75.38 225.3,74.54 225.3,72.21 225.23,72.12 225.12,72.15 224.93,72.28 224.71,72.33 224.59,72.33 224.55,72.35 224.53,72.38 224.53,74.12 224.14,75.79 225.55,76.77 225.77,76.77 225.87,76.56 226.02,76.38 227.38,76.38 227.53,76.56 227.63,76.77 230.73,76.77 230.73,78.03 227.03,78.03 226.7,78.09 226.37,78.03 221.14,78.03 219.96,76.86 214.72,76.86 213.5,78.08 213.28,78.04 213.06,78.03 204.5,78.03 203.07,78.62 202.48,80.05 202.48,81.53 199,81.53 197.57,82.12 196.98,83.55 196.98,85.29 197.8,85.29
GND on TOP (solid shape): outline of 2095 points within 0.2,0.2 230.86,89.65
GND on BOTTOM (solid shape): 37.71,23.27 37.71,20.41 37.41,20.11 35.84,20.11 35.61,20.34 35.61,23.45 35.74,23.59 37.39,23.59
GND on BOTTOM (solid shape): 71.05,72.35 71.05,68.67 70.54,68.16 61.14,68.16 60.51,68.8 60.51,71.84 61.27,72.61 70.8,72.61
GND on BOTTOM (solid shape): 211.51,72.61 211.51,71.72 211.13,71.34 207.81,71.34 207.62,71.53 207.62,72.91 207.69,72.99 211.13,72.99
GND on BOTTOM (solid shape): 63.79,20.87 63.79,19.37 63.18,18.76 61.12,18.76 61.02,18.66 58,18.66 57.65,19 57.65,20.98 57.7,21.03 63.62,21.03
GND on BOTTOM (solid shape): 95.56,41.49 95.56,40.09 95.18,39.71 92.77,39.71 92.13,39.08 91.37,39.08 91.12,39.33 91.12,41.24 91.75,41.87 95.18,41.87
GND on BOTTOM (solid shape): 161.2,41.44 162.72,41.44 162.85,41.31 162.85,40.45 162.74,40.35 159.65,40.35 159.57,40.42 159.57,41.74 159.82,42 160.64,42
GND on BOTTOM (solid shape): 185.57,69.52 185.57,66.9 185.43,66.76 182.94,66.76 182.79,66.92 182.79,70.6 182.91,70.73 184.36,70.73
GND on BOTTOM (solid shape): 27.69,44.98 27.69,44.27 27.64,44.23 24.37,44.23 24.16,44.44 24.16,45.03 24.78,45.66 27.01,45.66
GND on BOTTOM (solid shape): 49.55,65.84 49.55,63.72 49.29,63.46 47.32,63.46 46.46,64.32 42.36,64.32 42.19,64.49 42.19,65.81 42.52,66.14 49.25,66.14
GND on BOTTOM (solid shape): 63.43,53.17 63.43,52.67 62.54,51.78 59.49,51.78 59.11,51.4 58.86,51.4 58.6,51.65 58.6,53.2 58.69,53.29 59.48,53.29 59.49,53.3 63.3,53.3
GND on BOTTOM (solid shape): 105.47,41.74 105.72,41.74 105.98,41.49 105.98,37.61 105.6,37.24 98.29,37.24 96.02,39.51 96.02,41.67 96.22,41.87 105.34,41.87
GND on BOTTOM (solid shape): 38.79,82.77 38.79,82.09 38.72,82.02 38.72,80.45 38.79,80.38 38.79,77.43 38.54,77.18 31.05,77.18 30.41,77.81 30.41,80.61 31,81.19 31,82.72 31.17,82.89 38.67,82.89
GND on BOTTOM (solid shape): 118.9,24.68 118.9,19.24 118.55,18.88 117.02,18.88 116.35,19.56 113.37,19.56 113.01,19.92 113.01,22.68 113.56,23.23 114.92,23.23 115.09,23.41 115.12,23.41 115.12,23.63 116.69,25.21 118.37,25.21
GND on BOTTOM (solid shape): 158.81,85.42 158.81,81.75 157.66,80.61 157.03,80.61 156.84,80.42 156.78,80.48 155.89,80.48 155.63,80.23 153.73,80.23 153.47,80.48 153.47,85.88 153.72,86.12 158.11,86.12
GND on BOTTOM (solid shape): 31.27,23.59 33.17,23.59 33.36,23.41 33.36,20.61 33.14,20.39 32.23,20.39 31.96,20.66 31.96,21.35 31.71,21.6 30.73,21.6 30.41,21.93 30.41,22.82 30.13,23.1 30.13,23.8 30.18,23.85 31.01,23.85
GND on BOTTOM (solid shape): 205.06,72.76 205.06,69.75 204.93,69.62 202.84,69.62 202.47,69.25 202.47,66.13 202.11,65.77 200.16,65.77 199.7,66.23 199.7,71.27 200.2,71.77 201.19,71.77 202.25,72.83 204.99,72.83
GND on BOTTOM (solid shape): 215.37,65.9 215.37,63.74 214.74,63.11 214.74,62.69 214.44,62.39 213.56,62.39 213.17,62.79 212.7,62.79 212.7,62.8 212.24,62.8 211.96,63.08 211.96,64.24 212.39,64.67 212.92,64.67 213.37,65.11 213.37,65.98 213.42,66.03 215.25,66.03
GND on BOTTOM (solid shape): 105.57,51.88 105.57,48.96 104.32,47.71 104.32,46.82 104.2,46.7 103.26,46.7 102.72,47.23 102.72,48.73 102.85,48.86 103.64,48.86 103.79,49.01 103.79,51.9 103.82,51.93 105.52,51.93
GND on BOTTOM (solid shape): 170.23,85.79 170.23,84.19 169.6,83.57 169.6,80.48 169.22,80.1 168.08,80.1 167.82,80.35 167.82,82.64 167.57,82.89 164.27,82.89 164.14,83.02 164.14,85.19 164.5,85.55 167.75,85.55 168.02,85.81 168.02,85.83 168.35,86.16 169.87,86.16
GND on BOTTOM (solid shape): 149.51,38.57 149.51,36.28 149.66,36.13 149.66,35.06 149.61,35.01 149.49,35.01 149.38,35.12 149.38,36.11 149.18,36.31 147.02,36.31 146.9,36.18 145.88,36.18 145.8,36.26 145.8,36.36 145.9,36.46 146.92,36.46 147.12,36.66 147.12,38.57 147.25,38.7 149.38,38.7
GND on BOTTOM (solid shape): 195.79,57.34 195.79,56.53 195.64,56.38 195.64,55.77 195.21,55.33 192.84,55.33 192.72,55.46 191.42,55.46 191.24,55.64 191.24,56.96 191.37,57.09 192.87,57.09 193.46,56.49 194.91,56.49 195.1,56.69 195.1,57.32 195.21,57.42 195.71,57.42
GND on BOTTOM (solid shape): 89.97,66.76 89.97,66.13 90.01,66.09 90.01,66.08 90.1,65.93 90.26,65.84 90.26,64.51 90.1,64.35 87.69,64.35 87.43,64.6 87.43,65.75 87.69,66 87.69,66.46 88.14,66.91 89.83,66.91
GND on BOTTOM (solid shape): 49.64,54.71 49.64,53.62 49.58,53.56 49.58,51.77 49,51.19 49,48.58 49.41,48.17 50.17,48.17 50.6,47.74 50.6,46.95 50.48,46.82 40.57,46.82 40.44,46.7 32.06,46.7 31.91,46.85 31.91,48.49 32.4,48.98 34.28,48.98 35.34,50.04 35.34,52.12 35.76,52.54 39.17,52.54 41.83,55.19 49.16,55.19
GND on BOTTOM (solid shape): 96.45,80.73 96.45,78.7 95.94,78.19 93.22,78.19 93.14,78.23 93.12,78.31 93.1,79.65 92.65,80.9 92.64,80.92 92.64,81.24 92.77,81.37 95.82,81.37
GND on BOTTOM (solid shape): 41.96,74.89 45.78,74.89 46.03,75.15 49.28,75.15 49.59,74.84 49.59,73.75 49.46,73.62 46.04,73.62 45.47,73.05 41.91,73.05 41.08,72.22 41.08,70.71 40.94,70.57 39.17,70.57 37.27,68.67 33.59,68.67 33.33,68.92 33.33,71.08 33.46,71.21 38.03,71.21 38.16,71.34 38.16,73.37 38.41,73.62 39.17,73.62 39.71,74.16 39.71,75.26 40.06,75.61 41.25,75.61
GND on BOTTOM (solid shape): 64.57,52.03 64.57,47.97 64.95,47.59 64.95,45.68 64.83,45.55 61.27,45.55 60.51,44.79 57.84,44.79 57.59,45.05 57.59,45.81 57.84,46.06 58.1,46.06 58.35,46.32 60.89,46.32 61.42,46.85 62.52,46.85 62.68,47.02 62.68,47.79 62.46,48.02 61.53,48.02 61.3,48.25 61.3,48.7 61.5,48.91 62.31,48.91 62.68,49.28 62.68,50.06 62.36,50.38 59.75,50.38 59.24,50.89 59.24,51.27 59.49,51.52 62.54,51.52 63.3,52.29 64.32,52.29
GND on BOTTOM (solid shape): 53.03,68.33 53.84,68.33 53.95,68.23 59.36,68.23 59.53,68.05 59.53,67.64 59.43,67.54 58.64,67.54 58.5,67.68 58.22,67.68 58.09,67.54 56.99,67.54 56.89,67.44 56.89,66.96 56.82,66.88 56.64,66.88 56.49,67.03 56.49,67.25 56.19,67.54 56.05,67.54 55.92,67.68 55.61,67.68 55.5,67.57 54.66,67.57 54.65,67.58 53.82,67.58 53.65,67.75 53.36,67.75 53.26,67.64 53.06,67.64 52.32,68.38 52.32,68.56 52.37,68.61 52.75,68.61
GND on BOTTOM (solid shape): 188.44,72.49 188.77,72.21 189.15,72.43 191.14,72.43 191.55,72.01 192.3,72.01 192.36,71.95 192.36,71.51 192.34,71.49 191.82,71.49 191.81,71.48 191.81,70.73 192.31,70.73 192.35,70.69 192.35,70.34 192.31,70.3 191.85,70.3 191.81,70.26 191.81,69.53 192.35,69.53 192.36,69.52 192.36,68.94 192.16,68.74 189.82,68.74 189.81,68.76 187.62,68.76 187.29,69.09 187.29,72.09 187.7,72.49
GND on BOTTOM (solid shape): 180.5,61.05 183.7,61.05 184.72,60.03 187.92,60.03 188.02,59.93 188.02,58.73 187.99,58.65 187.91,58.62 187.76,58.6 187.63,58.52 187.56,58.49 187.49,58.52 187.05,58.58 186.86,58.17 186.82,58.14 186.77,58.13 185.02,58.13 184.69,57.8 183.14,57.8 182.96,57.62 177.98,57.62 177.73,57.87 177.73,60.67 178.54,61.48 180.07,61.48
GND on BOTTOM (solid shape): outline of 95 points within 78.42,44.53 89.36,52.67
GND on BOTTOM (solid shape): 180.37,83.85 180.37,79.11 180.3,79.03 180.17,79.03 180.09,79.11 180.09,80.33 179.08,81.34 178.67,81.34 178.52,81.19 178.52,80.63 178.39,80.51 178.39,79.08 178.32,79.01 177.68,79.01 177.6,79.08 177.6,80.45 177.48,80.58 177.48,80.62 177.49,80.63 177.55,80.72 177.58,80.81 177.79,81.29 177.33,81.54 177.26,81.55 177.21,81.6 176.55,81.74 176.8,81.12 176.88,81.07 176.89,80.98 176.87,80.86 176.89,80.74 176.87,80.65 176.79,80.61 175.57,80.61 175.19,80.23 172.52,80.23 172.4,80.35 172.4,83.02 172.63,83.25 174.28,83.25 175.28,84.25 179.97,84.25
GND on BOTTOM (solid shape): 225.23,70.48 225.3,70.39 225.3,68.06 224.81,67.22 225.55,66.6 230.75,66.6 231.28,66.38 231.5,65.85 231.5,63.4 231.27,62.87 230.73,62.65 229.59,62.65 229.59,63.42 230.73,63.42 230.73,65.83 227.65,65.83 227.55,66.04 227.4,66.22 226,66.22 225.85,66.04 225.75,65.83 225.55,65.83 224.14,66.81 224.53,68.48 224.53,70.22 224.55,70.25 224.59,70.27 224.71,70.27 224.93,70.32 225.12,70.45
GND on BOTTOM (solid shape): 221.73,63.82 222.99,63.72 226.19,63.72 226.5,63.42 226.5,62.65 222.96,62.65 222.12,63.14 221.5,62.4 221.5,48.8 222.12,48.06 222.96,48.55 226.79,48.55 226.79,47.78 226.51,47.5 223.03,47.5 221.72,47.38 220.81,48.34 221.11,49.16 220.85,50 220.83,50.03 220.48,50.03 220.36,50.15 220.36,50.53 220.37,50.54 220.37,50.65 220.51,50.79 220.7,50.79 220.78,50.88 221.28,51.63 220.73,52.34 220.73,52.86 221.28,53.6 220.73,54.34 220.73,54.85 221.27,55.6 220.73,56.36 220.73,56.86 221.28,57.6 220.73,58.34 220.73,58.86 221.28,59.6 220.73,60.34 220.73,60.98 221.17,61.93 220.83,62.92
GND on BOTTOM (solid shape): outline of 2252 points within 0.25,0.25 233.25,89.65
GND on GND1 (solid shape): outline of 98869 points within 0.51,0.51 232.99,89.34
GND on IN1 (solid shape): 71.05,71.72 71.05,70.83 70.67,70.45 70.67,69.3 69.53,68.16 61.14,68.16 60.51,68.8 60.51,71.84 60.76,72.1 70.67,72.1
GND on IN1 (solid shape): 26.35,70.07 26.35,66 26.22,65.87 24.57,65.87 24.06,65.37 23.3,65.37 23.17,65.49 23.17,68.67 23.43,68.92 24.82,68.92 25.08,69.18 25.08,70.07 25.2,70.19 26.22,70.19
GND on IN1 (solid shape): 225.23,70.48 225.3,70.39 225.3,68.06 224.81,67.22 225.55,66.6 230.75,66.6 231.28,66.38 231.5,65.85 231.5,63.4 231.27,62.87 230.73,62.65 229.59,62.65 229.59,63.42 230.73,63.42 230.73,65.83 227.65,65.83 227.55,66.04 227.4,66.22 226,66.22 225.85,66.04 225.75,65.83 225.55,65.83 224.14,66.81 224.53,68.48 224.53,70.22 224.55,70.25 224.59,70.27 224.71,70.27 224.93,70.32 225.12,70.45
GND on IN1 (solid shape): 221.74,63.83 223.02,63.7 226.21,63.7 226.5,63.42 226.5,62.65 222.96,62.65 222.12,63.14 221.5,62.4 221.5,48.8 222.12,48.06 222.96,48.55 226.79,48.55 226.79,47.78 226.41,47.4 222.83,47.4 221.61,47.42 220.81,48.34 221.11,49.16 220.86,50 220.83,50.02 220.48,50.02 220.34,50.16 220.34,50.56 220.73,50.95 220.77,50.97 221.17,51.45 221.01,52.06 221.01,52.74 220.85,52.9 221.04,53.08 221.04,53.18 221.05,53.19 221.16,53.79 220.76,54.24 220.73,54.25 220.73,54.98 221.16,55.6 220.73,56.22 220.73,56.95 220.76,56.96 221.06,57.21 221.19,57.58 221.14,57.84 221,58.07 221,58.86 220.93,58.92 220.9,59 220.94,59.07 221.18,59.5 221.07,59.98 220.93,60.13 220.76,60.24 220.73,60.25 220.73,60.98 221.17,61.93 220.83,62.92
GND on IN1 (solid shape): outline of 2586 points within 0.25,0.25 233.25,89.65
GND on GND2 (solid shape): outline of 108219 points within 0.51,0.51 232.99,89.34
GND on IN2 (solid shape): 26.35,70.07 26.35,66 26.22,65.87 24.57,65.87 24.06,65.37 23.3,65.37 23.17,65.49 23.17,68.67 23.43,68.92 24.82,68.92 25.08,69.18 25.08,70.07 25.2,70.19 26.22,70.19
GND on IN2 (solid shape): 225.23,70.48 225.3,70.39 225.3,68.06 224.81,67.22 225.55,66.6 230.75,66.6 231.28,66.38 231.5,65.85 231.5,63.4 231.27,62.87 230.73,62.65 229.59,62.65 229.59,63.42 230.73,63.42 230.73,65.83 227.65,65.83 227.55,66.04 227.4,66.22 226,66.22 225.85,66.04 225.75,65.83 225.55,65.83 224.14,66.81 224.53,68.48 224.53,70.22 224.55,70.25 224.59,70.27 224.71,70.27 224.93,70.32 225.12,70.45
GND on IN2 (solid shape): 221.72,63.82 222.98,63.73 226.18,63.73 226.5,63.42 226.5,62.65 222.96,62.65 222.12,63.14 221.5,62.4 221.5,48.8 222.12,48.06 222.96,48.55 226.79,48.55 226.79,47.78 226.46,47.45 222.95,47.45 221.67,47.4 220.81,48.34 221.11,49.09 220.93,49.88 220.8,50.01 220.51,50.01 220.34,50.18 220.34,50.56 220.73,50.95 220.77,50.97 221.19,51.6 220.77,52.23 220.73,52.25 220.73,52.95 220.77,52.97 221.19,53.6 220.77,54.23 220.73,54.25 220.73,54.98 221.16,55.6 220.73,56.22 220.73,56.95 220.77,56.97 221.19,57.6 220.77,58.23 220.73,58.25 220.73,58.95 220.77,58.97 221.19,59.6 220.77,60.23 220.73,60.25 220.73,60.98 221.17,61.93 220.83,62.92
GND on IN2 (solid shape): outline of 2292 points within 0.25,0.25 233.25,89.65
GND on GND3 (solid shape): outline of 108357 points within 0.51,0.51 232.99,89.34
GND on VCC (solid shape): outline of 1867 points within 16.52,74.23 31,87.02
GND on VCC (solid shape): outline of 3167 points within 181.16,51.18 231.24,81.23
GND on VCC (solid shape): outline of 39169 points within 18.6,0.51 232.99,68.29
GND on IN3 (solid shape): 71.05,71.97 71.05,68.67 70.54,68.16 61.14,68.16 60.51,68.8 60.51,71.84 60.89,72.22 70.8,72.22
GND on IN3 (solid shape): 225.23,70.48 225.3,70.39 225.3,68.06 224.81,67.22 225.55,66.6 230.75,66.6 231.28,66.38 231.5,65.85 231.5,63.4 231.27,62.87 230.73,62.65 229.59,62.65 229.59,63.42 230.73,63.42 230.73,65.83 227.65,65.83 227.55,66.04 227.4,66.22 226,66.22 225.85,66.04 225.75,65.83 225.55,65.83 224.14,66.81 224.53,68.48 224.53,70.22 224.55,70.25 224.59,70.27 224.71,70.27 224.93,70.32 225.12,70.45
GND on IN3 (solid shape): 221.63,63.78 222.81,63.81 226.1,63.81 226.5,63.42 226.5,62.65 222.96,62.65 222.12,63.14 221.5,62.4 221.5,48.8 222.12,48.06 222.96,48.55 226.79,48.55 226.79,47.78 226.79,47.78 226.48,47.47 222.98,47.47 221.69,47.39 220.81,48.34 221.11,49.17 220.85,50.01 220.52,50.01 220.35,50.18 220.35,50.57 220.73,50.95 220.77,50.97 221.19,51.6 220.77,52.23 220.73,52.25 220.73,52.95 220.77,52.97 221.19,53.6 220.77,54.23 220.73,54.25 220.73,54.98 221.16,55.6 220.73,56.22 220.73,56.95 220.77,56.97 221.19,57.6 220.77,58.23 220.73,58.25 220.73,58.95 220.77,58.97 221.19,59.6 220.77,60.23 220.73,60.25 220.73,60.98 221.17,61.93 220.83,62.92
GND on IN3 (solid shape): outline of 4523 points within 0.25,0.25 233.25,89.65
GND on GND4 (solid shape): outline of 108430 points within 0.51,0.51 232.99,89.34
GND on IN4 (solid shape): 71.05,72.35 71.05,68.67 70.54,68.16 61.14,68.16 60.51,68.8 60.51,71.84 60.51,71.85 60.51,71.98 61.14,72.61 70.8,72.61
GND on IN4 (solid shape): 26.35,70.07 26.35,66 26.22,65.87 24.57,65.87 24.06,65.37 23.3,65.37 23.17,65.49 23.17,68.67 23.43,68.92 24.82,68.92 25.08,69.18 25.08,70.07 25.2,70.19 26.22,70.19
GND on IN4 (solid shape): 225.23,70.48 225.3,70.39 225.3,68.06 224.81,67.22 225.55,66.6 230.75,66.6 231.28,66.38 231.5,65.85 231.5,63.4 231.27,62.87 230.73,62.65 229.59,62.65 229.59,63.42 230.73,63.42 230.73,65.83 227.65,65.83 227.55,66.04 227.4,66.22 226,66.22 225.85,66.04 225.75,65.83 225.55,65.83 224.14,66.81 224.53,68.48 224.53,70.22 224.55,70.25 224.59,70.27 224.71,70.27 224.93,70.32 225.12,70.45
GND on IN4 (solid shape): 221.69,63.81 222.93,63.75 226.16,63.75 226.5,63.42 226.5,62.65 222.96,62.65 222.12,63.14 221.5,62.4 221.5,48.8 222.12,48.06 222.96,48.55 226.79,48.55 226.79,47.78 226.78,47.78 226.48,47.49 223.01,47.49 221.7,47.39 220.81,48.34 221.12,49.19 220.83,50.04 220.49,50.04 220.38,50.14 220.38,50.6 220.73,50.95 220.77,50.97 221.19,51.6 220.77,52.23 220.73,52.25 220.73,52.95 220.77,52.97 221.19,53.6 220.77,54.23 220.73,54.25 220.73,54.98 221.16,55.6 220.73,56.22 220.73,56.95 220.77,56.97 221.19,57.6 220.77,58.23 220.73,58.25 220.73,58.95 220.77,58.97 221.19,59.6 220.77,60.23 220.73,60.25 220.73,60.98 221.17,61.93 220.83,62.92
GND on IN4 (solid shape): outline of 479 points within 0.25,0.25 233.25,89.65
GND on GND5 (solid shape): outline of 106023 points within 0.51,0.51 232.99,89.34
VIN on TOP (solid shape): 164.83,42.61 164.83,39.69 163.94,38.8 161.88,38.8 161.6,39.08 161.6,42.15 161.86,42.41 162.72,42.41 163.3,42.99 164.45,42.99
VIN on BOTTOM (solid shape): 186.28,77.28 186.28,74.76 186.75,74.29 186.75,70.83 186.5,70.58 184.98,70.58 184.6,70.95 182.81,70.95 182.63,71.13 182.63,72.33 185.97,72.33 185.98,72.27 185.99,72.22 186.01,72.16 186.04,72.12 186.07,72.07 186.11,72.03 186.16,72 186.2,71.97 186.26,71.96 186.31,71.95 186.37,71.94 186.42,71.95 186.48,71.96 186.53,71.99 186.58,72.02 186.62,72.05 186.66,72.09 186.69,72.14 186.71,72.19 186.73,72.24 186.74,72.3 186.74,72.35 186.73,72.41 186.71,72.46 186.69,72.51 186.66,72.56 186.62,72.6 186.58,72.64 186.53,72.67 186.48,72.69 186.42,72.7 186.37,72.71 186.31,72.71 186.26,72.7 186.2,72.68 186.16,72.65 186.11,72.62 186.07,72.58 186.04,72.54 186.01,72.49 185.99,72.44 185.98,72.38 185.97,72.33 182.63,72.33 182.63,72.64 183,73.01 183,74.46 183.88,75.33 183.88,76.57 184.84,77.53 185.25,77.53 185.39,77.67 185.88,77.67
VIN on IN3 (solid shape): outline of 3696 points within 160.97,27.14 189.92,73.49
+INV_PWR_SRC on TOP (solid shape): outline of 87 points within 158.43,79.21 167.57,82.51
+INV_PWR_SRC on BOTTOM (solid shape): 160.28,80.94 160.28,80.58 160.18,80.48 159.49,80.48 159.39,80.38 159.39,79.08 159.34,79.03 158.68,79.03 158.6,79.11 158.6,80.3 158.45,80.45 158.45,80.89 158.66,81.09 160.13,81.09
+LCDVDD on TOP (solid shape): 177.86,69.79 177.86,67.3 177.56,67 175.71,67 175.34,67.37 174.12,67.37 174,67.5 174,68.62 174.17,68.8 174.81,68.8 176.21,70.19 177.45,70.19
+LCDVDD on TOP (solid shape): 180.58,78.93 180.58,77.61 180.5,77.53 179.9,77.53 179.61,77.66 179.33,77.53 178.77,77.53 178.7,77.61 178.7,78.24 178.59,78.35 178.32,78.35 178.12,78.54 178.12,78.92 178.24,79.03 180.47,79.03
+LCDVDD on BOTTOM (solid shape): 179.89,80.28 179.89,79.08 180.09,78.88 180.3,78.88 180.52,78.65 180.52,78.41 180.49,78.41 180.23,78.14 178.19,78.14 178.04,78.3 178.04,78.52 178.34,78.83 178.9,78.83 179.1,79.03 179.1,80.3 179.18,80.38 179.79,80.38
+LCDVDD on IN3 (solid shape): outline of 359 points within 173.79,67.14 180.68,79.49
+V_SM_VREF on BOTTOM (solid shape): 57.59,51.27 57.59,50 57.33,49.75 56.45,49.75 56.19,49.49 56.19,46.44 56.06,46.32 55.68,46.32 55.3,46.7 54.67,46.7 54.41,46.95 54.41,51.02 54.54,51.14 55.3,51.14 55.81,51.65 57.21,51.65
+VSBP on TOP (solid shape): outline of 103 points within 176.26,79.87 180.4,82.16
ADET on BOTTOM (solid shape): 145.37,41.44 148.09,41.44 148.19,41.34 148.19,41.03 148.01,40.86 148.01,38.95 147.99,38.93 147.84,38.93 147.81,38.95 147.81,40.18 147.7,40.3 147.7,40.51 147.45,40.75 147.07,40.75 146.92,40.6 146.29,40.6 145.7,40.02 144.91,40.02 144.84,39.95 143.68,39.95 143.47,40.15 143.47,41.8 143.75,42.08 144.74,42.08
ADPIN on BOTTOM (solid shape): 191.09,82.31 193.18,82.31 193.4,82.1 193.4,80.65 193.02,80.27 190.79,80.27 190.56,80.04 190.56,77.53 190.56,73.72 189.69,73.72 189.44,73.81 189.19,73.72 188.76,73.72 188.49,73.99 188.59,74.6 187.98,74.5 187.76,74.71 187.76,75.89 187.79,75.94 187.81,75.95 188.02,76.29 187.81,76.63 187.79,76.64 187.76,76.68 187.76,79.31 188.55,80.1 188.55,82.44 188.87,82.76 190.65,82.76
AGATE on BOTTOM (solid shape): 147.23,39.84 147.23,38.95 147.17,38.9 147.05,38.9 146.87,39.08 146.57,39.08 146.37,39.27 146.37,40.28 146.46,40.37 146.69,40.37
B+ on TOP (solid shape): 173.32,84.4 179.01,84.4 179.51,83.91 179.51,82.33 179.18,82 178.77,82 177.88,82.89 172.7,82.89 172.27,83.32 172.27,84.29 172.55,84.57 173.16,84.57
B+ on TOP (solid shape): 115.5,41.03 115.5,40.14 115.68,39.97 117.61,39.97 117.63,39.94 118.24,39.94 118.45,39.74 118.45,38.39 118.35,38.3 114.49,38.3 114.29,38.49 114.29,40.96 114.43,41.11 115.42,41.11
B+ on TOP (solid shape): 25.23,55.65 29.05,55.65 29.75,54.95 29.75,51.05 29.38,50.69 19.37,50.69 18.99,51.07 18.49,51.07 17.74,51.83 17.74,55.41 17.84,55.51 21.01,55.51 21.52,56.02 24.87,56.02
B+ on TOP (solid shape): 162.62,83.78 162.62,82.77 162.57,82.76 162.45,82.73 162.35,82.65 162.33,82.64 160.97,82.64 160.84,82.77 159.32,82.77 159.06,82.51 159.06,81.5 158.81,81.24 157.79,81.24 157.66,81.37 157.66,83.65 157.92,83.91 162.49,83.91
B+ on TOP (solid shape): 130.99,34.79 131.12,34.66 131.12,32.35 130.99,32.22 129.47,32.22 129.22,32.47 129.22,33.67 128.66,34.23 128.66,34.76 130.06,34.76 130.41,35.12 130.06,35.47 128.66,35.47 128.66,35.9 128.91,36.16 130.99,36.16
B+ on TOP (solid shape): outline of 198 points within 195.46,68.9 205.09,74.97
B+ on BOTTOM (solid shape): 45.04,22.52 45.04,20 44.86,19.82 41.92,19.82 41.9,19.84 41.47,19.84 41.13,20.18 41.13,22.24 41.59,22.69 44.86,22.69
B+ on BOTTOM (solid shape): 198.91,73.8 198.91,70.09 198.58,69.76 196.08,69.76 195.31,70.54 195.31,74.08 195.69,74.46 196.88,74.46 197.38,74.96 197.76,74.96
B+ on BOTTOM (solid shape): outline of 1948 points within 129.26,32.83 152.32,76.54
B+ on IN1 (solid shape): 115.56,41 117.82,41 118.18,40.64 118.18,38.31 117.78,37.92 114.47,37.92 113.92,38.47 113.92,39.92 113.92,40.6 114.51,41.19 115.37,41.19
B+ on IN1 (solid shape): 135.31,46.06 135.31,43.65 135.06,43.4 131.71,43.4 130.61,42.3 128.28,42.3 127.95,42.63 127.95,45.05 129.34,46.44 134.93,46.44
B+ on VCC (solid shape): outline of 18321 points within 7.4,18.57 203.21,88.83
B+ on IN3 (solid shape): outline of 15507 points within 8.34,18.67 200.72,86.8
B++ on TOP (solid shape): 192.84,54.98 192.84,54.11 192.64,53.91 191.5,53.91 191.4,54.01 191.4,54.32 191.52,54.44 192.13,54.44 192.72,55.03 192.79,55.03
B++ on TOP (solid shape): 199.27,68.46 199.27,65.54 198.84,65.11 198.84,63.44 199.4,62.88 199.4,60.62 198.89,60.11 196.45,60.11 196.12,59.77 195.5,59.77 195.38,59.9 195.38,60.44 195.26,60.57 194.77,60.57 194.77,60.57 194.45,60.57 194.39,60.62 194.39,63.06 195.26,63.92 195.26,65.06 195.41,65.21 195.41,68.49 195.54,68.62 199.11,68.62
BATT+ on BOTTOM (solid shape): outline of 201 points within 108.29,30.31 127.07,41.77
BATT++ on BOTTOM (solid shape): outline of 679 points within 124.42,19.27 134.14,41.77
BATT++ on IN3 (solid shape): outline of 861 points within 125.91,20.41 132.9,41.87
BOOT1 on BOTTOM (solid shape): 27.01,78.37 27.77,78.37 28.23,77.91 28.23,76.31 28.18,76.26 27.31,76.26 27.24,76.34 27.24,77.51 26.14,78.6 25.66,78.6 25.58,78.68 25.58,78.83 25.64,78.88 26.5,78.88
BOOT1G on BOTTOM (solid shape): 21.57,78.8 21.57,78.63 21.27,78.32 21.27,75.15 20.89,74.76 20.23,74.76 20.07,74.92 20.07,76.87 20.58,77.38 20.58,77.85 20.58,77.86 20.61,77.99 20.58,78.12 20.58,78.13 20.58,78.8 20.63,78.85 21.52,78.85
BST_+V1.05S_VCCPP on TOP (solid shape): 128.48,44.89 128.48,43.7 128.4,43.62 127.52,43.62 127.46,43.68 127.46,44.06 126.98,44.54 126.93,44.54 126.09,44.54 125.99,44.64 125.99,45.33 126.07,45.4 127.97,45.4
CPU_B+ on TOP (solid shape): outline of 211 points within 25.29,55.24 35.85,69.35
DCIN_GND on BOTTOM (solid shape): 193.85,79.62 193.85,72.96 194.73,72.08 194.73,69.01 194.28,68.55 192.7,68.55 192.51,68.74 192.51,72.06 192.47,72.1 192.46,72.11 192.36,72.21 191.6,72.21 190.68,73.13 190.68,73.6 190.69,73.6 190.69,77.58 190.68,77.58 190.68,79.66 190.87,79.85 193.62,79.85
DH_1.35V on TOP (solid shape): 48.85,23.95 48.85,22.21 48.75,22.11 47.91,22.11 47.71,22.31 47.71,23.49 48.31,24.09 48.71,24.09
DH_1.35V on TOP (solid shape): 34.05,21.54 34.05,20.73 33.93,20.61 33.59,20.61 33.52,20.68 33.52,21.32 33.41,21.42 32.47,21.42 32.39,21.5 32.39,21.65 32.44,21.7 33.89,21.7
DH_1.35V on IN2 (solid shape): 35.77,21.76 35.77,21.55 34.85,20.64 33.67,20.64 33.54,20.76 33.54,21.76 33.64,21.86 35.67,21.86
DH_1.35V on IN2 (solid shape): 48.91,23.19 48.91,21.26 48.55,20.89 47.81,20.89 47.63,21.07 47.63,23.28 47.76,23.41 48.7,23.41
DL_1.35V on TOP (solid shape): 55.3,20.43 55.3,18.88 55.18,18.76 53.98,18.76 53.88,18.86 53.88,20.38 54.03,20.54 55.2,20.54
DL_1.35V on TOP (solid shape): 32.49,20.84 32.49,18.81 32.39,18.71 32.11,18.71 32.02,18.8 32.02,20.89 32.07,20.94 32.39,20.94
DL_1.35V on BOTTOM (solid shape): 33.01,19.5 33.01,18.9 32.82,18.71 32.14,18.71 31.97,18.88 31.97,19.59 31.99,19.66 32,19.71 32,19.73 32.13,19.87 32.64,19.87
DL_1.35V on IN4 (solid shape): 55.28,21.04 55.28,19.14 55.02,18.88 54.26,18.88 53.96,19.19 53.96,21.35 54.13,21.53 54.79,21.53
DL_1.35V on IN4 (solid shape): outline of 102 points within 32.01,18.67 35.24,20.66
GFX_B+ on TOP (solid shape): 19.92,69.08 19.92,65.27 20.3,64.89 20.3,64.85 20.34,64.85 20.53,64.66 20.53,64 22.03,62.5 22.03,56.83 21.41,56.21 17.6,56.21 17.46,56.35 17.46,57.26 18.24,58.05 18.24,63.69 17.9,64.04 17.89,64.04 17.57,64.35 16.72,64.35 16.59,64.48 16.59,67.01 16.95,67.37 17.56,67.37 17.81,67.63 17.81,68.19 17.86,68.24 18.6,68.24 18.8,68.44 18.8,69.05 18.85,69.1 19.9,69.1
LG_3V on TOP (solid shape): 187.08,59.67 188.12,59.67 188.27,59.52 188.27,58.2 188.06,57.99 186.96,57.99 186.11,58.84 186.11,59.78 186.19,59.86 186.89,59.86
LG_3V on TOP (solid shape): 192.56,55.31 192.56,55.13 192.01,54.57 190.15,54.57 190,54.72 190,55 190.05,55.05 191.07,55.05 191.37,55.36 192.51,55.36
LG_3V on IN3 (solid shape): 188.4,58.94 188.4,57.72 188.39,57.71 188.39,56.92 188.32,56.86 187.31,56.86 186.95,57.21 186.95,58.86 187.23,59.14 188.2,59.14
LG_3V on IN3 (solid shape): 189.88,55.17 190.94,55.17 191.13,54.98 191.13,54.69 190.84,54.39 188.75,54.39 188.22,54.93 188.22,55.33 188.53,55.64 189.41,55.64
LG_5V on TOP (solid shape): 206.56,63.18 206.56,62.13 206.46,62.03 205.81,62.03 205.46,62.39 204.49,62.39 204.42,62.46 204.42,63.27 204.55,63.41 206.33,63.41
LG_5V on TOP (solid shape): 195.94,55.11 196.78,55.11 196.96,54.93 196.96,54.22 196.65,53.91 195.74,53.91 195.3,54.36 195.3,54.89 195.1,55.08 194.57,55.08 194.52,55.13 194.52,55.28 195.76,55.28
