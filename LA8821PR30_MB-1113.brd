# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18687912: length 8
  TOP w0.254: PR201.2 198.03,58.59 PC219.2 198.43,58.19 PR941.2 199.17,58.42 204.06,58.42 v1(204.27,58.64) v7(204.65,59.02)
N19240262: length 3.5
  TOP w0.122: R1003.1 153,65.02 v1(153.69,64.33)
  TOP w0.254: R1003.1 R1089.2 C1152.1
N20043972: length 2.4
  TOP w0.203: C1170.1 v1(175.42,52.29) 174.77,52.29 174.68,52.19 U655.10
N20347908: length 6.7
  TOP w0.122: Q42.1 178.56,74.32 178.19,74.69 R543.2 ; Q42.1 179.25,75.4 v1(178.9,75.76) ; Q42.1 179.25,74 179.52,73.74 180.89,73.74 181.46,73.16 Q47.2
N20611554: length 2.6
  TOP w0.203: U654.12 172.96,68.6 v1(173.35,68.99) 174.17,69.81 C1163.1
N20611582: length 4.7
  TOP w0.122: v9(176.59,70.91) 175.57,69.89 175.11,69.89 C1164.1
  TOP w0.203: C1164.1 174.32,69.1 174.1,69.1 173.76,68.76 U654.10
N21102640: length 14.5
  TOP w0.122: PR900.1 193.17,81.25 193.17,82.17 192.81,82.53 PL901.1 ; PR900.1 194.88,81.95 PQ900.1 ; PR900.1 193.67,80.5 193.28,80.1 PR903.2 192.56,79.13 v1(192.56,75.67) 192.7,75.53 193.15,75.53 193.63,76.01 PD902.2
N21241055: length 1
  TOP w0.122: 154.39,37.63 153.58,37.63 v1(153.45,37.76)
N21884322: length 15.5
  TOP w0.254: v7(100.12,52.53) 100.12,52.44 100.57,51.99 100.57,51.3 101.44,50.42 102.81,50.42 104.05,51.65 PC401.1 PR401.1
  BOTTOM w0.254: v7(100.12,52.53) 100.12,53.31 99.73,53.71 95.49,53.71 94.93,53.15 PC403.1
  vias: v1(96.62,50.84) v7(96.22,51.34) v7(96.86,51.35)
N21900089: length 1.1
  TOP w0.122: PR22.1 153.9,33.4 v1(153.73,33.57)
N21947387: length 17.5
  TOP w0.254: PR13.3 155.02,38.06 154.92,38.16 152.96,38.16 152.71,38.42 152.05,38.42 v8(151.9,38.27) ; PR14.1 v7(142.04,39.97)
  IN1 w0.254: v8(151.9,38.27) 151.95,38.27 152.41,38.72 152.41,39.13 151.92,39.61 146.41,39.61 145.6,40.43 143.98,40.43 143.27,39.72 142.29,39.72 v7(142.04,39.97)
N21952280: length 17.4
  TOP w0.122: PR15.1 142.71,37.69 v9(142.42,37.4)
  TOP w0.254: v7(142.04,39.08) PR15.1 ; PR13.2 155.02,38.82 154.74,38.54 153.12,38.54 152.86,38.8 152.03,38.8 v7(151.91,38.92)
  IN1 w0.254: v7(142.04,39.08) 142.32,39.36 143.42,39.36 144.13,40.07 145.45,40.07 146.29,39.23 151.6,39.23 v7(151.91,38.92)
N21957175: length 77.2
  TOP w0.122: v7(161.3,46.37) 161.23,46.37 160.54,45.67 156.9,45.67 156.27,45.03 154.4,45.03 v1(153.8,45.63) 152.23,45.63 151.45,44.86 151.45,44.32 150.98,43.85 150.7,43.85 150.48,43.62 150.14,43.62 149.73,43.22 149.73,42.19 150.3,41.62 150.3,40.28 151.18,39.4 151.18,37.88 152.47,36.59 PR40.1 ; PR40.1 153.36,35.19 PR49.2 ; PR40.1 152.13,36.08 v7(151.57,35.52) ; PR954.2 187.57,72.33 v7(186.35,72.33)
  IN4 w0.071: v5(169.93,70.85) 169.93,71.31 171.58,72.96 185.72,72.96 v7(186.35,72.33)
  GND5 w0.104: v6(169.6,70.55) 169.88,70.83 169.91,70.83 v5(169.93,70.85)
  BOTTOM w0.122: v6(169.6,70.55) 169.44,70.38 169.44,68.62 170.62,67.44 170.62,62.83 168,60.21 164.31,60.21 160.37,56.27 160.37,49.53 161.3,48.6 v7(161.3,46.37)
  BOTTOM w0.178: v7(151.57,35.52) 151.54,35.52 150.76,36.31 PU2.14
N23648927: length 24.7
  TOP w0.122: T219.1 116.9,61.9 v7(117.25,61.55) ; v7(131.86,58.99) 132.04,58.81 132.04,56.38 RH313.2
  IN2 w0.094: v7(131.86,58.99) 129.37,58.99 128.42,59.94 126.22,59.94 125.46,60.71 123.65,60.71 123.41,60.94 119.17,60.94 118.08,59.86 116.72,59.86 116.09,60.49 116.09,60.92 116.71,61.55 v7(117.25,61.55)
  BOTTOM w0.122: v7(117.25,61.55) 117.17,61.55 UH1.A15
N25021747:
  vias: v1(18.14,75.2)
N25021764: length 4
  TOP w0.122: v9(18.63,74.84) PC715.1
  TOP w0.508: PC715.1 18.63,72.17 18.79,72.01 PR711.2
N27967271: length 5.1
  TOP w0.254: v7(111.89,86.07) 111.7,86.07 111.45,85.82 PR603.1 111.65,85.26 PC600.1
  BOTTOM w0.122: v1(113.21,85.83) 112.39,85.83 112.15,86.07 v7(111.89,86.07)
  BOTTOM w0.254: PU600.17 110.86,85.77 111.16,86.07 v7(111.89,86.07)
N27981869: length 10.8
  TOP w0.122: 115.01,83.58 114.56,84.02 v1(114.37,84.02)
  TOP w0.254: PR611.2 PR601.2 114.79,83.36 115.01,83.58 v7(115.49,83.58)
  IN2 w0.254: v7(110.45,86.07) 110.45,85.55 113.04,82.96 114.87,82.96 v7(115.49,83.58)
  BOTTOM w0.254: PU600.16 110.36,85.99 v7(110.45,86.07)
N27995579: length 3.3
  TOP w0.254: PR609.1 110.11,79.41 110.38,79.68 v7(110.4,79.68)
  BOTTOM w0.122: v7(110.4,79.68) 110.4,79.06 v1(110.62,78.83)
  BOTTOM w0.254: v7(110.4,79.68) 110.42,79.7 110.42,80.28 110.36,80.34 PU600.3
N27996731: length 5.3
  TOP w0.254: PC616.1 111,80.45 111.06,80.4 111.06,79.97 ; PC617.2 111,79.92 111.06,79.97 ; 111.06,79.97 v7(111.06,79.74)
  BOTTOM w0.122: v1(112.17,79.69) 111.78,79.3 111.3,79.3 111.06,79.54 v7(111.06,79.74)
  BOTTOM w0.254: PU600.2 110.86,80.27 111.06,80.07 v7(111.06,79.74)
N28024997: length 3.2
  TOP w0.254: v8(109.4,79.72) 109.23,79.54 PR608.2 PR610.2
  BOTTOM w0.254: PU600.5 109.36,80.58 109.4,80.55 109.4,79.9 109.4,79.9 v8(109.4,79.72)
N28033400: length 13
  TOP w0.254: v2(106.79,78.55) 106.79,78.07 107.32,77.53 108.74,77.53 109.23,78.01 PR608.1
  GND1 w0.254: v2(106.79,78.55) v3(106.36,78.55)
  IN1 w0.254: v7(98.05,80.16) 98.05,79.85 98.23,79.67 101.72,79.67 102.84,78.55 v3(106.36,78.55)
  vias: v7(98.05,80.8) v7(98.68,80.8) v7(98.68,80.16) v7(99.32,80.8) v7(99.32,80.16) v7(99.95,80.8) v7(99.95,80.16) v7(100.59,80.8) v7(100.59,80.16) v7(101.22,80.8) v7(101.22,80.16) v9(99.32,81.57)
N28058271: length 4.2
  TOP w0.254: PC618.2 109.93,80.66 109.93,80.13 v7(109.91,80.11)
  BOTTOM w0.122: v7(109.91,80.11) 109.91,79.31 109.46,78.85 108.92,78.85 v1(108.69,78.63)
  BOTTOM w0.254: v7(109.91,80.11) 109.86,80.16 PU600.4
N28066458: length 5
  TOP w0.122: v1(181.44,65.28) 183.83,65.28 184.13,65.59 PQ1227.2 184.13,67.12 184.25,67.23 PR943.2
N28080561: length 4.3
  TOP w0.122: PQ1227.1 v1(183.48,62.8)
  TOP w0.508: PQ1227.1 185.07,64.47 PR942.2
N28083008: length 74
  TOP w0.122: PR943.1 182.85,67.75 182.61,68 182.61,69.44 182.9,69.74 184.27,69.74 184.43,69.89 184.43,70.92 184.23,71.11 184.23,71.71 184.64,72.12 184.64,72.47 185.2,73.02 186.94,73.02 v7(187.33,73.42) ; PT20.1 v2(153.17,41.43) 153.17,41.47 152.94,41.69 PR41.1
  GND1 w0.104: v2(153.17,41.43) v3(153.17,41.86)
  IN1 w0.071: v7(160.65,46.42) 160.65,44.25 159.97,43.56 153.81,43.56 153.17,42.92 v3(153.17,41.86)
  IN4 w0.071: v7(187.33,73.42) 187.1,73.19 171.3,73.19 169.26,71.15 v5(169.26,70.87)
  GND5 w0.104: v6(169.07,70.29) 169.26,70.48 v5(169.26,70.87)
  BOTTOM w0.122: v7(160.65,46.42) 160.65,48.9 160.12,49.43 160.12,56.38 164.2,60.46 167.9,60.46 170.37,62.93 170.37,67.34 169.19,68.52 169.19,70.18 v6(169.07,70.29)
N28379220: length 3.6
  TOP w0.122: T247.1 98.99,59.33 v2(98.97,59.31)
  GND1 w0.104: v3(98.81,58.89) 98.81,59.16 v2(98.97,59.31)
  IN1 w0.071: v3(98.81,58.89) 98.84,58.92 99.42,58.92 v4(99.75,58.59)
  IN4 w0.071: v5(99.6,58.05) 99.6,58.43 v4(99.75,58.59)
  GND5 w0.104: v5(99.6,58.05) 99.22,58.05 v6(99.19,58.03)
  BOTTOM w0.122: UH1.BC7 v6(99.19,58.03)
N28385936: length 3.5
  TOP w0.122: v2(56.65,76.59) 56.38,76.86 T248.1
  GND1 w0.104: v3(56.27,76.39) 56.47,76.59 v2(56.65,76.59)
  IN1 w0.071: v4(56.67,76.87) 56.27,76.47 v3(56.27,76.39)
  IN4 w0.071: v4(56.67,76.87) 57,77.2 v5(57.08,77.2)
  GND5 w0.104: v6(57.82,77.26) 57.13,77.26 v5(57.08,77.2)
  BOTTOM w0.122: v6(57.82,77.26) UCPU1.F49
N28580605: length 3.7
  TOP w0.122: v1(146.17,73.18) 146.84,72.51 R1094.1 147.12,72.16 146.68,71.71 Q334.1 146.68,71 R1106.2
N28729492: length 2.9
  TOP w0.122: U638.5 140.69,73.44 140.58,73.33 R1091.2 141.45,72.86 v1(141.61,72.7)
N29996487: length 6.4
  TOP w0.254: PR521.2 28.65,20.54 v7(29.01,20.54) 29.01,20.66 29.51,21.16 29.86,21.16 PU300.10
  BOTTOM w0.122: v1(26.35,19.22) 26.96,19.82 27.27,19.82 27.76,20.31 27.76,20.92 PR48.2
  BOTTOM w0.254: v7(29.01,20.54) 29.01,20.8 28.47,21.35 PR48.2
N30510546: length 6.4
  TOP w0.122: v1(149.03,69.79) 148.83,69.79 148.14,70.47 R1106.1 148.11,72.11 148.79,72.78 150.34,72.78 150.63,73.08 QH8.2
N31230947: length 5.5
  TOP w0.254: v7(190.95,57.42) 190.95,57.42 191.09,57.42 191.68,56.83 PU501.6
  BOTTOM w0.122: PR43.1 189.65,58.5 188.92,58.5 v1(188.34,57.91)
  BOTTOM w0.254: v7(190.95,57.42) 190.5,57.87 PR43.1 190.25,57.86 PR516.2
N31334430: length 4
  BOTTOM w0.122: QC4.2 77.18,48.09 77.15,48.11 RC107.2 RC104.2 76.71,46.34 CC217.1 77.65,46.32 v1(77.78,46.19)
N31819837: length 4.4
  TOP w0.122: RC19.1 145.09,48.35 144.39,49.05 v1(143.62,49.05) QC1.1
N31893657: length 4.9
  BOTTOM w0.122: PR955.1 154.2,37.83 v1(152.93,37.83) 152.89,37.8 151.7,37.8 151.58,37.91 PU2.10
N31894758: length 3.9
  BOTTOM w0.122: PU2.11 151.39,37.51 v1(151.53,37.36) 151.61,37.29 152.69,37.29 152.87,37.46 153.68,37.46 PR956.1
N32893408: length 3
  TOP w0.254: PR607.2 109.23,80.54 v7(108.88,80.19)
  BOTTOM w0.122: v7(108.88,80.19) 108.88,80.19 108.41,79.72 v1(107.91,79.72)
  BOTTOM w0.254: v7(108.88,80.19) 108.86,80.21 PU600.6
N32893413: length 1.9
  TOP w0.122: PR609.2 110.11,77.17 v1(110.17,77.11)
  TOP w0.254: PR609.2 PC617.1
N34016374: length 9.3
  TOP w0.122: v1(5.18,20.98) 5.29,21.09 v7(6.44,21.09)
  TOP w0.508: D81.1 8.59,21.81 8.15,21.37 6.72,21.37 v7(6.44,21.09) R886.1
  BOTTOM w0.508: JFAN1.2 7.74,23.99 6.44,22.69 v7(6.44,21.09)
N34276852: length 2.4
  TOP w0.122: CH21.1 RH86.1 121.79,78.98 122.77,78.98 v1(122.82,78.93)
N34276861: length 0.9
  BOTTOM w0.122: CH22.1 123.56,77.87 RH89.1
N34353106: length 2.1
  TOP w0.254: PC1916.1 PR961.2 127.4,28.66 127.03,29.04 PU702.3
N34353215: length 1.9
  TOP w0.254: PR959.2 124.25,28.56 125.19,28.56 125.34,28.71 PU702.1
N35014398: length 4.3
  TOP w0.122: PC718.1 v1(24.06,75.81)
  TOP w0.254: v7(23.22,76.8) 23.41,76.99 PC718.1
  BOTTOM w0.254: PU700.25 23.77,77.35 v7(23.22,76.8) 23.3,76.72 PR724.1
N35074299: length 27.2
  TOP w0.254: v8(31,85.43) PR747.2
  IN2 w0.254: v7(32.11,70.5) 31.91,70.7 31.91,72.5 31.05,73.36 31.05,77.43 30.13,78.34 30.13,80.05 31.81,81.72 31.81,84.62 v8(31,85.43)
  BOTTOM w0.254: v7(32.11,70.5) 31.93,70.32 31.93,67.93 30.16,66.15 29.17,66.15 28.76,65.75 PL704.3
N35074711: length 24.3
  TOP w0.122: v7(31.33,83.27) 31.33,83.81 v1(31.58,84.06)
  TOP w0.254: PR749.1 30.74,82.69 v7(31.33,83.27)
  IN2 w0.254: v7(31.33,83.27) 31.33,81.78 29.78,80.23 29.78,78.19 30.69,77.28 30.69,73.22 31.55,72.35 31.55,70.62 v7(31.43,70.5)
  BOTTOM w0.254: PL704.2 28.76,66.97 29.19,66.54 29.93,66.54 31.55,68.16 31.55,70.37 v7(31.43,70.5)
N35103280: length 6.6
  TOP w0.254: PR700.2 20.84,81.65 v1(19.95,81.65) v7(19.39,81.65) 19.23,81.5 PR702.2 PC703.2
  BOTTOM w0.254: PU700.38 20.47,81.54 20.44,81.57 20.18,81.57 20.1,81.65 v7(19.39,81.65) 18.95,81.65 18.78,81.83 PC708.1 18.7,81.85 PR703.2
N35103282: length 2
  TOP w0.122: v1(22.05,83.52) 21.77,83.24 PC700.1
  TOP w0.254: PC700.1 PR700.1
N35124422: length 3.2
  TOP w0.122: v1(127.88,54.57) 128.39,54.05 R894.2 ; Q32.1 128.85,54.06 R894.2 ; R894.2 R287.2
N35128487: length 6
  TOP w0.122: v1(20.76,79.77) PR708.1
  TOP w0.254: v7(19.41,81.01) 19.67,81.01 19.84,81.19 20.31,81.19 PR708.1
  BOTTOM w0.254: PC701.1 18.73,80.02 PC708.2 18.83,81.01 v7(19.41,81.01) 19.67,81.01 19.84,81.19 20.28,81.19 20.33,81.14 PU700.37
N36352449: length 7.4
  TOP w0.076: v2(157.66,64.22) 157.76,64.32 U636.A5
  TOP w0.122: R1104.2 162.62,60.79 v2(162.45,60.96)
  GND1 w0.104: v2(162.45,60.96) v3(162.01,60.96) ; v2(157.66,64.22) v3(158.1,64.22)
  IN1 w0.071: v3(162.01,60.96) 161.68,60.96 160.22,62.42 160.22,62.67 159.62,63.27 159.05,63.27 v3(158.1,64.22)
N37120607: length 4.6
  TOP w0.122: Q333.2 167.37,49.38 166.74,48.75 R1031.2 166.74,47.94 165.39,46.59 v1(165.39,46.39)
N37468330: length 3.9
  TOP w0.122: PR965.1 191.18,70.83 191.46,71.11 v1(191.46,71.74)
  TOP w0.254: PR965.1 PR966.1 191.51,69.81 191.64,69.68 191.64,68.88 191.5,68.75 PQ1228.6
N37468352: length 4.1
  TOP w0.122: v1(188.28,69.27) PR964.1
  TOP w0.254: PQ1228.3 188.82,67.45 188.7,67.34 PR968.2 PR964.1 188.7,68.25 188.86,68.1 PQ1228.2
N37468375: length 5
  TOP w0.122: PR967.2 192.93,68.08 v1(192.93,70.04)
  TOP w0.254: PQ1228.5 191.74,68.1 192.22,67.61 PC1918.1 PR967.2
N38312875: length 11.4
  TOP w0.203: v7(192.16,58.56) 192.59,58.56 193.14,58.01 PU501.4
  IN3 w0.254: v7(192.16,58.56) 192.89,59.3 195.21,59.3 v7(195.27,59.36)
  BOTTOM w0.254: PC1919.2 199.5,58.2 197.96,58.2 PR218.2 197.4,58.14 196.65,58.89 v9(195.79,58.89) 195.74,58.89 v7(195.27,59.36)
N38315341: length 3.4
  TOP w0.254: PU501.2 193.94,58.34 194.24,58.64 v8(194.24,58.76)
  BOTTOM w0.254: v8(194.24,58.76) 194.24,58.64 193.72,58.12 PC1920.1 193.72,56.93 PR216.1
N38789239: length 3.1
  BOTTOM w0.122: RRF2.1 160.53,27.06 URF1.4 ; RRF2.1 CRF4.1 ; RRF2.1 161.67,26.15 v1(161.75,26.06)
N38789526: length 3.6
  BOTTOM w0.122: v1(157.5,26.02) 158.52,27.05 CRF5.1 ; CRF5.1 158.62,27.94 RRF1.1 ; CRF5.1 159.07,27.05 159.13,27.1 URF1.6
N39303073: length 7.6
  TOP w0.122: PR971.2 184.97,70.26 184.67,70.55 184.67,71.02 184.47,71.22 184.47,71.59 185.01,72.13 v1(185.01,72.32) 185.47,72.77 187.36,72.77 188.09,73.51 PD907.1
N39870974: length 1
  TOP w0.254: PR513.2 189.75,79.39 PT19.1
N40584368: length 5.7
  TOP w0.122: Q336.1 168.73,77.14 168.46,76.87 v1(168.46,75.39)
  TOP w0.254: Q335.2 171.27,77.77 R1086.2 170.01,76.86 169.73,77.14 Q336.1
N40707343: length 2.8
  TOP w0.122: R1107.1 138.17,78.19 v1(138.68,77.69) 139,77.36 U638.1
N43370893: length 16.2
  TOP w0.122: RC99.1 50.44,80.9 51.52,79.82 v1(51.52,79.51) 51.59,79.44 v7(51.59,77.95)
  IN4 w0.071: v5(61.63,76.95) 61.63,76.92 60.35,75.65 53.61,75.65 52.71,76.54 52.71,76.83 v7(51.59,77.95)
  GND5 w0.104: v6(61.3,77.25) 61.6,76.95 v5(61.63,76.95)
  BOTTOM w0.122: UCPU1.G43 61.63,76.93 v6(61.3,77.25)
N45600193: length 2.5
  TOP w0.122: v1(162.01,85.99) 161.54,85.52 Q71.1 162.12,85.05 162.31,85.24 R536.2
N50875368: length 2.9
  TOP w0.254: PR508.2 PR507.1 125.28,50.69 125.57,50.98 125.57,51.64 PR506.1 PC509.1
N50950299: length 2
  TOP w0.122: v1(150.68,38.84) PC35.1
  TOP w0.254: PC35.1 PR35.1
N50950325: length 2.2
  BOTTOM w0.122: v9(142.15,38.32) PR23.2
  BOTTOM w0.254: PR23.2 143.42,38.28 PC22.1
N50950426: length 3.5
  BOTTOM w0.254: PU2.4 148.32,40.68 v1(149.01,41.37) 149.67,41.37 PR31.2
N50950439: length 2.2
  BOTTOM w0.122: v1(154.57,39.43) 154.36,39.64 PC36.1
  BOTTOM w0.254: PR37.2 152.88,39.64 PC36.1
N51193799: length 2.4
  TOP w0.122: PR506.2 v1(127.69,51.65)
  TOP w0.254: PC510.1 126.17,51.32 PR506.2
N51517838: length 3.3
  TOP w0.122: PR26.1 v9(131.53,26.47)
  TOP w0.508: PR26.1 131.11,28.32 129.89,28.32 PC30.2
N51590731: length 4.3
  BOTTOM w0.122: v1(151.42,34.61) 151.7,34.61 152.24,35.15 PR38.1
  BOTTOM w0.178: PU2.13 150.79,36.71 151.19,36.31 151.98,36.31 PR104.1
  BOTTOM w0.254: PR38.1 152.24,36.22 PR104.1
N51681745: length 6.2
  TOP w0.254: PD10.1 147.4,44.67 145.77,44.67 v1(145.36,44.26) 145.36,43.12 144.13,41.88 PR24.1
N51733458: length 4.7
  TOP w0.254: v7(147.33,34.66) 147.52,34.85 PR32.1
  BOTTOM w0.203: PC32.1 148.47,33.19 v1(147.83,33.83) 147.56,34.1 147.55,34.1 147.51,34.16 147.33,34.43 v7(147.33,34.66) 147.52,34.86 PU2.20
N51743550: length 5.2
  TOP w0.122: v1(162.59,46.22) 162.31,45.93 PC41.2
  TOP w0.508: PR16.1 PR20.1 PC45.2 ; PR16.1 162.27,45.2 PC41.2 ; PR16.1 162.27,43.02 PQ102.4
N51743582: length 6.9
  TOP w0.122: PQ101.5 v9(163.89,35.52)
  TOP w0.508: PQ102.5 159.53,42.09 PC45.1
N51790438: length 6.2
  TOP w0.122: v1(146.73,43.93) 147.17,43.48 147.86,43.48 148.17,43.18 PR34.1
  TOP w0.254: v7(149.49,40.4) 149.49,41.33 PR33.2 148.7,42.46 PR34.1
  BOTTOM w0.254: PU2.6 149.12,40.03 149.36,40.26 149.36,40.27 v7(149.49,40.4)
N52416950: length 4
  BOTTOM w0.122: v1(154.48,40.79) 153.41,41.86 PR36.1
  BOTTOM w0.254: PR36.1 151.02,41.86 PC33.2
N52558691: length 1.5
  BOTTOM w0.122: PC740.2 26.35,73.72 v9(26.7,73.37)
N52558783: length 2.2
  TOP w0.122: PR733.1 28.89,77.24 29.04,77.09 v9(29.04,76.7)
  TOP w0.254: PR733.1 PC728.1
N52558792: length 4.8
  TOP w0.122: PC719.1 v1(21.65,75.76)
  TOP w0.254: v7(22.59,76.83) 22.44,76.99 PC719.1
  BOTTOM w0.254: PU700.26 23.37,77.55 23.12,77.3 22.98,77.3 22.59,76.9 v7(22.59,76.83) 22.59,76.66 PR722.1
N52558828: length 23.2
  TOP w0.122: v1(26.49,73.76) 26.46,73.74 26.46,72.17 26.09,71.81 v7(26.09,71.36)
  TOP w0.254: v7(26.09,71.36) 26.22,71.23 PH702.1 ; v7(25.46,86.58) 25.46,86.27 PR726.2 PR727.2
  IN2 w0.254: v7(25.46,86.58) 25.46,86.42 27.21,84.67 27.21,82.61 26.65,82.05 26.65,79.59 24.39,77.33 24.39,75.52 26.37,73.54 26.37,71.75 26.09,71.47 v7(26.09,71.36)
N52558829: length 3
  BOTTOM w0.254: PU700.9 24.97,83.53 25.28,83.83 25.69,83.83 v1(25.95,84.1) PR723.2
N52558859: length 1.1
  BOTTOM w0.254: PR738.1 29.83,80 29.83,78.98 PC730.2
N52558875: length 21.5
  TOP w0.254: v7(24.72,86.55) 24.72,86.4 PR701.1 PR704.1 ; PH700.2 24.37,70.68 24.37,71.59 25.13,72.35 25.41,72.35 v8(25.53,72.22)
  IN1 w0.254: v7(24.72,86.55) 24.72,86.22 24.31,85.81 23.65,85.81 22.16,84.32 22.16,83.65 22.94,82.87 22.94,78.57 23.81,77.71 23.81,73.85 25.43,72.22 v8(25.53,72.22)
N52558898: length 33.8
  TOP w0.122: v1(25.89,59.42) v7(25.31,59.42)
  TOP w0.254: PR741.2 27.87,85.14 v7(27.74,85.27)
  IN2 w0.254: v7(25.31,59.42) 25.1,59.22 25.1,58.97 25.19,58.88 29.14,58.88 29.32,59.05 29.32,75.22 28.84,75.7 28.84,84.17 v7(27.74,85.27)
  BOTTOM w0.254: PH703.2 v7(25.31,59.42)
N52559017: length 3.5
  TOP w0.122: v1(29.42,73.14) 28.05,73.14 PC744.1
  TOP w0.508: PC744.1 27.57,72.1 27.49,72.03 PR743.2
N52559077: length 2.4
  TOP w0.122: v1(24.62,79.64) 24.76,79.64 24.82,79.58 25.05,79.58 25.42,79.21 PR740.2
  TOP w0.254: PC733.1 26.47,80.05 PR740.2
N52757730: length 30.8
  TOP w0.122: v7(21.27,64.58) 22.41,63.44 v1(22.41,62.22)
  IN2 w0.254: v7(21.27,64.58) 21.06,64.38 20.09,64.38 16.49,67.98 16.49,84.01 16.64,84.16 16.9,84.16 v7(17.1,83.96)
  BOTTOM w0.254: PR714.2 17.1,83.46 v7(17.1,83.96) ; PL701.3 v7(21.27,64.58)
N52760442: length 27.6
  TOP w0.122: v7(21.27,63.84) 21.27,63.82 v1(21.7,63.39)
  IN2 w0.254: v7(17.1,84.67) 16.95,84.52 16.5,84.52 16.14,84.16 16.14,67.83 19.95,64.02 21.09,64.02 v7(21.27,63.84)
  BOTTOM w0.254: PR715.1 17.23,84.67 v7(17.1,84.67) ; v7(21.27,63.84) PL701.2
N53073163: length 2.6
  TOP w0.122: v9(153.93,43.68) 153.75,43.68 152.97,42.9 PR41.2
  TOP w0.254: PR41.2 152.74,42.69 PQ7.2
N53085144: length 2.9
  TOP w0.122: v9(38.01,19.56) PC301.1
  TOP w0.254: PC301.1 PR300.1
N56236213: length 3.1
  TOP w0.254: v8(185.41,56.92) 185.76,56.58 PR219.2 PR210.1
  BOTTOM w0.254: v8(185.41,56.92) 185.85,56.49 PD200.2
N59797367: length 2.8
  TOP w0.122: v1(139.5,45.61) 139.46,45.64 RC11.2 140,46.61 140.38,46.99 UC1.2
N70085701: length 2.6
  TOP w0.122: v1(184.96,73.75) 185.01,73.8 PD903.2 184.74,75.45 PR938.2
N74579073: length 6.3
  TOP w0.254: PC125.1 199.38,57.71 PR941.1 198.78,57.11 197.13,57.11 197.08,57.16 v1(196.2,57.16) 195.71,57.16 195.38,56.83 PU501.20
N74615006: length 41.7
  TOP w0.254: v7(194.03,53.37) 194.03,53.35 193.99,53.35 193.96,53.37 193.96,53.47 193.94,53.49 PU501.14 ; PC222.1 188.83,77.3 PR513.1 188.53,78.75 v1(187.88,78.75) 187.78,78.65 187.78,76.43 v7(187.64,76.29)
  IN1 w0.254: v7(187.64,76.29) 187.81,76.11 187.81,72.64 186.72,71.55 186.72,70.7 185.8,69.77 185.8,68.63 182.66,65.49 182.66,57.8 184.91,55.55 188.74,55.55 191.43,52.86 193.54,52.86 194.03,53.34 v7(194.03,53.37)
  BOTTOM w0.254: PR514.2 194.03,53.72 194.03,53.41 193.96,53.35 194.03,53.35 v7(194.03,53.37)
N75083074: length 23.6
  TOP w0.381: CH45.1 105.96,60.63 v2(106.38,60.21)
  GND1 w0.381: v2(106.38,60.21) v3(106.38,59.78)
  IN1 w0.381: v3(106.38,59.78) v4(106.38,59.3)
  IN3 w0.508: v4(92.03,55.61) 95.94,55.61 97.57,57.24 103.61,57.24 104.95,58.57 104.95,58.59 105.66,59.3 v4(106.38,59.3)
  IN4 w0.254: v5(105.8,61.05) 105.8,59.88 v4(106.38,59.3)
  IN4 w0.508: v5(91.37,55.44) 91.85,55.44 v4(92.03,55.61)
  GND5 w0.254: v6(105.39,61.05) v5(105.8,61.05)
  GND5 w0.508: v6(91.37,55.87) v5(91.37,55.44)
  BOTTOM w0.122: v1(92.72,54.98) 92.54,55.16 RH207.1
  BOTTOM w0.254: UH1.AJ13 v6(105.39,61.05)
  BOTTOM w0.508: RH207.1 v6(91.37,55.87)
N75342688: length 3.2
  TOP w0.122: v9(103.88,80.24) PC603.2
  TOP w0.508: PC603.2 104.88,82.12 PR606.1
N75921521: length 4
  TOP w0.122: v1(215.84,52.63) 215.52,52.95 215.52,53.14 215.14,53.53 R808.2 215.1,53.59 R809.1 215.09,54.43 UI1.4
N76682880: length 5.8
  TOP w0.122: U637.13 155.49,49.14 155.18,48.83 155.18,47.52 C964.2 153.73,47.02 v1(153.42,47.32)
N76692443: length 3.4
  TOP w0.122: C964.1 154.67,48.92 154.46,49.12 v1(154.46,49.49) 154.46,49.54 154.69,49.77 U637.12
N76702116: length 2.7
  TOP w0.122: C968.1 151.18,55.4 v1(151.18,54.55) 151.18,54.2 151.49,53.89 U637.6
N76768428: length 3
  TOP w0.122: C974.1 141.99,81.04 v1(141.99,79.77) U638.14
N82958598: length 6.4
  TOP w0.122: v1(65.51,30.47) RD10.1 65.5,31.71 64.14,31.71 63.41,32.45 61.26,32.45 UD10.H8
N82974297: length 13.2
  BOTTOM w0.122: RD9.1 53.66,42.13 v1(54.2,41.59) 54.2,40.77 52.64,39.2 52.64,34.41 53.79,33.25 55.39,33.25 55.76,32.88 UD9.H8
N82984966: length 13.2
  TOP w0.122: RD12.1 50.88,40.73 52.25,40.73 52.76,40.21 v1(52.76,39.97) 52.76,39.2 52.4,38.83 52.4,34.14 50.75,32.49 50.17,32.49 UD12.H8
N82985022: length 12.9
  BOTTOM w0.122: UD11.H8 44.71,32.88 44.3,33.29 42.96,33.29 41.46,34.79 41.46,36.77 41.84,37.15 41.84,39.94 41.46,40.32 v1(41.46,41.43) 42.18,42.15 RD11.1
N83067505: length 9
  TOP w0.122: UD14.H8 39.14,32.46 40.3,32.46 41.66,31.1 v1(41.66,26.76) RD14.1
N83067634: length 9.2
  TOP w0.122: RD16.1 30.26,26.8 v1(30.26,27) 30.26,31.45 29.26,32.45 28.11,32.45 UD16.H8
N83067686: length 16.3
  BOTTOM w0.122: v1(27.27,42.09) 26.64,41.45 RD15.1 24.75,41.45 22.99,39.7 21.25,39.7 19.74,38.19 19.74,35.52 21.14,34.12 21.14,33.62 21.52,33.24 22.28,33.24 22.64,32.88 UD15.H8
N83068729: length 10.2
  BOTTOM w0.122: RD13.1 30.06,26.53 v1(30.65,27.11) 31.38,27.85 31.38,32.56 32.08,33.25 33.35,33.25 33.72,32.88 UD13.H8
N83116242: length 6.1
  TOP w0.122: UD2.H8 109.86,27.41 112.03,27.41 113.02,26.42 113.53,26.42 v1(113.76,26.19) RD2.1
N83116246: length 10.8
  BOTTOM w0.122: UD1.H8 104.55,27.92 104.25,27.92 103.99,28.17 102.56,28.17 101.75,27.36 v1(101.75,21.64) 101.94,21.44 RD1.1
N83116251: length 9.5
  TOP w0.122: UD4.H8 98.77,27.44 99.98,27.44 100.99,26.44 v1(100.99,21.04) RD4.1
N83116264: length 11.3
  BOTTOM w0.122: RD3.1 91,20.28 90.74,20.55 v1(90.74,21.01) 90.74,27.52 91.39,28.17 93.02,28.17 93.39,27.8 UD3.H8
N83118336: length 9.9
  TOP w0.122: UD6.H8 87.78,27.39 89.49,27.39 90.1,26.78 90.1,21.83 v1(90.33,21.6) 90.7,21.23 RD6.1
N83118366: length 9.4
  TOP w0.122: UD8.H8 76.7,27.42 77.53,27.42 78.65,26.31 v1(78.65,21.7) 79.65,20.7 RD8.1
N83118379: length 11.9
  BOTTOM w0.122: UD7.H8 71.31,27.8 70.96,28.16 70.11,28.16 68.51,29.76 68.51,34.79 v1(67.55,35.75) 67.55,36.06 RD7.1
N83118646: length 11.8
  BOTTOM w0.122: UD5.H8 82.49,27.88 82.23,27.88 81.93,28.17 80.46,28.17 79.71,27.42 79.71,20.62 v1(79.8,20.54) 80.04,20.3 81.23,20.3 RD5.1
N83503951: length 2.8
  BOTTOM w0.122: v1(15.88,35.88) 15.95,35.81 CD124.1 16.82,35.38 16.89,35.31 RD36.2 RD38.2
N83550878: length 3
  TOP w0.122: CD123.1 119.79,34.06 119.75,34.02 RD35.2 RD37.2 120.4,32.73 v1(120.81,33.13)
N83744884: length 8.4
  TOP w0.254: PR408.1 171.18,40.08 PC407.1 171.18,38.57 v1(170.67,38.06) 170.19,37.58 v7(164.75,37.58)
N83757774: length 4.8
  TOP w0.254: PU501.15 194.72,54.54 194.88,54.7 v7(194.9,54.7)
  BOTTOM w0.122: v1(196.02,53) 195.99,53.02 PR512.1
  BOTTOM w0.254: v7(194.9,54.7) 195.39,54.7 195.74,54.35 195.74,54.29 PR512.1 196.81,54.04 197.03,53.81 PC205.1
N84344604: length 17.9
  TOP w0.254: PC509.2 v2(123.81,51.09)
  GND1 w0.254: v2(123.81,51.09) v3(123.81,50.46)
  IN1 w0.254: v3(123.81,50.46) 123.07,50.46 122.66,50.05 119.08,50.05 118.29,50.84 116.72,50.84 115.88,50 113.68,50 113.13,49.44 111.54,49.44 109.66,47.56 v7(108.92,47.56)
  vias: v7(108.11,45.05) v7(108.21,44.03) v7(108.21,43.4) v7(108.29,47.56) v7(108.29,46.93) v7(108.29,46.29) v7(108.29,45.66) v7(108.26,42.76) v7(108.26,42.13) v7(108.26,41.49) v7(108.26,40.86) v7(108.74,45.05) v7(108.92,46.93) v7(108.92,46.29) v7(108.92,45.66) v9(107.68,41.41)
N85222631: length 8.3
  TOP w0.076: v2(141.79,59.3) 141.73,59.3 141.42,59.6 U34.J6
  TOP w0.122: v2(140.39,54.83) 140.27,54.7 R921.1
  GND1 w0.104: v2(141.79,59.3) 141.79,59.3 141.17,59.3 v3(140.76,58.89) ; v2(140.39,54.83) 140.16,54.59 140.02,54.59 v3(139.63,54.98)
  IN1 w0.071: v3(140.76,58.89) 140.61,58.74 140.08,58.74 139.96,58.61 139.96,57.29 139.73,57.06 139.73,55.37 139.63,55.27 v3(139.63,54.98)
N85751870: length 3.5
  TOP w0.508: PR501.2 127.88,42.63 PC504.1 v1(126.36,40.73)
N85751893: length 3.6
  BOTTOM w0.122: v1(116.39,49.97) 116.89,50.47 PR504.2
  BOTTOM w0.508: PR504.2 118.59,50.47 PC508.1
N86118123: length 22.6
  TOP w0.122: v7(224.4,23.39) 224.17,23.62 Q316.5 Q316.6 224.26,24.82 v1(224.67,24.82)
  GND1 w0.104: v3(228.65,7.04) v2(229.31,7.04)
  IN1 w0.071: v3(228.65,7.04) 230.08,8.48 230.08,13.91 229.75,14.24 229.75,18.12 224.48,23.39 v7(224.4,23.39)
N86178716: length 3.1
  TOP w0.122: LED1.1 230.71,17.35 230.18,16.83 v1(230.18,16.47) R910.1
N86209671: length 2.9
  TOP w0.122: LED2.1 230.97,13.75 v1(230.28,13.07) 230.18,12.97 R911.1
N86209740: length 1.6
  TOP w0.122: R912.1 230.88,10.15 LED3.1
N86209815: length 1.5
  TOP w0.122: R913.1 230.47,6.09 230.93,6.55 LED4.1
N86209896: length 2.5
  TOP w0.122: LED5.1 230.73,3.72 230.73,4.34 R916.1
N86222873: length 1.6
  TOP w0.122: R909.1 225.98,8.88 Q317.6 Q317.5
N86223054: length 2.8
  TOP w0.122: Q318.5 Q318.6 227.96,8.12 R915.1
N86223355: length 3.1
  TOP w0.122: R918.1 229.08,13.88 228.38,13.88 v1(228.25,13.75) 227.96,13.46 Q319.6 Q319.5
N86223600: length 2
  TOP w0.122: R920.1 229.21,4.79 Q320.5 Q320.6
N88409051: length 0.9
  TOP w0.122: R976.2 156.97,55.6 C1141.1
N88620271: length 2.1
  BOTTOM w0.254: DH4.2 28.52,48.34 v1(28.43,48.43) 28.29,48.56 RH259.1
N89386241: length 2.1
  TOP w0.122: UD17.1 60.8,53.13 60.63,53.3 RD39.2
N89389377: length 3
  TOP w0.122: UD17.2 61.14,52.48 61.07,52.41 RD40.2 60.19,51.63 v1(60.36,51.46)
N89456409: length 2.6
  TOP w0.122: v1(70.99,55) 70.98,55 RD41.2 71.42,54.06 71.59,53.9 UD18.1
N89456446: length 5.6
  TOP w0.122: v1(74.67,55.93) 74.67,54.7 73.22,53.25 UD18.2 71.05,53.25 RD42.2
N90173610: length 20.7
  IN3 w1.016: 218.6,69.52 218.6,71.77 216.1,74.27 216.1,75.35 214.93,76.52 208.21,76.52 205.86,74.17
  BOTTOM w0.254: JMDP1.20 v7(218.6,68.6)
  vias: v1(206.43,72.45) v7(205.8,73.16) v7(205.81,72.53) v7(218.38,68)
N93046705: length 3.1
  TOP w0.122: T224.1 v2(54.05,77.53)
  GND1 w0.104: v2(54.05,77.53) v3(53.6,77.53)
  IN1 w0.071: v3(53.6,77.53) 53.6,77.2 v4(53.25,76.85)
  IN4 w0.071: v5(53.25,77.33) v4(53.25,76.85)
  GND5 w0.104: v6(53.68,77.33) v5(53.25,77.33)
  BOTTOM w0.122: T224.1 53.91,77.1 v6(53.68,77.33)
N93049125: length 1.8
  TOP w0.122: v7(54.64,78.07) 54.31,78.4 T225.1
  BOTTOM w0.122: v7(54.64,78.07) 54.8,77.91 UCPU1.E55
N93049404: length 7
  BOTTOM w0.122: T226.1 48.93,81.01 49.71,81.01 51.72,79.01 51.72,78.55 52.14,78.13 52.14,77.6 52.36,77.38 52.87,77.38 UCPU1.E59
N93049685: length 2.7
  TOP w0.122: T227.1 v6(54.85,76.61)
  GND1 w0.104: v6(54.85,76.61) v3(54.41,76.61)
  IN1 w0.071: v3(54.41,76.61) v4(53.91,76.61)
  IN4 w0.071: v4(53.91,76.61) v5(54.4,76.61)
  GND5 w0.104: v6(54.85,76.61) v5(54.4,76.61)
  BOTTOM w0.122: T227.1 v6(54.85,76.61)
N93049968: length 7
  BOTTOM w0.122: UCPU1.G59 53.05,77 52.7,76.65 52.15,76.65 51.92,76.87 51.43,76.87 51.13,77.17 51.13,79.11 49.64,80.61 T228.1
N93050253: length 7.3
  BOTTOM w0.122: UCPU1.H60 52.97,76.42 52,76.42 51.8,76.62 51.33,76.62 50.89,77.07 50.89,78.98 49.61,80.25 48.93,80.25 T229.1
N93050540: length 6.6
  BOTTOM w0.122: T231.1 48.91,79.55 49.52,79.55 50.39,78.68 50.39,76.86 51.36,75.88 UCPU1.J61
N93050829: length 6.9
  BOTTOM w0.122: T230.1 49.58,79.9 50.64,78.83 50.64,76.96 51.23,76.37 51.74,76.37 51.91,76.2 52.67,76.2 52.99,75.88 UCPU1.J59
N93297412: length 4.7
  TOP w0.122: R542.2 168.59,85.81 169.16,85.24 v1(169.16,84.76) 169.08,84.69 Q305.6 Q305.5
N93297423: length 3.4
  TOP w0.122: v1(168.05,81.95) 167.82,81.72 R541.2
  TOP w0.508: R541.2 166.11,82.17 Q305.3
N96981838: length 4.3
  TOP w0.122: R944.2 173.05,26.33 172.45,26.92 v1(172.45,27.15) 172.45,27.4 v7(172.85,27.8)
  BOTTOM w0.122: v7(172.85,27.8) JBL1.3
N98615300: length 2.2
  BOTTOM w0.122: v1(140.16,79.27) CH94.1 RH256.1
N104496657: length 3.4
  BOTTOM w0.122: T123.1 113.84,53.23 113.84,55.38 113.75,55.48 UH1.H2
N141332713: length 5.5
  TOP w0.122: v1(26.93,82.41) 26.69,82.17 26.69,81.64 v7(27.25,81.08)
  BOTTOM w0.254: PU700.15 26.79,80.74 27.08,81.04 27.21,81.04 v7(27.25,81.08) 27.34,80.99 PC746.2 28.51,81.57 PR748.2
N141350441: length 1
  BOTTOM w0.254: PC746.1 29.26,80.99 29.31,80.94 PR750.2
N141612052: length 2
  BOTTOM w0.122: PC701.2 16.95,79.97 v1(16.8,79.82)
  BOTTOM w0.254: PR703.1 17.79,80 PC701.2
N141616081: length 3.2
  TOP w0.122: PR705.1 16.87,78.6 v9(17.02,78.45)
  TOP w0.254: PC703.1 17.77,80.63 PR705.1
N141681282: length 21
  TOP w0.254: PR706.1 21.57,86 21.14,86.44 v7(21.14,86.58)
  IN2 w0.254: v7(21.14,86.58) 21.14,85.76 18.4,83.02 18.4,75.4 17.58,74.59 17.58,70.14 v7(17.99,69.74)
  BOTTOM w0.122: PH701.1 17.18,70.37 v1(17,70.55)
  BOTTOM w0.254: v7(17.99,69.74) 17.96,69.76 PH701.1
N141712369: length 6.2
  TOP w0.254: PC712.1 19.82,83.27 v7(20.23,82.87)
  IN1 w0.254: v7(18.86,84.93) 18.86,84.23 v7(20.23,82.87)
  BOTTOM w0.122: v7(18.86,84.93) 18.36,84.93 v1(18.24,85.05)
  BOTTOM w0.254: v7(18.86,84.93) 18.9,84.97 PR712.2 ; v7(20.23,82.87) 20.75,82.35 PU700.40
N141714393: length 2.6
  TOP w0.122: PR707.1 19.46,85.38 18.63,85.38 v1(18.36,85.11)
  TOP w0.254: PR707.1 19.79,84.42 PC712.2

## Copper pours and planes (outline as drawn)
1.5VSP_LX on BOTTOM (solid shape): 167.29,41.36 167.29,40.2 167.62,39.87 168.74,39.87 168.82,39.79 168.82,39.1 168.74,39.03 168.28,39.03 168.13,38.87 167.37,38.87 167.27,38.77 167.27,37.1 167.19,37.02 165.72,37.02 165.54,37.2 165.54,41.06 165.97,41.49 167.16,41.49
1.5VSP_VIN on BOTTOM (solid shape): 171.81,39.71 171.81,38.32 172.85,37.27 173.62,37.27 173.69,37.2 173.69,36.26 173.51,36.08 171.76,36.08 171.13,36.72 169.15,36.72 169.02,36.84 169.02,37.55 169.76,38.29 170.77,38.29 170.95,38.47 170.95,39.84 171,39.89 171.63,39.89
1.8VSP_LX on BOTTOM (solid shape): 102.47,52.02 102.47,50.84 102.85,50.46 103.59,50.46 103.64,50.41 103.64,49.7 103.54,49.59 102.75,49.59 102.42,49.26 102.42,47.59 101.68,46.85 101.68,46.34 101.56,46.22 99.85,46.22 99.75,46.32 99.75,47.97 100.13,48.35 100.13,51.42 100.41,51.67 100.34,52.03 100.58,52.27 102.22,52.27
1.8VSP_VIN on BOTTOM (solid shape): 106.32,50.42 106.69,50.15 107.05,50.42 107.06,50.46 107.8,50.46 107.88,50.38 107.88,48.04 108.01,47.92 107.3,47.21 106.69,47.21 106.1,47.21 105.98,47.21 105.9,47.13 105.9,46.77 105.82,46.7 105.09,46.7 104.96,46.82 104.96,48.09 105.71,48.84 105.71,50.32 105.85,50.46 106.31,50.46
1.35V_B+ on TOP (solid shape): 47.51,23.41 47.51,22.03 47.78,21.76 50.73,21.76 50.91,21.58 50.91,19.24 50.73,19.06 48.5,19.06 47.76,19.8 44.54,19.8 44.2,20.14 43.25,20.14 43.01,20.38 43.01,23.18 43.44,23.61 47.3,23.61
1.35V_B+ on BOTTOM (solid shape): 47.57,23.16 47.57,22.12 47.71,21.98 47.71,19.75 47.66,19.7 45.32,19.7 45.22,19.8 45.22,20.26 45.24,20.28 45.88,20.28 45.93,20.33 45.93,22.9 46.29,23.25 47.48,23.25
+0.675VS on TOP (solid shape): 31.29,25.66 31.29,24.83 31.23,24.77 30.59,24.77 30.37,24.55 30.37,24.09 30.31,24.02 29.94,24.02 29.85,24.12 29.85,25.55 30.01,25.71 31.24,25.71
+0.675VS on TOP (solid shape): 17.44,41 17.44,40.28 17.2,40.04 17.2,30.51 17.11,30.41 17.11,30.09 17.2,30 17.2,26.27 17.13,26.2 16.15,26.2 15.82,26.53 15.82,26.97 15.55,27.24 15.06,27.24 14.85,27.45 14.85,27.97 14.96,28.07 15.32,28.07 15.55,28.31 15.55,29.09 15.55,29.15 15.4,29.3 14.97,29.3 14.89,29.38 14.89,29.95 15.07,30.13 15.07,32.37 15.07,32.37 15.07,38.04 15.02,38.09 15.02,38.39 15.63,38.39 15.63,38.34 15.64,38.29 15.65,38.24 15.67,38.19 15.7,38.14 15.74,38.11 15.78,38.07 15.83,38.05 15.88,38.03 15.93,38.01 15.98,38.01 16.04,38.01 16.09,38.03 16.14,38.05 16.18,38.07 16.23,38.11 16.26,38.14 16.29,38.19 16.32,38.24 16.33,38.29 16.34,38.34 16.34,38.39 16.33,38.45 16.32,38.5 16.29,38.55 16.26,38.59 16.23,38.63 16.18,38.66 16.14,38.69 16.09,38.71 16.04,38.72 15.98,38.72 15.93,38.72 15.88,38.71 15.83,38.69 15.78,38.66 15.74,38.63 15.7,38.59 15.67,38.55 15.65,38.5 15.64,38.45 15.63,38.39 15.02,38.39 15.02,40.14 16.03,41.16 17.28,41.16
+0.675VS on TOP (solid shape): outline of 805 points within 112.71,18.71 121.1,33.88
+0.675VS on BOTTOM (solid shape): 58.1,49.36 58.1,48.43 57.33,47.66 57.11,47.66 56.68,48.09 56.67,48.09 56.45,48.32 56.45,49.36 56.57,49.49 57.97,49.49
+0.675VS on BOTTOM (solid shape): 17.3,33.29 17.3,25.77 17.2,25.67 16.62,25.67 16.52,25.77 16.52,27.23 16.52,27.24 16.54,27.37 16.52,27.49 16.52,27.5 16.52,27.55 15.73,28.33 15.73,29.14 16.29,29.7 16.29,33.29 16.44,33.44 17.15,33.44
+0.675VS on IN2 (solid shape): 67.2,19.43 67.2,18.78 67.01,18.59 65.74,18.59 65.49,18.85 65.49,19.35 65.74,19.6 67.04,19.6
+0.675VS on IN2 (solid shape): 31.47,24.99 31.47,22.95 31.38,22.86 30.12,22.86 29.81,23.16 29.81,24.37 30.41,24.37 30.41,24.32 30.43,24.26 30.45,24.21 30.47,24.16 30.51,24.12 30.55,24.08 30.59,24.04 30.64,24.02 30.7,24 30.75,23.99 30.81,23.99 30.86,24 30.92,24.01 30.97,24.03 31.01,24.06 31.06,24.1 31.09,24.14 31.13,24.18 31.15,24.23 31.17,24.29 31.17,24.34 31.17,24.4 31.17,24.45 31.15,24.51 31.13,24.56 31.09,24.6 31.06,24.65 31.01,24.68 30.97,24.71 30.92,24.73 30.86,24.75 30.81,24.75 30.75,24.75 30.7,24.74 30.64,24.72 30.59,24.7 30.55,24.67 30.51,24.63 30.47,24.58 30.45,24.53 30.43,24.48 30.41,24.43 30.41,24.37 29.81,24.37 29.81,24.97 30.02,25.17 31.29,25.17
+0.675VS on IN3 (solid shape): 116.9,19.65 116.9,18.76 116.85,18.71 114.78,18.71 114.61,18.88 114.61,19.77 114.74,19.9 116.64,19.9
+0.675VS on IN3 (solid shape): 17.86,29.34 17.86,27.57 17.66,27.37 16.77,27.37 16.11,28.03 15.83,28.03 15.73,28.13 15.73,28.94 15.86,29.07 15.86,29.49 15.97,29.61 17.59,29.61
+0.675VS on IN3 (solid shape): 30.41,25.05 30.41,23.57 30.41,23.46 30.26,23.31 28.51,23.31 28.34,23.48 28.34,24.28 29.03,24.28 29.03,24.23 29.04,24.17 29.06,24.12 29.09,24.07 29.12,24.03 29.16,23.99 29.21,23.96 29.26,23.93 29.31,23.91 29.37,23.9 29.42,23.9 29.48,23.91 29.53,23.92 29.58,23.94 29.63,23.97 29.67,24.01 29.71,24.05 29.74,24.1 29.76,24.15 29.78,24.2 29.79,24.25 29.79,24.31 29.78,24.37 29.76,24.42 29.74,24.47 29.71,24.52 29.67,24.56 29.63,24.59 29.58,24.62 29.53,24.64 29.48,24.66 29.42,24.66 29.37,24.66 29.31,24.65 29.26,24.63 29.21,24.61 29.16,24.58 29.12,24.54 29.09,24.49 29.06,24.44 29.04,24.39 29.03,24.34 29.03,24.28 28.34,24.28 28.34,25.04 28.52,25.22 30.25,25.22
+0.675VS on IN3 (solid shape): outline of 267 points within 65.49,18.68 76.44,20.92
+0.675VSP on TOP (solid shape): 33.92,24.91 33.92,22.99 33.6,22.67 32.47,22.67 32.42,22.72 32.42,23.74 32.66,23.98 32.66,24.5 32.43,24.73 32.15,24.73 31.88,24.46 31.88,24.27 31.81,24.19 31.63,24.19 31.58,24.24 31.58,24.85 31.87,24.85 31.87,25.69 33.14,25.69
+0.675VSP on BOTTOM (solid shape): 35.36,23.37 35.36,20.21 35.22,20.07 34.44,20.07 34.19,20.33 34.19,21.71 33.71,22.19 33.71,23.44 33.08,24.07 32.83,24.07 32.7,24.2 32.7,24.62 32.84,24.76 33.97,24.76
+1.5VS on TOP (solid shape): 174.96,37.27 174.96,36.08 174.99,36.06 174.99,36.02 175.02,36.02 175.04,36 175.52,36 175.55,35.98 175.55,35.83 175.52,35.8 175.09,35.8 175.04,35.8 175.02,35.79 174.99,35.79 174.99,35.42 174.96,35.39 174.56,35.39 174.43,35.52 174.43,35.64 174.43,37.17 174.56,37.3 174.94,37.3
+1.5VS on BOTTOM (solid shape): 157.39,41.01 157.39,38.01 157.31,37.93 156.39,37.93 156.22,38.11 156.22,41.06 156.29,41.14 157.26,41.14
+1.5VS on IN2 (solid shape): 159.32,44.67 159.32,44.28 158.68,43.65 158.05,43.65 157.79,43.9 157.79,44.28 158.43,44.92 159.06,44.92
+1.05VS_SATA3 on BOTTOM (solid shape): 106.71,61.76 106.71,61.2 106.68,61.14 106.66,61.09 106.66,61.07 106.46,60.87 105.9,60.87 105.63,61.14 105.62,61.17 105.62,61.94 105.75,62.06 106.41,62.06
+1.05VS_VCCA_A_DPL on BOTTOM (solid shape): 89.79,74.58 89.79,72.04 89.65,71.9 87.96,71.9 87.76,72.1 87.76,72.79 87.56,72.99 85.91,72.99 85.66,73.24 85.66,74.38 85.97,74.7 89.66,74.7
+1.05VS_VCCA_B_DPL on BOTTOM (solid shape): 89.96,71.23 89.96,68.92 90.35,68.52 90.35,67.4 90.1,67.14 87.56,67.14 87.11,67.6 87.11,68.59 87.56,69.05 88.2,69.05 88.7,69.56 88.7,71.34 88.83,71.46 89.72,71.46
+1.5VS_WLAN on TOP (solid shape): 179.97,37.3 179.97,36.69 179.94,36.67 179.76,36.67 179.56,36.46 179.18,36.46 178.87,36.16 177.1,36.16 176.44,35.5 176.41,35.52 176.11,35.52 175.9,35.3 175.89,35.27 175.19,35.27 175.11,35.34 175.11,35.65 175.14,35.67 175.65,35.67 175.67,35.7 175.67,36.11 175.65,36.13 175.14,36.13 175.11,36.16 175.12,37.02 175.17,37.08 175.21,37.03 175.55,36.9 175.83,37.14 175.85,37.17 177.9,37.17 178.1,36.97 178.65,36.97 179.05,37.38 179.89,37.38
+1.8VS on BOTTOM (solid shape): 92.01,54.06 92.01,52.54 91.9,52.44 91.9,50.13 91.83,50.05 89.44,50.05 88.5,50.99 88.5,52.97 89.01,53.48 90.38,53.48 91.09,54.19 91.88,54.19
+1.8VS_VCCPLL on BOTTOM (solid shape): 84.54,59.3 84.54,57.75 84.94,57.34 84.94,55.79 85.02,55.71 90.18,55.71 90.35,55.54 90.35,54.16 90.28,54.08 88.84,54.08 85.77,51.02 82.86,51.02 82.73,51.14 82.73,52.16 81.72,53.17 80.7,53.17 80.58,53.3 80.58,54.06 82.76,56.25 82.76,58.53 82.35,58.94 81.08,58.94 80.91,58.76 80.75,58.76 80.63,58.89 80.63,59.11 80.66,59.18 80.73,59.21 80.96,59.34 80.95,59.61 80.94,59.63 80.94,59.66 80.98,59.7 81.41,59.7 81.43,59.7 81.45,59.68 81.66,59.57 81.88,59.68 82.1,59.91 82.16,59.92 82.22,59.94 82.5,59.94 82.51,59.93 82.63,59.91 82.74,59.95 82.76,59.96 83.88,59.96
+1.35V on TOP (solid shape): 21.54,37.41 21.85,37.11 22.43,37.11 22.52,37.02 22.52,36.71 22.42,36.62 21.23,36.62 21.12,36.73 21.12,37.64 21.25,37.78 21.54,37.78
+1.35V on TOP (solid shape): 92.18,32.36 92.55,31.99 93.21,31.99 93.28,31.92 93.28,31.6 93.21,31.54 91.99,31.54 91.8,31.72 91.8,32.58 91.92,32.69 92.18,32.69
+1.35V on TOP (solid shape): 70.18,32.59 70.18,32.26 70.39,32.05 71.05,32.05 71.11,31.98 71.11,31.64 71.01,31.54 69.87,31.54 69.76,31.65 69.76,32.51 69.96,32.72 70.06,32.72
+1.35V on TOP (solid shape): 81.23,32.78 81.23,32.26 81.45,32.04 82.11,32.04 82.2,31.95 82.2,31.64 82.1,31.54 80.92,31.54 80.81,31.65 80.81,32.7 80.88,32.75 80.94,32.82 81.19,32.82
+1.35V on TOP (solid shape): 54.64,37.67 54.69,37.58 54.69,37.34 54.91,37.12 55.57,37.12 55.68,37.01 55.68,36.7 55.59,36.62 54.38,36.62 54.26,36.73 54.26,37.52 54.29,37.59 54.36,37.62 54.45,37.63 54.54,37.66
+1.35V on TOP (solid shape): 32.49,38.18 32.56,38.15 32.59,38.07 32.59,37.46 32.91,37.15 33.44,37.15 33.66,36.93 33.65,36.91 33.71,36.71 33.96,36.57 33.98,36.5 33.98,36.45 33.98,36.41 33.97,36.37 33.93,36.35 33.87,36.35 33.61,36.62 32.28,36.62 32.17,36.73 32.17,37.78 32.3,37.9 32.35,38.08 32.39,38.15 32.46,38.18
+1.35V on TOP (solid shape): 32.49,38.18 32.56,38.15 32.59,38.07 32.59,37.46 32.91,37.15 33.44,37.15 33.66,36.93 33.65,36.91 33.71,36.71 33.96,36.57 33.98,36.5 33.98,36.45 33.98,36.41 33.97,36.37 33.93,36.35 33.87,36.35 33.61,36.62 32.28,36.62 32.17,36.73 32.17,37.78 32.19,37.79 32.31,37.91 32.35,38.08 32.39,38.15 32.46,38.18
+1.35V on TOP (solid shape): 43.54,38.2 43.61,38.17 43.64,38.1 43.64,37.34 43.86,37.12 44.52,37.12 44.71,36.93 44.7,36.91 44.76,36.71 45.01,36.57 45.03,36.5 45.03,36.45 45.03,36.41 45.02,36.37 44.98,36.35 44.92,36.35 44.66,36.62 43.33,36.62 43.21,36.73 43.21,37.78 43.24,37.79 43.36,37.92 43.4,38.1 43.43,38.17 43.51,38.2
+1.35V on TOP (solid shape): outline of 293 points within 27.12,26.47 30.1,32.29
+1.35V on TOP (solid shape): outline of 14308 points within 18.47,18.67 112.46,42.76
+1.35V on BOTTOM (solid shape): 29.4,37.67 29.4,36.85 29.31,36.76 28.7,36.76 28.63,36.69 28.33,36.69 28.24,36.78 28.24,37.07 28.31,37.14 28.67,37.14 29,37.47 29,37.7 29.06,37.76 29.31,37.76
+1.35V on BOTTOM (solid shape): 62.53,37.8 62.53,36.92 62.37,36.76 61.85,36.76 61.78,36.69 61.43,36.69 61.36,36.76 61.36,37.01 61.44,37.1 61.89,37.1 62.14,37.34 62.14,37.82 62.21,37.9 62.43,37.9
+1.35V on BOTTOM (solid shape): 78.04,32.57 78.04,31.77 77.95,31.68 77.34,31.68 77.27,31.61 76.96,31.61 76.87,31.69 76.87,31.98 76.95,32.06 77.31,32.06 77.64,32.39 77.64,32.61 77.72,32.69 77.92,32.69
+1.35V on BOTTOM (solid shape): 40.05,37.86 40.08,37.9 40.13,37.9 40.16,37.88 40.16,37.49 40.45,37.2 40.45,36.85 40.36,36.76 39.75,36.76 39.68,36.69 39.12,36.69 38.78,36.35 38.72,36.35 38.68,36.37 38.67,36.41 38.68,36.46 38.67,36.5 38.7,36.57 38.94,36.71 39,36.91 39,36.93 39.2,37.14 39.72,37.14 40.05,37.47
+1.35V on BOTTOM (solid shape): 62.14,37.95 62.19,38.03 62.29,38.04 62.36,38.01 62.43,38 62.5,37.97 62.53,37.9 62.53,36.92 62.37,36.76 61.85,36.76 61.78,36.69 61.21,36.69 60.88,36.35 60.82,36.35 60.78,36.37 60.77,36.41 60.77,36.46 60.77,36.5 60.79,36.57 61.04,36.71 61.1,36.91 61.1,36.93 61.26,37.1 61.89,37.1 62.14,37.34
+1.35V on BOTTOM (solid shape): 29,37.78 29.04,37.86 29.14,37.87 29.21,37.85 29.29,37.85 29.37,37.82 29.4,37.75 29.4,36.85 29.31,36.76 28.7,36.76 28.63,36.69 28.07,36.69 27.73,36.35 27.67,36.35 27.63,36.37 27.62,36.41 27.63,36.46 27.63,36.5 27.65,36.57 27.89,36.71 27.95,36.91 27.95,36.93 28.15,37.14 28.67,37.14 29,37.47
+1.35V on BOTTOM (solid shape): 88.69,32.7 88.73,32.78 88.83,32.79 88.9,32.77 88.98,32.77 89.06,32.74 89.09,32.67 89.09,31.77 89,31.68 88.39,31.68 88.32,31.61 87.82,31.61 87.6,31.38 87.53,31.38 87.42,31.27 87.36,31.27 87.32,31.29 87.31,31.33 87.32,31.38 87.32,31.42 87.34,31.49 87.58,31.63 87.64,31.83 87.64,31.85 87.84,32.06 88.36,32.06 88.69,32.39
+1.35V on BOTTOM (solid shape): 77.64,32.7 77.69,32.78 77.78,32.79 77.86,32.77 77.93,32.77 78.01,32.74 78.04,32.67 78.04,31.77 77.95,31.68 77.34,31.68 77.27,31.61 77.03,31.61 76.64,31.21 76.57,31.18 76.5,31.21 76.43,31.25 76.36,31.27 76.29,31.31 76.27,31.38 76.27,31.42 76.29,31.49 76.53,31.63 76.59,31.83 76.59,31.85 76.8,32.06 77.31,32.06 77.64,32.39
+1.35V on BOTTOM (solid shape): outline of 18970 points within 17.58,18.67 112.43,47.97
+1.35V_CPU_VDDQ on TOP (solid shape): outline of 1030 points within 60.43,53.05 74.35,68.03
+1.35V_CPU_VDDQ on BOTTOM (solid shape): 57,47.38 57.79,47.38 58.1,47.08 58.1,46.44 57.97,46.32 56.57,46.32 56.45,46.44 56.45,47.18 56.37,47.26 56.37,47.61 56.45,47.69 56.7,47.69
+1.35V_CPU_VDDQ on BOTTOM (solid shape): 68.74,54.22 68.74,53 69.2,52.54 69.73,52.54 70.95,53.76 73.01,53.76 73.3,53.46 73.3,48.77 72.75,48.22 66.1,48.22 65.88,48.01 65.88,46.66 65.79,46.57 65.29,46.57 65.16,46.7 65.16,47.63 64.83,47.96 64.83,52.9 64.55,53.17 64.55,53.78 65.16,54.39 68.56,54.39
+1.35VS on BOTTOM (solid shape): 65.59,24.92 65.59,21.4 65.36,21.17 57.54,21.17 57.46,21.09 57.46,20.54 57.21,20.28 54.26,20.28 54.13,20.41 54.13,23.84 63.68,23.84 63.69,23.78 63.7,23.73 63.72,23.68 63.75,23.63 63.78,23.58 63.82,23.54 63.87,23.51 63.92,23.49 63.97,23.47 64.02,23.46 64.08,23.46 64.14,23.46 64.19,23.48 64.24,23.5 64.29,23.53 64.33,23.56 64.37,23.6 64.4,23.65 64.42,23.7 64.44,23.75 64.45,23.81 64.45,23.87 64.44,23.92 64.42,23.97 64.4,24.02 64.37,24.07 64.33,24.11 64.29,24.15 64.24,24.18 64.19,24.2 64.14,24.21 64.08,24.22 64.02,24.22 63.97,24.21 63.92,24.19 63.87,24.16 63.82,24.13 63.78,24.09 63.75,24.05 63.72,24 63.7,23.95 63.69,23.89 63.68,23.84 54.13,23.84 54.13,24.12 54.41,24.4 61.2,24.4 63.02,26.23 64.28,26.23
+3V_PCH on TOP (solid shape): 128.58,63.33 128.58,62.57 128.2,62.19 128.2,60.29 128.03,60.11 127.51,60.11 127.44,60.18 127.44,62.57 127.06,62.95 127.06,63.33 127.18,63.46 128.45,63.46
+3V_PCH on TOP (solid shape): 112.71,70.32 112.71,68.03 112.2,67.53 112.2,66.64 111.69,66.13 111.44,66.13 110.67,65.37 110.67,64.64 110.57,64.53 109.48,64.53 109.39,64.62 109.39,65.22 109.79,65.62 110.04,65.62 110.46,66.04 110.46,68.2 110.66,68.4 111.48,68.4 111.82,68.75 111.82,70.32 111.94,70.45 112.58,70.45
+3V_PCH on TOP (solid shape): 122.44,53.67 122.7,53.67 122.72,53.69 123.72,53.69 123.75,53.66 123.75,52.85 123.7,52.81 122.85,52.81 122.65,53.01 122.65,53.01 122.44,53.15 122.21,53.06 122.19,53.05 122.1,53.05 121.85,52.79 121.47,52.79 121.34,52.92 121.34,52.94 121.25,53.04 121.25,53.47 121.14,53.57 120.92,53.57 120.81,53.68 120.81,54.07 120.87,54.13 121.99,54.13
+3V_PCH on TOP (solid shape): 117.17,54.05 117.17,51.57 116.61,51.02 114.56,51.02 114.41,51.17 114.41,51.68 114.42,51.69 114.47,51.99 114.22,52.16 114.2,52.16 114.16,52.21 114.16,52.64 113.91,52.89 113.91,53.3 113.79,53.41 113.79,53.94 113.84,53.99 114.28,53.99 114.31,53.96 114.31,52.83 114.82,52.32 114.82,52.06 115.03,51.85 116.44,51.85 116.59,52.01 116.59,52.11 116.59,52.71 116.51,52.79 115.95,52.79 115.76,52.98 115.76,54.01 115.83,54.09 117.13,54.09
+3V_PCH on BOTTOM (solid shape): 121.91,55.2 121.91,53.65 121.82,53.56 120.2,53.56 119.82,53.94 119.82,55.21 119.95,55.33 121.79,55.33
+3V_PCH on BOTTOM (solid shape): 118.9,51.9 119.69,51.9 119.82,51.78 119.82,51.14 119.69,51.02 118.94,51.02 118.94,51.11 117.09,51.11 116.79,50.81 116.68,50.81 116.58,50.91 116.58,51.2 116.87,51.5 117.28,51.5 117.33,51.54 117.33,51.89 117.5,52.07 118.73,52.07
+3V_PCH on BOTTOM (solid shape): 124.64,85.31 124.64,83.78 124.52,83.65 124.52,82.26 124.39,82.13 123.88,82.13 123.76,82.26 123.76,84.09 123.81,84.09 124.16,84.44 123.81,84.8 123.76,84.8 123.76,85.43 123.88,85.56 124.39,85.56
+3V_PCH on BOTTOM (solid shape): outline of 125 points within 110.04,66.64 112.07,70.45
+3V_PCH on VCC (solid shape): outline of 3528 points within 110.17,51.14 134.04,69.18
+3VALW on TOP (solid shape): 172.4,51.85 172.4,48.83 172.27,48.7 171.28,48.7 171.15,48.83 171.15,51.42 171.66,51.93 172.32,51.93
+3VALW on TOP (solid shape): 172.4,53.86 172.4,53.35 172.32,53.28 170.64,53.28 170.36,53.56 169.48,53.56 169.35,53.68 169.35,54.62 170.19,55.46 170.8,55.46
+3VALW on TOP (solid shape): 174.84,65.87 175.19,65.87 175.83,65.24 180.14,65.24 180.3,65.09 180.3,63.06 180.02,62.78 176.33,62.78 175.11,64 175.01,64 174.05,64.96 174.05,66.05 174.12,66.13 174.58,66.13
+3VALW on BOTTOM (solid shape): 171.23,35.83 171.23,35.14 170.87,34.79 169.12,34.79 168.82,35.09 168.82,35.88 168.87,35.93 171.13,35.93
+3VALW on BOTTOM (solid shape): 123.44,84.34 123.44,81.81 122.41,80.78 121.72,80.78 121.19,80.25 120.91,80.25 120.71,80.45 120.71,84.16 121.05,84.51 123.27,84.51
+3VALW on BOTTOM (solid shape): 180.47,69.02 180.47,67.73 180.49,67.72 180.49,62.59 179.06,62.59 178.87,62.78 178.87,67.14 179,67.27 179.03,67.27 179.92,68.16 179.92,69.02 180.02,69.13 180.37,69.13
+3VALW on BOTTOM (solid shape): 108.52,50.89 108.59,50.86 108.62,50.79 108.83,50.56 109.11,50.72 109.11,50.73 109.27,50.89 110.6,50.89 110.75,50.74 110.75,50.46 111.13,50.08 111.13,49.57 110.95,49.39 110.55,49.39 110.45,49.3 110.42,49.3 110.42,49.26 110.32,49.16 110.32,48.63 109.66,47.97 109.28,47.97 108.17,47.97 108.17,48.33 108.72,48.33 108.72,48.35 108.72,48.83 108.72,48.84 108.17,48.84 108.17,49.13 108.72,49.13 108.72,49.14 108.72,49.62 108.72,49.64 108.17,49.64 108.17,50.11 108.16,50.11 108.16,50.76 108.29,50.89
+3VALW on BOTTOM (solid shape): outline of 624 points within 127.82,46.95 136.07,75.65
+3VALW on IN3 (solid shape): outline of 12764 points within 105.59,34.89 181.29,77.56
+3VALW on IN4 (solid shape): outline of 765 points within 120.83,74.26 138.23,86.23
+3VS on TOP (solid shape): 169.16,69.82 169.16,69.06 169.04,68.94 167.11,68.94 166.95,69.1 166.95,69.6 167.31,69.96 167.31,70.53 167.68,70.9 168.08,70.9
+3VS on TOP (solid shape): 169.85,57.47 169.85,55.92 169.69,55.76 169.22,55.76 169.1,55.88 169.1,56.52 168.97,56.65 168.37,56.65 168.3,56.72 168.3,57.6 168.47,57.76 169.55,57.76
+3VS on TOP (solid shape): 70.42,53.3 70.42,52.19 70.42,52.16 70.16,51.9 69.27,51.9 68.89,52.29 67.24,52.29 67.11,52.41 67.11,53.15 67.13,53.19 67.24,53.3 69.4,53.3 69.53,53.43 70.29,53.43
+3VS on TOP (solid shape): 176.33,51.52 176.33,49.92 176.16,49.75 175.22,49.75 174.81,49.34 174.23,49.34 174.05,49.16 174.05,48.27 173.87,48.09 173.11,48.09 173.01,48.2 173.01,50.58 173.64,51.22 173.64,51.83 173.74,51.93 175.93,51.93
+3VS on TOP (solid shape): 111.56,51.09 111.56,51.02 111.63,51.02 112.15,50.51 112.45,50.51 112.76,50.81 113.09,50.81 113.21,50.69 113.21,50.01 113.08,49.87 111.08,49.87 110.87,50.09 110.87,50.44 110.87,50.47 110.74,50.83 110.37,50.89 110.36,50.89 110,50.89 109.99,50.89 109.86,50.91 109.73,50.89 109.72,50.89 108.64,50.89 108.52,51.02 108.52,51.65 108.64,51.78 110.88,51.78
+3VS on TOP (solid shape): 14.56,29.07 14.56,28.74 14.03,28.21 14.03,28.15 13.97,28.1 13.97,27.27 13.98,27.2 14,27.13 14.03,27.08 14.03,26.94 14.89,26.07 15.15,26.07 15.38,25.83 15.38,25.81 15.38,25.68 15.42,25.56 15.42,25.55 15.42,24.68 15.3,24.55 14.69,24.55 14.54,24.7 14.54,25.11 14.41,25.23 14.03,25.23 13.93,25.33 13.91,25.33 13.05,26.19 13.05,28.12 13.07,28.14 13.65,28.58 14.15,29.1 14.16,29.12 14.51,29.12
+3VS on TOP (solid shape): 81.21,53.68 81.21,52.92 81.08,52.79 80.47,52.79 80.38,52.84 80.38,52.94 80.14,53.49 79.66,53.12 79.63,53.05 79.56,53.02 77.71,53.02 77.53,53.2 77.53,54.09 77.63,54.19 80.7,54.19
+3VS on TOP (solid shape): 174.9,78.61 174.9,77.94 174.64,77.68 174.64,76.12 174.17,75.65 173.7,75.65 173.61,75.7 173.61,75.8 173.29,76.31 172.96,75.8 172.96,75.7 172.87,75.65 172.14,75.65 171.83,75.34 171.17,75.34 171,75.5 171,77.14 172.27,78.41 172.27,78.84 172.89,79.46 174.05,79.46
+3VS on TOP (solid shape): 124.9,81.62 124.9,80.23 127.76,77.37 127.76,76.12 127.62,75.98 126.75,75.98 126.63,76.1 125.86,76.1 125.66,75.9 125.66,73.7 125.58,73.62 124.91,73.62 124.71,73.83 124.57,73.83 124.47,73.89 124.36,73.91 124.24,73.89 124.15,73.83 123.22,73.83 123.02,74.03 123.02,76.26 123.09,76.33 123.82,76.33 124.08,76.59 124.37,76.59 124.77,77 124.97,77 125.08,77.1 125.08,77.68 125.18,77.79 125.38,78.42 124.8,78.11 124.77,78.08 124.48,78.08 123.76,78.8 123.76,80.67 123.84,80.75 123.84,81.22 123.76,81.31 123.76,81.75 123.95,81.95 124.57,81.95
+3VS on BOTTOM (solid shape): 168.45,70.53 168.45,70.14 168.56,70.03 168.56,68.68 168.4,68.52 166.55,68.52 166.28,68.79 166.28,70.57 166.7,70.99 167.99,70.99
+3VS on BOTTOM (solid shape): 169.68,57.67 169.68,55.99 169.52,55.83 169.06,55.83 168.38,56.51 166.66,56.51 166.53,56.64 166.53,57.03 166.64,57.14 168.56,57.14 169.22,57.8 169.55,57.8
