# Allegro board LA8821PR30_MB-1113.brd (continued)
## Nets (continued)
GND: C265.2 C276.2 C277.2 C278.2 C279.2 C280.1 C281.1 C283.2 C284.2 C285.2 C293.2 C303.2 C352.2 C355.2 C612.2 C617.1 C654.2 C655.2 C656.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C719.2 C720.2 C721.2 C722.2 C961.1 C962.2 C963.2 C965.2 C966.2 C968.2 C969.2 C970.2 C974.2 C976.2 C977.2 C978.2 C979.2 C1059.2 C1078.2 C1098.1 C1099.1 C1100.1 C1101.1 C1102.1 C1109.2 C1110.2 C1116.1 C1117.2 C1118.2 C1122.2 C1123.2 C1124.2 C1125.2 C1133.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1143.2 C1145.2 C1146.1 C1151.2 C1152.2 C1153.2 C1154.2 C1155.2 C1156.2 C1157.2 C1158.2 C1159.2 C1160.2 C1161.2 C1162.2 C1163.2 C1164.2 C1165.2 C1167.2 C1168.2 C1169.2 C1170.2 C1171.2 C1172.2 C1173.2 C1174.2 C1175.2 C1176.2 C1177.2 C1178.2 C1179.2 C1180.2 C1181.2 C1182.2 C1183.2 C1184.2 C1185.2 C1186.2 C1187.2 C1188.2 C1189.2 C1190.2 C1191.2 C1192.2 C1193.2 C1194.2 C1195.2 C1196.2 C1197.2 C1198.2 C1199.2 C1200.2 C1204.2 C1205.2 C1206.2 C1207.2 CC65.2 CC68.2 CC69.2 CC138.2 CC139.2 CC160.2 CC161.2 CC162.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC169.2 CC170.2 CC171.2 CC172.2 CC174.2 CC175.2 CC176.2 CC217.2 CC218.2 CC219.2 CC220.2 CC221.2 CC222.2 CC223.2 CC224.2 CC225.2 CC226.2 CC227.2 CC228.2 CC229.2 CC230.2 CC231.2 CC232.2 CC233.2 CC234.2 CC235.2 CC236.2 CC237.2 CC238.2 CC239.2 CC240.2 CC241.2 CC242.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD29.2 CD30.2 CD33.2 CD34.2 CD37.2 CD38.2 CD41.2 CD42.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD113.2 CD114.2 CD115.2 CD116.2 CD117.2 CD118.2 CD119.2 CD120.2 CD123.2 CD124.2 CD125.2 CD126.2 CD127.2 CD128.2 CD129.2 CD132.2 CD133.2 CD135.2 CD136.2 CD139.2 CD140.2 CD142.2 CH2.2 CH3.2 CH4.1 CH5.2 CH6.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH26.2 CH27.2 CH28.2 CH35.2 CH36.2 CH37.2 CH38.2 CH39.2 CH40.2 CH41.2 CH42.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH57.2 CH58.2 CH59.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH80.2 CH81.2 CH82.2 CH83.2 CH84.2 CH85.2 CH86.2 CH87.2 CH88.2 CH89.2 CH94.2 CH95.2 CH99.2 CH102.1 CH103.2 CH107.2 CH116.2 CH117.2 CH118.1 CH1202.2 CH1203.2 CLRP1.1 CLRP2.2 CRF4.2 CRF5.2 CV1.2 CV2.2 CV13.2 CV14.2 CV15.2 D50.2 D74.7 D82.7 D90.2 DE1.1 DE2.1 DV1.3 DV2.3 H1.1(TP-1) H3.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H14.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) JANT1.1 JANT1.3 JANT2.1 JANT2.3 JANT3.1 JANT3.3 JBATT9.1 JBATT9.2 JBATT9.10 JBATT9.11 JBL1.5 JBL1.6 JDCIN1.6 JDCIN1.7 JFAN1.1 JFAN1.5 JFAN1.6 JIOL1.9 JIOL1.10 JIOL1.11 JIOL1.12 JIOL1.13 JIOL1.16 JIOL1.21 JIOL1.22 JIOL1.30 JIOL1.36 JIOL1.37 JIOL1.38 JKB1.30 JKB1.31 JKB1.32 JLVDS1.1 JLVDS1.4 JLVDS1.7 JLVDS1.11 JLVDS1.12 JLVDS1.20 JLVDS1.21 JLVDS1.22 JLVDS1.23 JLVDS1.24 JLVDS2.1 JLVDS2.11 JLVDS2.15 JLVDS2.16 JLVDS2.20 JLVDS2.21 JLVDS2.22 JLVDS2.23 JLVDS2.24 JMDP1.1 JMDP1.7 JMDP1.8 JMDP1.13 JMDP1.14 JMDP1.19 JMDP1.21 JMDP1.22 JMDP1.23 JMDP1.24 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.4 JSATA1.9 JSATA1.15 JSATA1.18 JSATA1.21 JSATA1.26 JSATA1.27 JSATA1.29 JSATA1.34 JSATA1.35 JSATA1.37 JSATA1.40 JSATA1.43 JSATA1.50 JSATA1.53 JSATA1.54 JTP1.4 JTP1.7 JTP1.8 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JWLAN1.4 JWLAN1.9 JWLAN1.15 JWLAN1.18 JWLAN1.21 JWLAN1.26 JWLAN1.27 JWLAN1.29 JWLAN1.34 JWLAN1.35 JWLAN1.43 JWLAN1.50 JWLAN1.53 JWLAN1.54 L44.1 PC15.2 PC16.2 PC17.2 PC18.2 PC19.2 PC21.1 PC23.2 PC24.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.1 PC32.2 PC34.2 PC35.2 PC37.1 PC38.2 PC39.2 PC43.2 PC44.2 PC125.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC207.2 PC210.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC221.2 PC222.2 PC224.2 PC300.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.1 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC400.2 PC402.2 PC403.2 PC404.2 PC405.2 PC406.2 PC408.2 PC409.2 PC410.2 PC411.2 PC500.2 PC501.2 PC502.2 PC503.2 PC505.2 PC506.2 PC507.2 PC508.2 PC511.2 PC600.2 PC601.1 PC604.1 PC605.1 PC606.2 PC607.1 PC608.1 PC609.2 PC610.1 PC611.1 PC612.1 PC613.2 PC614.1 PC615.1 PC616.2 PC618.1 PC619.2 PC700.2 PC702.1 PC704.2 PC705.2 PC706.2 PC709.2 PC714.2 PC715.2 PC717.2 PC718.2 PC719.2 PC733.2 PC734.2 PC735.2 PC736.2 PC737.2 PC738.2 PC744.2 PC745.2 PC747.2 PC748.2 PC749.2 PC750.2 PC850.2 PC851.2 PC852.2 PC853.2 PC854.2 PC855.2 PC856.2 PC858.2 PC859.2 PC860.2 PC861.2 PC862.2 PC890.2 PC891.2 PC892.2 PC893.2 PC894.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC909.2 PC910.2 PC911.2 PC913.2 PC914.2 PC915.2 PC916.2 PC980.2 PC981.2 PC984.2 PC986.2 PC987.2 PC990.2 PC991.2 PC993.2 PC994.2 PC995.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1256.2 PC1257.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1269.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1285.2 PC1286.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1900.2 PC1901.2 PC1903.2 PC1908.2 PC1909.2 PC1910.2 PC1911.2 PC1912.2 PC1913.2 PC1914.2 PC1916.2 PC1917.2 PC1918.2 PC1921.2 PD11.2 PD901.2 PD902.1 PD904.1 PD905.1 PH901.2 PJP205.2 PL903.1 PQ7.3 PQ204.1 PQ204.4 PQ901.3 PQ904.3 PQ908.3 PQ1208.1 PQ1208.2 PQ1208.3 PQ1210.1 PQ1210.2 PQ1210.3 PQ1217.5 PQ1217.6 PQ1217.7 PQ1218.5 PQ1218.6 PQ1218.7 PQ1219.1 PQ1219.2 PQ1219.3 PQ1221.1 PQ1221.2 PQ1221.3 PQ1226.1 PQ1226.2 PQ1226.3 PQ1227.3 PQ1228.1 PQ1228.4 PR19.2 PR28.2 PR34.2 PR40.2 PR47.1 PR202.1 PR203.2 PR212.2 PR307.2 PR403.2 PR404.2 PR407.2 PR409.2 PR502.1 PR505.2 PR509.1 PR510.1 PR600.2 PR602.2 PR606.2 PR607.1 PR701.2 PR708.2 PR726.1 PR734.2 PR905.2 PR906.1 PR918.2 PR937.1 PR958.2 PR959.1 PR968.1 PR970.2 PU2.15 PU2.22 PU2.29 PU300.1 PU300.3 PU300.14 PU300.21 PU400.11 PU401.11 PU500.11 PU501.21 PU600.1 PU600.19 PU600.20 PU600.21 PU600.25 PU700.41 PU702.2 Q4.3 Q5.3 Q32.3 Q34.3 Q35.1 Q35.4 Q37.3 Q38.3 Q42.3 Q71.3 Q305.1 Q305.4 Q311.3 Q316.1 Q316.4 Q317.1 Q317.4 Q318.1 Q318.4 Q319.1 Q319.4 Q320.1 Q320.4 Q321.3 Q330.3 Q333.3 Q334.3 Q336.3 QC1.3 QC4.1 QC4.4 QC5.3 R225.1 R290.2 R540.2 R545.2 R607.1 R608.1 R730.2 R809.2 R819.1 R923.2 R924.1 R928.2 R929.1 R941.1 R945.1 R980.2 R1026.2 R1027.2 R1032.1 R1034.1 R1035.2 R1099.1 R1100.1 R1108.1 RC34.2 RC44.1 RC52.2 RC54.2 RC55.2 RC58.2 RC60.2 RC77.2 RC78.2 RC81.2 RC86.2 RC87.2 RC89.2 RC100.1 RC103.2 RC105.2 RC116.2 RC129.1 RC136.2 RC138.2 RC141.2 RC142.1 RC143.2 RC144.2 RD1.2 RD2.2 RD3.2 RD4.2 RD5.2 RD6.2 RD7.2 RD8.2 RD9.2 RD10.2 RD11.2 RD12.2 RD13.2 RD14.2 RD15.2 RD16.2 RD19.2 RD20.2 RD25.2 RD26.2 RD29.2 RD32.2 RD39.1 RD40.1 RD41.1 RH34.1 RH44.2 RH45.2 RH46.2 RH48.2 RH53.2 RH76.2 RH77.2 RH78.2 RH79.2 RH80.2 RH81.2 RH82.2 RH83.2 RH84.2 RH123.1 RH125.1 RH140.2 RH151.1 RH158.1 RH159.2 RH163.2 RH171.2 RH177.1 RH182.1 RH183.1 RH186.1 RH272.2 RH275.1 RH291.2 RH295.2 RH299.2 RH300.1 RH306.2 RH314.1 RH315.1 RH316.1 RH337.2 RH338.1 RH339.1 RV3.2 RV4.2 RV9.2 RV10.2 SW1.2 SW1.4 SW2.3 SW2.4 U34.G2 U34.J8 U34.J9 U34.J10 U34.N13 U48.4 U635.3 U636.A7 U636.B1 U636.E7 U636.F5 U636.H2 U636.H3 U637.7 U637.10 U637.11 U638.4 U638.8 U638.9 U638.10 U638.11 U638.12 U638.13 U652.1 U652.2 U652.3 U652.4 U652.8 U652.9 U652.11 U652.18 U652.25 U654.11 U654.15 U655.11 U655.15 U656.1 U657.1 UC1.3 UC2.3 UCPU1.A5 UCPU1.A9 UCPU1.A13 UCPU1.A17 UCPU1.A21 UCPU1.A25 UCPU1.A28 UCPU1.A33 UCPU1.A37 UCPU1.A40 UCPU1.A45 UCPU1.A49 UCPU1.A53 UCPU1.A57 UCPU1.AA1 UCPU1.AA8 UCPU1.AA13 UCPU1.AA50 UCPU1.AA51 UCPU1.AA52 UCPU1.AA53 UCPU1.AA55 UCPU1.AA56 UCPU1.AB16 UCPU1.AB18 UCPU1.AB21 UCPU1.AB48 UCPU1.AB61 UCPU1.AC6 UCPU1.AC10 UCPU1.AC14 UCPU1.AC46 UCPU1.AD4 UCPU1.AD17 UCPU1.AD20 UCPU1.AD61 UCPU1.AE8 UCPU1.AE13 UCPU1.AF1 UCPU1.AF17 UCPU1.AF21 UCPU1.AF47 UCPU1.AF48 UCPU1.AF50 UCPU1.AF51 UCPU1.AF52 UCPU1.AF53 UCPU1.AF55 UCPU1.AF56 UCPU1.AF58 UCPU1.AF59 UCPU1.AG7 UCPU1.AG10 UCPU1.AG14 UCPU1.AG18 UCPU1.AG47 UCPU1.AG52 UCPU1.AG61 UCPU1.AH4 UCPU1.AH58 UCPU1.AJ7 UCPU1.AJ13 UCPU1.AJ16 UCPU1.AJ20 UCPU1.AJ22 UCPU1.AJ26 UCPU1.AJ30 UCPU1.AJ34 UCPU1.AJ38 UCPU1.AJ42 UCPU1.AJ45 UCPU1.AJ48 UCPU1.AK1 UCPU1.AK52 UCPU1.AL10 UCPU1.AL13 UCPU1.AL17 UCPU1.AL21 UCPU1.AL25 UCPU1.AL28 UCPU1.AL33 UCPU1.AL36 UCPU1.AL40 UCPU1.AL43 UCPU1.AL47 UCPU1.AL61 UCPU1.AM4 UCPU1.AM13 UCPU1.AM20 UCPU1.AM22 UCPU1.AM26 UCPU1.AM30 UCPU1.AM34 UCPU1.AM38 UCPU1.AM42 UCPU1.AM45 UCPU1.AM48 UCPU1.AM58 UCPU1.AN1 UCPU1.AN21 UCPU1.AN25 UCPU1.AN28 UCPU1.AN33 UCPU1.AN36 UCPU1.AN40 UCPU1.AN43 UCPU1.AN47 UCPU1.AN50 UCPU1.AN54 UCPU1.AP7 UCPU1.AP10 UCPU1.AP51 UCPU1.AP55 UCPU1.AR7 UCPU1.AR13 UCPU1.AR17 UCPU1.AR21 UCPU1.AR41 UCPU1.AR48 UCPU1.AR61 UCPU1.AT4 UCPU1.AT14 UCPU1.AT19 UCPU1.AT36 UCPU1.AT45 UCPU1.AT52 UCPU1.AT58 UCPU1.AU1 UCPU1.AU7 UCPU1.AU11 UCPU1.AU28 UCPU1.AU32 UCPU1.AU51 UCPU1.AV17 UCPU1.AV21 UCPU1.AV22 UCPU1.AV34 UCPU1.AV40 UCPU1.AV48 UCPU1.AV55 UCPU1.AW7 UCPU1.AW13 UCPU1.AW43 UCPU1.AW61 UCPU1.AY4 UCPU1.AY9 UCPU1.AY14 UCPU1.AY19 UCPU1.AY30 UCPU1.AY36 UCPU1.AY41 UCPU1.AY45 UCPU1.AY49 UCPU1.AY55 UCPU1.AY58 UCPU1.BA1 UCPU1.BA11 UCPU1.BA17 UCPU1.BA21 UCPU1.BA26 UCPU1.BA32 UCPU1.BA48 UCPU1.BA51 UCPU1.BB53 UCPU1.BC5 UCPU1.BC13 UCPU1.BC57 UCPU1.BC61 UCPU1.BD3 UCPU1.BD8 UCPU1.BD12 UCPU1.BD16 UCPU1.BD19 UCPU1.BD23 UCPU1.BD27 UCPU1.BD32 UCPU1.BD36 UCPU1.BD40 UCPU1.BD44 UCPU1.BD48 UCPU1.BD52 UCPU1.BD56 UCPU1.BD59 UCPU1.BE4 UCPU1.BE5 UCPU1.BE58 UCPU1.BG5 UCPU1.BG9 UCPU1.BG13 UCPU1.BG17 UCPU1.BG21 UCPU1.BG24 UCPU1.BG28 UCPU1.BG37 UCPU1.BG41 UCPU1.BG45 UCPU1.BG49 UCPU1.BG53 UCPU1.BG57 UCPU1.C3 UCPU1.C29 UCPU1.C35 UCPU1.C40 UCPU1.C58 UCPU1.D4 UCPU1.D6 UCPU1.D10 UCPU1.D14 UCPU1.D18 UCPU1.D22 UCPU1.D26 UCPU1.D29 UCPU1.D35 UCPU1.D40 UCPU1.D43 UCPU1.D46 UCPU1.D50 UCPU1.D54 UCPU1.D58 UCPU1.D59 UCPU1.E1 UCPU1.E3 UCPU1.E25 UCPU1.E29 UCPU1.E35 UCPU1.E40 UCPU1.E61 UCPU1.F13 UCPU1.F15 UCPU1.F19 UCPU1.F29 UCPU1.F35 UCPU1.F40 UCPU1.F55 UCPU1.G6 UCPU1.G48 UCPU1.G51 UCPU1.G61 UCPU1.H4 UCPU1.H10 UCPU1.H14 UCPU1.H17 UCPU1.H21 UCPU1.H53 UCPU1.H58 UCPU1.J1 UCPU1.J49 UCPU1.J55 UCPU1.K8 UCPU1.K11 UCPU1.K21 UCPU1.K51 UCPU1.L16 UCPU1.L20 UCPU1.L22 UCPU1.L26 UCPU1.L30 UCPU1.L34 UCPU1.L38 UCPU1.L43 UCPU1.L48 UCPU1.L61 UCPU1.M4 UCPU1.M6 UCPU1.M11 UCPU1.M15 UCPU1.M58 UCPU1.N1 UCPU1.N17 UCPU1.N21 UCPU1.N25 UCPU1.N28 UCPU1.N33 UCPU1.N36 UCPU1.N40 UCPU1.N43 UCPU1.N47 UCPU1.N48 UCPU1.N51 UCPU1.N52 UCPU1.N56 UCPU1.N61 UCPU1.P9 UCPU1.P14 UCPU1.P16 UCPU1.P18 UCPU1.P21 UCPU1.P58 UCPU1.P59 UCPU1.R4 UCPU1.R17 UCPU1.R20 UCPU1.R46 UCPU1.T1 UCPU1.T47 UCPU1.T50 UCPU1.T51 UCPU1.T52 UCPU1.T53 UCPU1.T55 UCPU1.T56 UCPU1.U8 UCPU1.U13 UCPU1.V20 UCPU1.V61 UCPU1.W8 UCPU1.W13 UCPU1.W15 UCPU1.W18 UCPU1.W21 UCPU1.W46 UCPU1.Y4 UCPU1.Y47 UCPU1.Y58 UCPU1.Y59 UD1.A1 UD1.A8 UD1.B1 UD1.B2 UD1.B7 UD1.B8 UD1.C9 UD1.D1 UD1.D8 UD1.D9 UD1.F2 UD1.F8 UD1.J1 UD1.J9 UD1.L1 UD1.L9 UD1.N1 UD1.N9 UD2.A1 UD2.A8 UD2.B1 UD2.B2 UD2.B7 UD2.B8 UD2.C9 UD2.D1 UD2.D8 UD2.D9 UD2.F2 UD2.F8 UD2.J1 UD2.J9 UD2.L1 UD2.L9 UD2.N1 UD2.N9 UD3.A1 UD3.A8 UD3.B1 UD3.B2 UD3.B7 UD3.B8 UD3.C9 UD3.D1 UD3.D8 UD3.D9 UD3.F2 UD3.F8 UD3.J1 UD3.J9 UD3.L1 UD3.L9 UD3.N1 UD3.N9 UD4.A1 UD4.A8 UD4.B1 UD4.B2 UD4.B7 UD4.B8 UD4.C9 UD4.D1 UD4.D8 UD4.D9 UD4.F2 UD4.F8 UD4.J1 UD4.J9 UD4.L1 UD4.L9 UD4.N1 UD4.N9 UD5.A1 UD5.A8 UD5.B1 UD5.B2 UD5.B7 UD5.B8 UD5.C9 UD5.D1 UD5.D8 UD5.D9 UD5.F2 UD5.F8 UD5.J1 UD5.J9 UD5.L1 UD5.L9 UD5.N1 UD5.N9 UD6.A1 UD6.A8 UD6.B1 UD6.B2 UD6.B7 UD6.B8 UD6.C9 UD6.D1 UD6.D8 UD6.D9 UD6.F2 UD6.F8 UD6.J1 UD6.J9 UD6.L1 UD6.L9 UD6.N1 UD6.N9 UD7.A1 UD7.A8 UD7.B1 UD7.B2 UD7.B7 UD7.B8 UD7.C9 UD7.D1 UD7.D8 UD7.D9 UD7.F2 UD7.F8 UD7.J1 UD7.J9 UD7.L1 UD7.L9 UD7.N1 UD7.N9 UD8.A1 UD8.A8 UD8.B1 UD8.B2 UD8.B7 UD8.B8 UD8.C9 UD8.D1 UD8.D8 UD8.D9 UD8.F2 UD8.F8 UD8.J1 UD8.J9 UD8.L1 UD8.L9 UD8.N1 UD8.N9 UD9.A1 UD9.A8 UD9.B1 UD9.B2 UD9.B7 UD9.B8 UD9.C9 UD9.D1 UD9.D8 UD9.D9 UD9.F2 UD9.F8 UD9.J1 UD9.J9 UD9.L1 UD9.L9 UD9.N1 UD9.N9 UD10.A1 UD10.A8 UD10.B1 UD10.B2 UD10.B7 UD10.B8 UD10.C9 UD10.D1 UD10.D8 UD10.D9 UD10.F2 UD10.F8 UD10.J1 UD10.J9 UD10.L1 UD10.L9 UD10.N1 UD10.N9 UD11.A1 UD11.A8 UD11.B1 UD11.B2 UD11.B7 UD11.B8 UD11.C9 UD11.D1 UD11.D8 UD11.D9 UD11.F2 UD11.F8 UD11.J1 UD11.J9 UD11.L1 UD11.L9 UD11.N1 UD11.N9 UD12.A1 UD12.A8 UD12.B1 UD12.B2 UD12.B7 UD12.B8 UD12.C9 UD12.D1 UD12.D8 UD12.D9 UD12.F2 UD12.F8 UD12.J1 UD12.J9 UD12.L1 UD12.L9 UD12.N1 UD12.N9 UD13.A1 UD13.A8 UD13.B1 UD13.B2 UD13.B7 UD13.B8 UD13.C9 UD13.D1 UD13.D8 UD13.D9 UD13.F2 UD13.F8 UD13.J1 UD13.J9 UD13.L1 UD13.L9 UD13.N1 UD13.N9 UD14.A1 UD14.A8 UD14.B1 UD14.B2 UD14.B7 UD14.B8 UD14.C9 UD14.D1 UD14.D8 UD14.D9 UD14.F2 UD14.F8 UD14.J1 UD14.J9 UD14.L1 UD14.L9 UD14.N1 UD14.N9 UD15.A1 UD15.A8 UD15.B1 UD15.B2 UD15.B7 UD15.B8 UD15.C9 UD15.D1 UD15.D8 UD15.D9 UD15.F2 UD15.F8 UD15.J1 UD15.J9 UD15.L1 UD15.L9 UD15.N1 UD15.N9 UD16.A1 UD16.A8 UD16.B1 UD16.B2 UD16.B7 UD16.B8 UD16.C9 UD16.D1 UD16.D8 UD16.D9 UD16.F2 UD16.F8 UD16.J1 UD16.J9 UD16.L1 UD16.L9 UD16.N1 UD16.N9 UD17.3 UD17.4 UD18.3 UD18.4 UH1.AA7 UH1.AA9 UH1.AA11 UH1.AA39 UH1.AA41 UH1.AA43 UH1.AA45 UH1.AB2 UH1.AB4 UH1.AB17 UH1.AB25 UH1.AB33 UH1.AB35 UH1.AB37 UH1.AB48 UH1.AB50 UH1.AC7 UH1.AC9 UH1.AC11 UH1.AC17 UH1.AC25 UH1.AC33 UH1.AC41 UH1.AC43 UH1.AC45 UH1.AE7 UH1.AE9 UH1.AE11 UH1.AE13 UH1.AE15 UH1.AE17 UH1.AE25 UH1.AE33 UH1.AE35 UH1.AE41 UH1.AE43 UH1.AE45 UH1.AF2 UH1.AF4 UH1.AF8 UH1.AF19 UH1.AF25 UH1.AF27 UH1.AF29 UH1.AF31 UH1.AF33 UH1.AF35 UH1.AF37 UH1.AF48 UH1.AF50 UH1.AG7 UH1.AG9 UH1.AG11 UH1.AG17 UH1.AG19 UH1.AG29 UH1.AG31 UH1.AG33 UH1.AG35 UH1.AG37 UH1.AG39 UH1.AG41 UH1.AG43 UH1.AG45 UH1.AH2 UH1.AH10 UH1.AH12 UH1.AJ7 UH1.AJ9 UH1.AJ11 UH1.AJ19 UH1.AJ33 UH1.AJ35 UH1.AJ37 UH1.AJ39 UH1.AJ41 UH1.AJ43 UH1.AJ45 UH1.AK2 UH1.AK4 UH1.AK10 UH1.AK12 UH1.AK17 UH1.AK19 UH1.AK23 UH1.AK25 UH1.AK27 UH1.AK35 UH1.AK37 UH1.AK48 UH1.AK50 UH1.AL7 UH1.AL9 UH1.AL11 UH1.AL39 UH1.AL41 UH1.AL43 UH1.AL45 UH1.AM15 UH1.AM19 UH1.AM25 UH1.AM29 UH1.AM31 UH1.AM37 UH1.AP2 UH1.AP4 UH1.AP7 UH1.AP9 UH1.AP11 UH1.AP17 UH1.AP21 UH1.AP23 UH1.AP25 UH1.AP29 UH1.AP31 UH1.AP33 UH1.AP35 UH1.AP37 UH1.AP41 UH1.AP43 UH1.AP45 UH1.AP48 UH1.AP50 UH1.AR6 UH1.AR8 UH1.AR17 UH1.AR19 UH1.AR21 UH1.AR31 UH1.AR35 UH1.AR37 UH1.AT7 UH1.AT9 UH1.AT11 UH1.AT39 UH1.AT41 UH1.AT43 UH1.AT45 UH1.AU17 UH1.AU37 UH1.AV2 UH1.AV4 UH1.AV48 UH1.AV50 UH1.AW7 UH1.AW9 UH1.AW11 UH1.AW13 UH1.AW23 UH1.AW25 UH1.AW27 UH1.AW29 UH1.AW36 UH1.AW39 UH1.AW41 UH1.AW43 UH1.AW45 UH1.AY10 UH1.B6 UH1.B10 UH1.B14 UH1.B18 UH1.B22 UH1.B26 UH1.B30 UH1.B34 UH1.B38 UH1.B42 UH1.B46 UH1.BA7 UH1.BA9 UH1.BA11 UH1.BA13 UH1.BA16 UH1.BA18 UH1.BA21 UH1.BA23 UH1.BA25 UH1.BA27 UH1.BA29 UH1.BA31 UH1.BA34 UH1.BA36 UH1.BA39 UH1.BA41 UH1.BA43 UH1.BA45 UH1.BB2 UH1.BB4 UH1.BB48 UH1.BB50 UH1.BC11 UH1.BC13 UH1.BC16 UH1.BC18 UH1.BC21 UH1.BC23 UH1.BC25 UH1.BC27 UH1.BC29 UH1.BC31 UH1.BC34 UH1.BC36 UH1.BC39 UH1.BC41 UH1.BC43 UH1.BC45 UH1.BD15 UH1.BD24 UH1.BE7 UH1.BE9 UH1.BE11 UH1.BE13 UH1.BE16 UH1.BE18 UH1.BE21 UH1.BE23 UH1.BE25 UH1.BE27 UH1.BE29 UH1.BE31 UH1.BE34 UH1.BE36 UH1.BE39 UH1.BE41 UH1.BE43 UH1.BE45 UH1.BF2 UH1.BF4 UH1.BF15 UH1.BF24 UH1.BF48 UH1.BF50 UH1.BH6 UH1.BH10 UH1.BH14 UH1.BH18 UH1.BH22 UH1.BH26 UH1.BH28 UH1.BH30 UH1.BH32 UH1.BH34 UH1.BH38 UH1.BH42 UH1.BH44 UH1.BH46 UH1.BH48 UH1.BK10 UH1.BK14 UH1.BK18 UH1.BK22 UH1.BK26 UH1.BK30 UH1.BK32 UH1.BK34 UH1.BK38 UH1.BK42 UH1.BK46 UH1.D6 UH1.D10 UH1.D14 UH1.D18 UH1.D22 UH1.D26 UH1.D30 UH1.D34 UH1.D38 UH1.D42 UH1.D46 UH1.F2 UH1.F4 UH1.F48 UH1.F50 UH1.G7 UH1.G9 UH1.G11 UH1.G13 UH1.G16 UH1.G18 UH1.G21 UH1.G23 UH1.G25 UH1.G27 UH1.G29 UH1.G31 UH1.G34 UH1.G36 UH1.G39 UH1.G41 UH1.G43 UH1.J7 UH1.J9 UH1.J11 UH1.J13 UH1.J16 UH1.J18 UH1.J21 UH1.J23 UH1.J25 UH1.J27 UH1.J29 UH1.J31 UH1.J34 UH1.J36 UH1.J39 UH1.J41 UH1.J45 UH1.K2 UH1.K4 UH1.K48 UH1.K50 UH1.L7 UH1.L9 UH1.L11 UH1.L13 UH1.L16 UH1.L18 UH1.L21 UH1.L23 UH1.L25 UH1.L27 UH1.L29 UH1.L31 UH1.L34 UH1.L36 UH1.L39 UH1.L41 UH1.L43 UH1.L45 UH1.N7 UH1.N9 UH1.N11 UH1.N13 UH1.N21 UH1.N23 UH1.N25 UH1.N29 UH1.N31 UH1.N34 UH1.N39 UH1.N41 UH1.N43 UH1.N45 UH1.P2 UH1.P4 UH1.P48 UH1.P50 UH1.R17 UH1.R21 UH1.R31 UH1.R37 UH1.T7 UH1.T9 UH1.T11 UH1.T13 UH1.T41 UH1.T43 UH1.T45 UH1.T48 UH1.U31 UH1.U49 UH1.V2 UH1.V4 UH1.V7 UH1.V9 UH1.V11 UH1.V15 UH1.V17 UH1.V27 UH1.V29 UH1.V33 UH1.V35 UH1.V41 UH1.V43 UH1.V45 UH1.V48 UH1.V50 UH1.Y15 UH1.Y17 UH1.Y33 UH1.Y35 UH1.Y37 UH5.3 UI1.9 URF1.2 UV1.8 UV1.15 YH2.2 YH2.4
VCC_AXG_SENSE: PC702.2 PC707.1 PR702.1 PR705.2 RC135.2 UCPU1.F45
VCC_DIE_SENSE: RC142.2 UCPU1.F48
VCCIO_SENSE: PR508.1 RC126.2 UCPU1.AN16
VCCSA_SENSE: PR610.1 UCPU1.U10
VCCSA_VID0: PC619.1 PR602.1 PU600.14 UCPU1.D48
VCCSA_VID1: PR600.1 PU600.15 UCPU1.D49
VCCSENSE: PC737.1 PC739.2 PR733.2 PR737.1 RC97.2 RC98.2
VCCSENSE_R: RC98.1 UCPU1.F43
VDD_1.35V: PC310.1 PR301.1 PR303.2 PU300.11
VDDPWRGOOD: RC8.2 RC19.2 RC57.1 UC1.4
VDDPWRGOOD_R: RC57.2 UCPU1.BE45
VIN: PC41.1 PC902.1 PC903.1 PD10.2 PL900.2 PQ102.1 PQ102.2 PQ102.3 PR16.2 PR18.1 PR942.1 PR964.2 PR965.2 PR966.2
VSS_AXG_SENSE: PC706.1 PC707.2 PU700.39 RC136.1 UCPU1.G45
VSSIO_SENSE: PR509.2 RC129.2 UCPU1.AN17
VSSSENSE: PC738.1 PC739.1 PU700.16 RC99.2 RC100.2
8243_TON: PR19.1 PU501.3
+DDR_CHG: Q38.1 R293.2
+EC_VCCA: C282.1 L43.2 U34.B11
+EDP_COM: RC36.2 UCPU1.AD2 UCPU1.AF3
+INV_PWR_SRC: C612.1 JLVDS1.15 JLVDS1.16 Q70.1 Q70.2 Q70.5 Q70.6 R531.2 R541.1
+LCDVDD: C1143.1 C1145.1 C1165.1 JLVDS2.12 JLVDS2.13 U654.8 U654.9
+LCDVDD_R: Q71.2 Q305.2 R538.1
+PCH_V5REF_RUN: CH64.1 DH3.1 RH227.2 UH1.N36
+PCH_V5REF_SUS: CH56.1 DH2.1 RH222.2 UH1.M37
+PCH_VCCDSW: CH51.1 UH1.R10
+RTCBATT: JRTC1.1 RH259.2
+RTCVCC: CH82.1 CH83.1 CH84.1 CH95.1 DH4.1 JIOL1.8 PR104.2 R1101.1 RH11.1 RH23.1 RH25.1 RH31.1 RH147.1 UH1.N16
+V_SM_VREF: QC6.3 RC106.2 RC112.2 RC116.1 RC141.1 RCU1.2 UCPU1.AY43
+VREFCA_A: CD113.1 CD114.1 RD17.2 RD19.1 UD1.J8 UD2.J8 UD3.J8 UD4.J8 UD5.J8 UD6.J8 UD7.J8 UD8.J8
+VREFCA_B: CD115.1 CD116.1 RD18.2 RD20.1 UD9.J8 UD10.J8 UD11.J8 UD12.J8 UD13.J8 UD14.J8 UD15.J8 UD16.J8
+VREFDQ_A: CD117.1 CD118.1 QC6.1 QD1.1 RCU1.1 RD21.2 RD25.1 RD27.1 UD1.E1 UD2.E1 UD3.E1 UD4.E1 UD5.E1 UD6.E1 UD7.E1 UD8.E1
+VREFDQ_B: CD119.1 CD120.1 QD2.1 RD22.2 RD26.1 RD30.1 UD9.E1 UD10.E1 UD11.E1 UD12.E1 UD13.E1 UD14.E1 UD15.E1 UD16.E1
+VSBP: PC909.1 PJP702.1 PQ903.1 RC101.1
AC_PRESENT: RH137.2 RH150.1 U34.E5
AC_PRESENT_R: RH137.1 UH1.H19
ACC_INT1: R1108.2 U636.F6 U637.5
ACC_INT2: U636.E4 U637.4
ACIN: C1116.2 PR954.1 PR967.1 R924.2 U34.F5
AD_BID0: C283.1 R219.1 R225.2 U34.A12
ADET: PC39.1 PD11.1 PQ7.1 PR18.2 PR28.1 PU2.3
ADP_I: PC38.1 PR936.2 PU2.9 U34.B12
ADPIN: JDCIN1.2 JDCIN1.3 PC900.1 PC901.1 PL900.1
AGATE: PR20.2 PU2.1
ALS_SMBCLK: JLVDS2.7 R983.1 R985.1
ALS_SMBDATA: JLVDS2.8 R984.1 R986.1
AOAC_THERMAL: R927.2 R928.1 U34.D7
APWROK_R: RH131.2 UH1.G3
AUD_MUTE#: JIOL1.17 U34.N12
B+: C613.1 PC24.1 PC25.1 PC26.1 PC43.1 PC44.1 PC908.1 PC1912.1 PC1913.1 PC1917.1 PC1921.1 PJP200.2 PJP301.2 PJP500.1 PJP700.1 PJP701.1 PJP702.2 PL1211.2 PQ903.3 PR25.4 PR908.1 Q70.4 R531.1 R535.1
B++: PC201.1 PC202.1 PC203.1 PC204.1 PC206.1 PC207.1 PC216.1 PD200.1 PJP200.1 PQ1207.5 PQ1209.5 PR219.1 PU501.11
BATBTN#: C1122.1 D84.1 R937.2 SW1.1 SW1.3 U34.B4
BATT+: PC904.1 PC905.1 PD5.2 PL902.1 PQ103.5 PQ103.6 PQ103.7 PQ103.8 PR47.2
BATT++: JBATT9.8 JBATT9.9 PC906.1 PC907.1 PL902.2
BATT_CHG_LED#: JIOL1.25 U34.A4
BATT_LED#_LV1: Q316.2 R906.1 U34.B10
BATT_LED#_LV2: Q317.2 R908.1 U34.B9
BATT_LED#_LV3: Q318.2 R914.1 U34.K2
BATT_LED#_LV4: Q319.2 R917.1 U34.J2
BATT_LED#_LV5: Q320.2 R919.1 U34.M6
BATT_LED_LV1: Q316.3 R910.2
BATT_LED_LV2: Q317.3 R911.2
BATT_LED_LV3: Q318.3 R912.2
BATT_LED_LV4: Q319.3 R913.2
BATT_LED_LV5: Q320.3 R916.2
BATT_LOW_LED#: JIOL1.23 U34.A2
BATT_PRS: JBATT9.5 PD905.2 PR915.1
BBS_BIT0_R: RH276.2 UH1.R1
BBS_BIT1: RH291.1 UH1.F42
BEEP#: JIOL1.15 U34.M8
BGATE: PR46.1 PU2.16
BKOFF#: D72.2 U34.E1
BMON: PC1914.1 PR960.2 U34.A13
BMON_OUT: PR960.1 PU702.6
BOOT: PR23.1 PU2.25
BOOT0: R819.2 R1092.1 U636.A6
BOOT1: PR742.1 PU700.20
BOOT1G: PR710.1 PU700.31
BOOT_1.35V: PR300.2 PU300.18
BST1_3V: PC208.1 PR206.1
BST1_5V: PC209.2 PR207.2
BST_3V: PR206.2 PU501.7
BST_5V: PR207.1 PU501.19
BST_+V1.05S_VCCPP: PR501.1 PU500.10
BT_RADIO_DIS#: R731.1 RH294.1 UH1.R3
BUF_CPU_RST#: RC33.2 RC34.1 UCPU1.D44
BUFO_CPU_RST#: RC32.2 RC33.1 RC130.2 UC2.4
CAB_DET_SINK: JMDP1.4 RV8.2 RV9.1
CAPS_LED: JKB1.27 R943.2
CAPS_LED#: Q326.3 R990.1 U34.B3
CFG0: T232.1(TP-1) UCPU1.B50
CFG1: T208.1(TP-1) UCPU1.C51
CFG2: RC78.1 UCPU1.B54
CFG3: T209.1(TP-1) UCPU1.D53
CFG4: RC81.1 UCPU1.A51
CFG5: RC87.1 UCPU1.C53
CFG6: RC86.1 UCPU1.C55
CFG7: RC89.1 UCPU1.H49
CFG8: T213.1(TP-1) UCPU1.A55
CFG9: T210.1(TP-1) UCPU1.H51
CFG10: T211.1(TP-1) UCPU1.K49
CFG11: T212.1(TP-1) UCPU1.K53
CFG12: T235.1(TP-1) UCPU1.F53
CFG13: T236.1(TP-1) UCPU1.G53
CFG14: T237.1(TP-1) UCPU1.L51
CFG15: T238.1(TP-1) UCPU1.F51
CFG16: T214.1(TP-1) UCPU1.D52
CFG17: T215.1(TP-1) UCPU1.L53
CLK_BCLK_ITP: T240.1(TP-1) UH1.AR10
CLK_BCLK_ITP#: T239.1(TP-1) UH1.AR12
CLK_CPU_DMI: UCPU1.J3 UH1.AY24
CLK_CPU_DMI#: UCPU1.H2 UH1.BB24
CLK_CPU_DPLL: UCPU1.AG3 UH1.AN12
CLK_CPU_DPLL#: UCPU1.AG1 UH1.AN10
CLK_LPC_DEBUG: JWLAN1.19 RH305.1
CLK_PCH_14M: RH84.1 RH86.2 UH1.J49
CLK_PCI0: CH107.1 RH164.1 UH1.G51
CLK_PCI1: CH99.1 RH165.2 UH1.E49
CLK_PCI2: RH305.2 UH1.H48
CLK_PCI3: T166.1(TP-1) UH1.J43
CLK_PCI4: T204.1(TP-1) UH1.G45
CLK_PCI_LPBACK: RH89.2 RH164.2 UH1.E51
CLK_PCI_LPC: R226.1 RH165.1 U34.N5
CLK_PCI_TPM: R976.1 RH296.2 U652.21
CLK_PCIE_MINI1: JWLAN1.13 UH1.AA51
CLK_PCIE_MINI1#: JWLAN1.11 UH1.AA49
CLK_RES_ITP: T233.1(TP-1) UCPU1.N59
CLK_RES_ITP#: T234.1(TP-1) UCPU1.N58
CLK_SMB: JBATT9.7 PD904.2 PR913.1
CLKFLEX0: RH296.1 UH1.H50
CLKIN_DMI: RH79.1 UH1.BF17
CLKIN_DMI2: RH78.1 UH1.AY26
CLKIN_DMI2#: RH76.1 UH1.BB26
CLKIN_DMI#: RH77.1 UH1.BD17
CLKIN_DOT96: RH81.1 UH1.K24
CLKIN_DOT96#: RH80.1 UH1.M24
CLKIN_SATA: RH83.1 UH1.AK6
CLKIN_SATA#: RH82.1 UH1.AK8
COMP: PC729.1 PC730.1 PR734.1 PU700.18
CPU1.5V_S3_GATE: PR323.1 QC6.2 RC11.1 RC107.1 U34.F4
CPU_B+: PC734.1 PC735.1 PC736.1 PC749.1 PC750.1 PC1909.1 PJP701.2 PQ1218.2 PQ1218.3 PQ1218.4 PQ1218.10 PT15.1(TP-1)
CPU_EDP_HPD#: QC5.1 RC137.1 UCPU1.AG11
CPU_RSVD6: RC143.1 UCPU1.H48
CPU_RSVD7: RC144.1 UCPU1.K48
CRT_IREF: RH140.1 UH1.R51
CS_1.35V: PR301.2 PU300.13
CSIN: PC20.2 PC21.2 PR15.2 PU2.27
CSIP: PC19.1 PC20.1 PR14.2 PU2.28
CSON: PC31.2 PR30.1 PU2.17
CSON_B: PR25.2 PR30.2 PR962.2
CSOP: PC31.1 PR29.2 PU2.18
CSOP_B: PR25.3 PR29.1 PR963.1
DAT_SMB: JBATT9.6 PD904.3 PR917.1
DC_TEST_A59_C59: UCPU1.A59 UCPU1.C59
DC_TEST_A61_C61: UCPU1.A61 UCPU1.C61
DC_TEST_BE61_BE59: UCPU1.BE59 UCPU1.BE61
DC_TEST_BG1_BE1: UCPU1.BE1 UCPU1.BG1
DC_TEST_BG3_BE3: UCPU1.BE3 UCPU1.BG3
DC_TEST_C4_D3: UCPU1.C4 UCPU1.D3
DCIN: PC23.1 PR24.2 PU2.2
DCIN_GND: JDCIN1.4 JDCIN1.5 PJP205.1 PL903.2
DDR3_DRAMRST#: RC76.1 UD1.N2 UD2.N2 UD3.N2 UD4.N2 UD5.N2 UD6.N2 UD7.N2 UD8.N2 UD9.N2 UD10.N2 UD11.N2 UD12.N2 UD13.N2 UD14.N2 UD15.N2 UD16.N2
DDR3_DRAMRST#_R: QC2.1 RC74.1 RC75.2 RC76.2
DDR_A_BS0: R1078.1 UCPU1.BD37 UD1.J2 UD2.J2 UD3.J2 UD4.J2 UD5.J2 UD6.J2 UD7.J2 UD8.J2
DDR_A_BS1: R1082.1 UCPU1.BF36 UD1.K8 UD2.K8 UD3.K8 UD4.K8 UD5.K8 UD6.K8 UD7.K8 UD8.K8
DDR_A_BS2: R1080.1 UCPU1.BA28 UD1.J3 UD2.J3 UD3.J3 UD4.J3 UD5.J3 UD6.J3 UD7.J3 UD8.J3
DDR_A_CAS#: R1074.1 UCPU1.BE39 UD1.G3 UD2.G3 UD3.G3 UD4.G3 UD5.G3 UD6.G3 UD7.G3 UD8.G3
DDR_A_CKE0: R1068.1 UCPU1.AY26 UD1.G9 UD2.G9 UD3.G9 UD4.G9 UD5.G9 UD6.G9 UD7.G9 UD8.G9
DDR_A_CS0#: R1072.1 UCPU1.BB40 UD1.H2 UD2.H2 UD3.H2 UD4.H2 UD5.H2 UD6.H2 UD7.H2 UD8.H2
DDR_A_D0: UCPU1.AG6 UD1.E8
DDR_A_D1: UCPU1.AJ6 UD1.C7
DDR_A_D2: UCPU1.AP11 UD1.B3
DDR_A_D3: UCPU1.AL6 UD1.E3
DDR_A_D4: UCPU1.AJ10 UD1.C8
DDR_A_D5: UCPU1.AJ8 UD1.E7
DDR_A_D6: UCPU1.AL8 UD1.D2
DDR_A_D7: UCPU1.AL7 UD1.C2
DDR_A_D8: UCPU1.AR11 UD2.E8
DDR_A_D9: UCPU1.AP6 UD2.E7
DDR_A_D10: UCPU1.AU6 UD2.B3
DDR_A_D11: UCPU1.AV9 UD2.E3
DDR_A_D12: UCPU1.AR6 UD2.C7
DDR_A_D13: UCPU1.AP8 UD2.C8
DDR_A_D14: UCPU1.AT13 UD2.C2
DDR_A_D15: UCPU1.AU13 UD2.D2
DDR_A_D16: UCPU1.BC7 UD3.C7
DDR_A_D17: UCPU1.BB7 UD3.E3
DDR_A_D18: UCPU1.BA13 UD3.B3
DDR_A_D19: UCPU1.BB11 UD3.C2
DDR_A_D20: UCPU1.BA7 UD3.E8
DDR_A_D21: UCPU1.BA9 UD3.E7
DDR_A_D22: UCPU1.BB9 UD3.C8
DDR_A_D23: UCPU1.AY13 UD3.D2
DDR_A_D24: UCPU1.AV14 UD4.C8
DDR_A_D25: UCPU1.AR14 UD4.C7
DDR_A_D26: UCPU1.AY17 UD4.E3
DDR_A_D27: UCPU1.AR19 UD4.D2
DDR_A_D28: UCPU1.BA14 UD4.E8
DDR_A_D29: UCPU1.AU14 UD4.E7
DDR_A_D30: UCPU1.BB14 UD4.B3
DDR_A_D31: UCPU1.BB17 UD4.C2
DDR_A_D32: UCPU1.BA45 UD5.D2
DDR_A_D33: UCPU1.AR43 UD5.C7
DDR_A_D34: UCPU1.AW48 UD5.E7
DDR_A_D35: UCPU1.BC48 UD5.B3
DDR_A_D36: UCPU1.BC45 UD5.C2
DDR_A_D37: UCPU1.AR45 UD5.E3
DDR_A_D38: UCPU1.AT48 UD5.E8
DDR_A_D39: UCPU1.AY48 UD5.C8
DDR_A_D40: UCPU1.BA49 UD6.E7
DDR_A_D41: UCPU1.AV49 UD6.C7
DDR_A_D42: UCPU1.BB51 UD6.B3
DDR_A_D43: UCPU1.AY53 UD6.D2
DDR_A_D44: UCPU1.BB49 UD6.C8
DDR_A_D45: UCPU1.AU49 UD6.E8
DDR_A_D46: UCPU1.BA53 UD6.C2
DDR_A_D47: UCPU1.BB55 UD6.E3
DDR_A_D48: UCPU1.BA55 UD7.E8
DDR_A_D49: UCPU1.AV56 UD7.C7
DDR_A_D50: UCPU1.AP50 UD7.C2
DDR_A_D51: UCPU1.AP53 UD7.C8
DDR_A_D52: UCPU1.AV54 UD7.E3
DDR_A_D53: UCPU1.AT54 UD7.D2
DDR_A_D54: UCPU1.AP56 UD7.B3
DDR_A_D55: UCPU1.AP52 UD7.E7
DDR_A_D56: UCPU1.AN57 UD8.E3
DDR_A_D57: UCPU1.AN53 UD8.C7
DDR_A_D58: UCPU1.AG56 UD8.C2
DDR_A_D59: UCPU1.AG53 UD8.B3
DDR_A_D60: UCPU1.AN55 UD8.C8
DDR_A_D61: UCPU1.AN52 UD8.E8
DDR_A_D62: UCPU1.AG55 UD8.D2
DDR_A_D63: UCPU1.AK56 UD8.E7
DDR_A_DQS0: UCPU1.AJ11 UD1.C3
DDR_A_DQS1: UCPU1.AR10 UD2.C3
DDR_A_DQS2: UCPU1.AY11 UD3.C3
DDR_A_DQS3: UCPU1.AU17 UD4.C3
DDR_A_DQS4: UCPU1.AW45 UD5.C3
DDR_A_DQS5: UCPU1.AV51 UD6.C3
DDR_A_DQS6: UCPU1.AT56 UD7.C3
DDR_A_DQS7: UCPU1.AK54 UD8.C3
DDR_A_DQS#0: UCPU1.AL11 UD1.D3
DDR_A_DQS#1: UCPU1.AR8 UD2.D3
DDR_A_DQS#2: UCPU1.AV11 UD3.D3
DDR_A_DQS#3: UCPU1.AT17 UD4.D3
DDR_A_DQS#4: UCPU1.AV45 UD5.D3
DDR_A_DQS#5: UCPU1.AY51 UD6.D3
DDR_A_DQS#6: UCPU1.AT55 UD7.D3
DDR_A_DQS#7: UCPU1.AK55 UD8.D3
DDR_A_MA0: R1040.1 UCPU1.BG35 UD1.K3 UD2.K3 UD3.K3 UD4.K3 UD5.K3 UD6.K3 UD7.K3 UD8.K3
DDR_A_MA1: R1048.1 UCPU1.BB34 UD1.L7 UD2.L7 UD3.L7 UD4.L7 UD5.L7 UD6.L7 UD7.L7 UD8.L7
DDR_A_MA2: R1046.1 UCPU1.BE35 UD1.L3 UD2.L3 UD3.L3 UD4.L3 UD5.L3 UD6.L3 UD7.L3 UD8.L3
DDR_A_MA3: R1052.1 UCPU1.BD35 UD1.K2 UD2.K2 UD3.K2 UD4.K2 UD5.K2 UD6.K2 UD7.K2 UD8.K2
DDR_A_MA4: R1044.1 UCPU1.AT34 UD1.L8 UD2.L8 UD3.L8 UD4.L8 UD5.L8 UD6.L8 UD7.L8 UD8.L8
DDR_A_MA5: R1058.1 UCPU1.AU34 UD1.L2 UD2.L2 UD3.L2 UD4.L2 UD5.L2 UD6.L2 UD7.L2 UD8.L2
DDR_A_MA6: R1050.1 UCPU1.BB32 UD1.M8 UD2.M8 UD3.M8 UD4.M8 UD5.M8 UD6.M8 UD7.M8 UD8.M8
DDR_A_MA7: R1062.1 UCPU1.AT32 UD1.M2 UD2.M2 UD3.M2 UD4.M2 UD5.M2 UD6.M2 UD7.M2 UD8.M2
DDR_A_MA8: R1064.1 UCPU1.AY32 UD1.N8 UD2.N8 UD3.N8 UD4.N8 UD5.N8 UD6.N8 UD7.N8 UD8.N8
DDR_A_MA9: R1054.1 UCPU1.AV32 UD1.M3 UD2.M3 UD3.M3 UD4.M3 UD5.M3 UD6.M3 UD7.M3 UD8.M3
DDR_A_MA10: R1042.1 UCPU1.BE37 UD1.H7 UD2.H7 UD3.H7 UD4.H7 UD5.H7 UD6.H7 UD7.H7 UD8.H7
DDR_A_MA11: R1056.1 UCPU1.BA30 UD1.M7 UD2.M7 UD3.M7 UD4.M7 UD5.M7 UD6.M7 UD7.M7 UD8.M7
DDR_A_MA12: R1036.1 UCPU1.BC30 UD1.K7 UD2.K7 UD3.K7 UD4.K7 UD5.K7 UD6.K7 UD7.K7 UD8.K7
DDR_A_MA13: R1066.1 UCPU1.AW41 UD1.N3 UD2.N3 UD3.N3 UD4.N3 UD5.N3 UD6.N3 UD7.N3 UD8.N3
DDR_A_MA14: R1060.1 UCPU1.AY28 UD1.N7 UD2.N7 UD3.N7 UD4.N7 UD5.N7 UD6.N7 UD7.N7 UD8.N7
DDR_A_MA15: R1038.1 UCPU1.AU26 UD1.J7 UD2.J7 UD3.J7 UD4.J7 UD5.J7 UD6.J7 UD7.J7 UD8.J7
DDR_A_RAS#: R1070.1 UCPU1.BD39 UD1.F3 UD2.F3 UD3.F3 UD4.F3 UD5.F3 UD6.F3 UD7.F3 UD8.F3
DDR_A_WE#: R1076.1 UCPU1.AT41 UD1.H3 UD2.H3 UD3.H3 UD4.H3 UD5.H3 UD6.H3 UD7.H3 UD8.H3
DDR_B_BS0: R1081.1 UCPU1.BG39 UD9.J2 UD10.J2 UD11.J2 UD12.J2 UD13.J2 UD14.J2 UD15.J2 UD16.J2
DDR_B_BS1: R1077.1 UCPU1.BD42 UD9.K8 UD10.K8 UD11.K8 UD12.K8 UD13.K8 UD14.K8 UD15.K8 UD16.K8
DDR_B_BS2: R1079.1 UCPU1.AT22 UD9.J3 UD10.J3 UD11.J3 UD12.J3 UD13.J3 UD14.J3 UD15.J3 UD16.J3
DDR_B_CAS#: R1073.1 UCPU1.AV43 UD9.G3 UD10.G3 UD11.G3 UD12.G3 UD13.G3 UD14.G3 UD15.G3 UD16.G3
DDR_B_CKE0: R1069.1 UCPU1.AR22 UD9.G9 UD10.G9 UD11.G9 UD12.G9 UD13.G9 UD14.G9 UD15.G9 UD16.G9
DDR_B_CS0#: R1071.1 UCPU1.BE41 UD9.H2 UD10.H2 UD11.H2 UD12.H2 UD13.H2 UD14.H2 UD15.H2 UD16.H2
DDR_B_D0: UCPU1.AL4 UD9.E3
DDR_B_D1: UCPU1.AL1 UD9.E7
DDR_B_D2: UCPU1.AN3 UD9.C2
DDR_B_D3: UCPU1.AR4 UD9.B3
DDR_B_D4: UCPU1.AK4 UD9.C7
DDR_B_D5: UCPU1.AK3 UD9.E8
DDR_B_D6: UCPU1.AN4 UD9.D2
DDR_B_D7: UCPU1.AR1 UD9.C8
DDR_B_D8: UCPU1.AU4 UD10.E8
DDR_B_D9: UCPU1.AT2 UD10.C8
DDR_B_D10: UCPU1.AV4 UD10.C2
DDR_B_D11: UCPU1.BA4 UD10.D2
DDR_B_D12: UCPU1.AU3 UD10.C7
DDR_B_D13: UCPU1.AR3 UD10.E7
DDR_B_D14: UCPU1.AY2 UD10.E3
DDR_B_D15: UCPU1.BA3 UD10.B3
DDR_B_D16: UCPU1.BE9 UD11.C2
DDR_B_D17: UCPU1.BD9 UD11.E8
DDR_B_D18: UCPU1.BD13 UD11.C7
DDR_B_D19: UCPU1.BF12 UD11.D2
DDR_B_D20: UCPU1.BF8 UD11.E3
DDR_B_D21: UCPU1.BD10 UD11.E7
DDR_B_D22: UCPU1.BD14 UD11.B3
DDR_B_D23: UCPU1.BE13 UD11.C8
DDR_B_D24: UCPU1.BF16 UD12.C7
DDR_B_D25: UCPU1.BE17 UD12.E8
DDR_B_D26: UCPU1.BE18 UD12.C2
DDR_B_D27: UCPU1.BE21 UD12.E3
DDR_B_D28: UCPU1.BE14 UD12.C8
DDR_B_D29: UCPU1.BG14 UD12.E7
DDR_B_D30: UCPU1.BG18 UD12.B3
DDR_B_D31: UCPU1.BF19 UD12.D2
DDR_B_D32: UCPU1.BD50 UD13.E3
DDR_B_D33: UCPU1.BF48 UD13.C7
DDR_B_D34: UCPU1.BD53 UD13.B3
DDR_B_D35: UCPU1.BF52 UD13.C2
DDR_B_D36: UCPU1.BD49 UD13.E7
DDR_B_D37: UCPU1.BE49 UD13.E8
DDR_B_D38: UCPU1.BD54 UD13.C8
DDR_B_D39: UCPU1.BE53 UD13.D2
DDR_B_D40: UCPU1.BF56 UD14.E7
DDR_B_D41: UCPU1.BE57 UD14.C7
DDR_B_D42: UCPU1.BC59 UD14.B3
DDR_B_D43: UCPU1.AY60 UD14.D2
DDR_B_D44: UCPU1.BE54 UD14.C8
DDR_B_D45: UCPU1.BG54 UD14.E3
DDR_B_D46: UCPU1.BA58 UD14.E8
DDR_B_D47: UCPU1.AW59 UD14.C2
DDR_B_D48: UCPU1.AW58 UD15.E8
DDR_B_D49: UCPU1.AU58 UD15.C7
DDR_B_D50: UCPU1.AN61 UD15.B3
DDR_B_D51: UCPU1.AN59 UD15.C8
DDR_B_D52: UCPU1.AU59 UD15.E7
DDR_B_D53: UCPU1.AU61 UD15.E3
DDR_B_D54: UCPU1.AN58 UD15.D2
DDR_B_D55: UCPU1.AR58 UD15.C2
DDR_B_D56: UCPU1.AK58 UD16.C7
DDR_B_D57: UCPU1.AL58 UD16.C8
DDR_B_D58: UCPU1.AG58 UD16.E3
DDR_B_D59: UCPU1.AG59 UD16.C2
DDR_B_D60: UCPU1.AM60 UD16.E7
DDR_B_D61: UCPU1.AL59 UD16.E8
DDR_B_D62: UCPU1.AF61 UD16.D2
DDR_B_D63: UCPU1.AH60 UD16.B3
DDR_B_DQS0: UCPU1.AM2 UD9.C3
DDR_B_DQS1: UCPU1.AV1 UD10.C3
DDR_B_DQS2: UCPU1.BE11 UD11.C3
DDR_B_DQS3: UCPU1.BD18 UD12.C3
DDR_B_DQS4: UCPU1.BE51 UD13.C3
DDR_B_DQS5: UCPU1.BA61 UD14.C3
DDR_B_DQS6: UCPU1.AR59 UD15.C3
DDR_B_DQS7: UCPU1.AK61 UD16.C3
DDR_B_DQS#0: UCPU1.AL3 UD9.D3
DDR_B_DQS#1: UCPU1.AV3 UD10.D3
DDR_B_DQS#2: UCPU1.BG11 UD11.D3
DDR_B_DQS#3: UCPU1.BD17 UD12.D3
DDR_B_DQS#4: UCPU1.BG51 UD13.D3
DDR_B_DQS#5: UCPU1.BA59 UD14.D3
DDR_B_DQS#6: UCPU1.AT60 UD15.D3
DDR_B_DQS#7: UCPU1.AK59 UD16.D3
DDR_B_MA0: R1041.1 UCPU1.BF32 UD9.K3 UD10.K3 UD11.K3 UD12.K3 UD13.K3 UD14.K3 UD15.K3 UD16.K3
DDR_B_MA1: R1055.1 UCPU1.BE33 UD9.L7 UD10.L7 UD11.L7 UD12.L7 UD13.L7 UD14.L7 UD15.L7 UD16.L7
DDR_B_MA2: R1051.1 UCPU1.BD33 UD9.L3 UD10.L3 UD11.L3 UD12.L3 UD13.L3 UD14.L3 UD15.L3 UD16.L3
DDR_B_MA3: R1061.1 UCPU1.AU30 UD9.K2 UD10.K2 UD11.K2 UD12.K2 UD13.K2 UD14.K2 UD15.K2 UD16.K2
DDR_B_MA4: R1049.1 UCPU1.BD30 UD9.L8 UD10.L8 UD11.L8 UD12.L8 UD13.L8 UD14.L8 UD15.L8 UD16.L8
DDR_B_MA5: R1067.1 UCPU1.AV30 UD9.L2 UD10.L2 UD11.L2 UD12.L2 UD13.L2 UD14.L2 UD15.L2 UD16.L2
DDR_B_MA6: R1047.1 UCPU1.BG30 UD9.M8 UD10.M8 UD11.M8 UD12.M8 UD13.M8 UD14.M8 UD15.M8 UD16.M8
DDR_B_MA7: R1059.1 UCPU1.BD29 UD9.M2 UD10.M2 UD11.M2 UD12.M2 UD13.M2 UD14.M2 UD15.M2 UD16.M2
DDR_B_MA8: R1053.1 UCPU1.BE30 UD9.N8 UD10.N8 UD11.N8 UD12.N8 UD13.N8 UD14.N8 UD15.N8 UD16.N8
DDR_B_MA9: R1063.1 UCPU1.BE28 UD9.M3 UD10.M3 UD11.M3 UD12.M3 UD13.M3 UD14.M3 UD15.M3 UD16.M3
DDR_B_MA10: R1043.1 UCPU1.BD43 UD9.H7 UD10.H7 UD11.H7 UD12.H7 UD13.H7 UD14.H7 UD15.H7 UD16.H7
DDR_B_MA11: R1065.1 UCPU1.AT28 UD9.M7 UD10.M7 UD11.M7 UD12.M7 UD13.M7 UD14.M7 UD15.M7 UD16.M7
DDR_B_MA12: R1037.1 UCPU1.AV28 UD9.K7 UD10.K7 UD11.K7 UD12.K7 UD13.K7 UD14.K7 UD15.K7 UD16.K7
DDR_B_MA13: R1057.1 UCPU1.BD46 UD9.N3 UD10.N3 UD11.N3 UD12.N3 UD13.N3 UD14.N3 UD15.N3 UD16.N3
DDR_B_MA14: R1045.1 UCPU1.AT26 UD9.N7 UD10.N7 UD11.N7 UD12.N7 UD13.N7 UD14.N7 UD15.N7 UD16.N7
DDR_B_MA15: R1039.1 UCPU1.AU22 UD9.J7 UD10.J7 UD11.J7 UD12.J7 UD13.J7 UD14.J7 UD15.J7 UD16.J7
DDR_B_RAS#: R1075.1 UCPU1.BF40 UD9.F3 UD10.F3 UD11.F3 UD12.F3 UD13.F3 UD14.F3 UD15.F3 UD16.F3
DDR_B_WE#: R1083.1 UCPU1.BD45 UD9.H3 UD10.H3 UD11.H3 UD12.H3 UD13.H3 UD14.H3 UD15.H3 UD16.H3
DH_1.35V: PQ1215.4 PT9.1(TP-1) PU300.17
DISP_CEC: JMDP1.6 RV4.1
DISP_CLK_AUXP_CONN: JMDP1.16 RV3.1 UV1.4
DISP_DAT_AUXN_CONN: JMDP1.18 RV2.1 UV1.7
DISP_HPD_SINK: JMDP1.2 QV1.1 RV10.1
DISPOFF#: D72.1 JLVDS1.13 R540.1
DL_1.35V: PQ1226.4 PT10.1(TP-1) PU300.15
DMI_CRX_PTX_N0: UCPU1.M2 UH1.BD22
DMI_CRX_PTX_N1: UCPU1.P6 UH1.BB22
DMI_CRX_PTX_N2: UCPU1.P1 UH1.BB19
DMI_CRX_PTX_N3: UCPU1.P10 UH1.BB17
DMI_CRX_PTX_P0: UCPU1.N3 UH1.BF22
DMI_CRX_PTX_P1: UCPU1.P7 UH1.AY22
DMI_CRX_PTX_P2: UCPU1.P3 UH1.AY19
DMI_CRX_PTX_P3: UCPU1.P11 UH1.AY17
DMI_CTX_PRX_N0: UCPU1.K1 UH1.BL21
DMI_CTX_PRX_N1: UCPU1.M8 UH1.BL23
DMI_CTX_PRX_N2: UCPU1.N4 UH1.BJ19
DMI_CTX_PRX_N3: UCPU1.R2 UH1.BL17
DMI_CTX_PRX_P0: UCPU1.K3 UH1.BJ21
DMI_CTX_PRX_P1: UCPU1.M7 UH1.BJ23
DMI_CTX_PRX_P2: UCPU1.P4 UH1.BL19
DMI_CTX_PRX_P3: UCPU1.T3 UH1.BJ17
DMI_IRCOMP: RH124.2 UH1.BD19 UH1.BF19
DMIC0: C1206.1 D50.4 JIOL1.34 JLVDS2.5
DMIC_CLK: D50.6 JIOL1.32 R537.2
DMIC_CLK_R: C1133.1 JLVDS2.6 R537.1
DP_CBL_DET: RV8.1 UH1.F45 UV1.1
DRAMRST_CNTRL: CC69.1 QC2.2 QD1.2 QD2.2 R1035.1 RC72.2 RC145.2
DRAMRST_CNTRL_EC: R987.1 RC145.1 U34.A1
DRAMRST_CNTRL_PCH: RC72.1 RH75.1 UH1.H22
DSWODVREN: RH147.2 RH151.2 UH1.F22
EAPD#: JIOL1.19 R228.1
EAPD_R#: R228.2 R241.1 U34.D6
EC_BATT_PRS: C286.2 PQ908.2 PR915.2 PR916.1 U34.B13
EC_CRY2: C654.1 R253.2 R607.2 U34.K1
EC_ENVDD: D93.3 U34.A10
EC_INV_PWM: D73.2 U34.K8
EC_LID_OUT#: RH336.2 U34.D1
EC_ON: C1117.1 PR938.1 PR969.1 U34.G1
EC_ON_CTRL#: C1118.1 D84.2 D85.2 R936.1 U34.G5
EC_PECI: R240.1 U34.H2
EC_RST#: C285.1 R221.1 U34.K13
EC_RX: R729.1 U34.K9
EC_RX_R: JWLAN1.51 R729.2 R731.2
EC_SCI#: R218.2 U34.N6 UH1.A45
EC_SMB_CK1: PR913.2 PR956.2 R229.1 U34.A8
EC_SMB_DA1: PR917.2 PR955.2 R230.1 U34.A7
EC_SMI#: RH190.1 U34.L13 UH1.H17
EC_TX: R728.1 U34.K10
EC_TX_R: JWLAN1.49 R728.2 R730.1
EC_WLAN_WAKE#: JWLAN1.1 R942.2 U34.M7
ECAGND: C282.2 C286.1 L44.2 U34.A11
EDP_AUXN: C1065.1 UCPU1.AG4
EDP_AUXN_C: C1065.2 L58.1 R1011.1 R1033.1
EDP_AUXN_CONN: JLVDS1.9 L58.2 R1011.2
EDP_AUXP: C1064.1 UCPU1.AF4
EDP_AUXP_C: C1064.2 L58.4 R1010.1 R1034.2
EDP_AUXP_CONN: JLVDS1.8 L58.3 R1010.2
EDP_HPD: JLVDS1.10 QC5.2 RC138.1
EDP_TXN_P0: C1060.1 UCPU1.AC3
EDP_TXN_P0_C: C1060.2 L57.4 R1008.1
EDP_TXN_P0_CONN: JLVDS1.5 L57.3 R1008.2
EDP_TXN_P1: C1061.1 UCPU1.AC4
EDP_TXN_P1_C: C1061.2 L56.4 R1006.1
EDP_TXN_P1_CONN: JLVDS1.2 L56.3 R1006.2
EDP_TXP_P0: C1062.1 UCPU1.AC1
EDP_TXP_P0_C: C1062.2 L57.1 R1009.1
EDP_TXP_P0_CONN: JLVDS1.6 L57.2 R1009.2
EDP_TXP_P1: C1063.1 UCPU1.AA4
EDP_TXP_P1_C: C1063.2 L56.1 R1007.1
EDP_TXP_P1_CONN: JLVDS1.3 L56.2 R1007.2
EN_1.5VSP: PC406.1 PR405.2 PR407.1 PU401.5
EN_1.8VSP: PC404.1 PR402.2 PR403.1 PU400.5
EN_+V1.05S_VCCPP: PC505.1 PR503.2 PU500.3
EN_CAM: Q42.2 UH1.H42
EN_INVPWR: R538.2 U34.B1
EN_TS: Q336.2 RH326.2 UH1.G46
ENBKL: RH123.2 U34.B6 UH1.M44
ENM: PR514.1 PR515.1 PU501.13
ENTRIP1: PC1920.2 PQ204.6 PR216.2
ENTRIP2: PC1919.1 PQ204.3 PR218.1
ENVDD: D93.1 R1026.1 U654.5
FB: PC728.2 PC729.2 PR737.2 PR738.2 PR740.1 PU700.17
FB_3V: PC220.2 PR200.2 PR202.2 PU501.5
FB_+V1.05S_VCCPP: PC510.2 PR507.2 PR510.2 PU500.4
FDI_CTX_PRX_N0: UCPU1.U7 UH1.BL13
FDI_CTX_PRX_N1: UCPU1.W11 UH1.BJ15
FDI_CTX_PRX_N2: UCPU1.W1 UH1.BD12
FDI_CTX_PRX_N3: UCPU1.AA6 UH1.BJ11
FDI_CTX_PRX_N4: UCPU1.W6 UH1.AY15
FDI_CTX_PRX_N5: UCPU1.V4 UH1.AY12
FDI_CTX_PRX_N6: UCPU1.Y2 UH1.BJ9
FDI_CTX_PRX_N7: UCPU1.AC9 UH1.BF10
FDI_CTX_PRX_P0: UCPU1.U6 UH1.BJ13
FDI_CTX_PRX_P1: UCPU1.W10 UH1.BL15
FDI_CTX_PRX_P2: UCPU1.W3 UH1.BF12
FDI_CTX_PRX_P3: UCPU1.AA7 UH1.BL11
FDI_CTX_PRX_P4: UCPU1.W7 UH1.BB15
FDI_CTX_PRX_P5: UCPU1.T4 UH1.BB12
FDI_CTX_PRX_P6: UCPU1.AA3 UH1.BL9
FDI_CTX_PRX_P7: UCPU1.AC8 UH1.BD10
FDI_FSYNC0: UCPU1.AA11 UH1.BH12
FDI_FSYNC1: UCPU1.AC12 UH1.BK8
FDI_INT: UCPU1.U11 UH1.BB10
FDI_LSYNC0: UCPU1.AA10 UH1.BK12
FDI_LSYNC1: UCPU1.AG8 UH1.BH8
GATEA20: RH174.1 U34.M2 UH1.U3
GFX_B+: PC704.1 PC705.1 PC709.1 PC747.1 PC748.1 PC1908.1 PJP700.2 PQ1217.2 PQ1217.3 PQ1217.4 PQ1217.10 PT11.1(TP-1)
GYRO_DRDY: U636.G5 U638.6
GYRO_INT#: U636.H8 U638.7
H_CATERR#: T1.1(TP-1) UCPU1.C49
H_CPU_SVIDALRT#: RC94.1 UCPU1.A44
H_CPU_SVIDCLK: RC92.1 UCPU1.B43
H_CPU_SVIDDAT: RC95.1 RC96.1 UCPU1.C44
H_CPUPWRGD: RC53.1 UH1.AU10
H_CPUPWRGD_R: RC44.2 RC53.2 UCPU1.B46
H_DRAMRST#: QC2.3 RC74.2 RC77.1 UCPU1.AT30
H_PECI: R240.2 RH175.2 UCPU1.A48
H_PM_SYNC: UCPU1.C48 UH1.BB8
H_PROCHOT#: C656.1 PC124.1 R265.1 RC41.1 RC43.1 U635.4
H_PROCHOT#_EC: R608.2 U34.E2 U635.2
H_PROCHOT#_R: RC41.2 UCPU1.C45
H_THERMTRIP#: RC49.1 RH176.2
H_THERMTRIP#_C: RH176.1 UH1.BC9
H_THERMTRIP#_R: RC49.2 UCPU1.D45
H_VCCP_SEL: T223.1(TP-1) UCPU1.BC22
HDA_BIT_CLK: RH27.2 UH1.H35
HDA_BITCLK_AUDIO: CH117.1 LH9.1 RH27.1
HDA_BITCLK_AUDIO_C: JIOL1.14 LH9.2
HDA_RST#: RH28.2 UH1.F35
HDA_RST_AUDIO#: JIOL1.20 RH28.1
HDA_SDIN0: JIOL1.26 UH1.D36
HDA_SDO: RH24.1 U34.C1
HDA_SDOUT: CH103.1 RH24.2 RH30.2 RH42.2 UH1.K37
HDA_SDOUT_AUDIO: JIOL1.24 RH30.1
HDA_SPKR: JIOL1.28 RH37.2 UH1.N1
HDA_SYNC: QH1.1 RH36.2 RH279.2 UH1.H37
HDA_SYNC_AUDIO: JIOL1.18 RH33.1
HDA_SYNC_R: QH1.3 RH33.2 RH36.1 RH275.2
HUB_OSC_IN: C1204.1 U636.D8 Y2.1
HUB_OSC_OUT: C1205.1 U636.D7 Y2.3
HWPG: R930.2 R931.1 R933.1 R934.1 R982.1 U34.F1
I2C_INT#: T249.1(TP-1) U636.E8
ICOMP: PR35.2 PU2.5
IN+: PC1915.1 PR962.1 PU702.4
IN-: PC1915.2 PR963.2 PU702.5
INIT3_3V#: T127.1(TP-1) UH1.R6
INV_PWM_R: C1151.1 D73.1 D92.1 JLVDS1.14 R545.1
ISEN2: PR736.2 PU700.12
ISEN2G: PR720.2 PU700.3
ISL9519_VDD: PC34.1 PD9.2 PR32.2 PR49.1 PU2.19
JNTRST: JSATA1.16 R1098.2 U636.B4
JTCK: JSATA1.14 R1099.2 U636.B2
JTDI: JSATA1.12 R1097.2 U636.C3
JTDO: JSATA1.10 R1096.2 U636.A4
JTMS: JSATA1.8 R1095.2 U636.D4
KB_BL_DET: R944.1 R945.2 UH1.A43
KB_DET#: JKB1.1 RH302.1 UH1.D48
KB_LED_PWM: Q311.2 U34.M9
KB_LED_PWM#: JBL1.1 Q311.1
KB_RST#: RH196.1 U34.L2 UH1.U6
KSI0: C1190.1 JKB1.9 U34.D9
KSI1: C1192.1 JKB1.7 U34.E12
KSI2: C1186.1 JKB1.5 U34.E13
KSI3: C1191.1 JKB1.8 U34.D12
KSI4: C1187.1 JKB1.4 U34.D13
KSI5: C1193.1 JKB1.6 U34.C12
KSI6: C1188.1 JKB1.3 U34.C13
KSI7: C1189.1 JKB1.2 U34.D10
KSO0: C1078.1 JKB1.18 U34.J13
KSO1: C1195.1 JKB1.16 U34.J12
KSO2: C1194.1 JKB1.17 U34.H12
KSO3: C1196.1 JKB1.15 R1032.2 U34.H13
KSO4: C1184.1 JKB1.11 U34.H10
KSO5: C1185.1 JKB1.10 U34.H9
KSO6: C1182.1 JKB1.13 U34.G9
KSO7: C1183.1 JKB1.12 U34.G10
KSO8: C1197.1 JKB1.14 U34.G13
KSO9: C1180.1 JKB1.24 U34.G12
KSO10: C1178.1 JKB1.26 U34.F13
KSO11: C1179.1 JKB1.25 U34.F12
KSO12: C1177.1 JKB1.19 U34.F10
KSO13: C1174.1 JKB1.22 U34.F9
KSO14: C1181.1 JKB1.23 U34.E10
KSO15: C1175.1 JKB1.21 U34.E9
KSO16: C1176.1 JKB1.20 U34.E8
LCD_TEST: JLVDS2.14 U34.A3
LDO_EN: PC215.1 PR210.2 PR211.2 PR212.1 PU501.12
LG_3V: PC221.1 PQ1208.4 PT5.1(TP-1) PU501.10
LG_5V: PC218.1 PQ1210.4 PT6.1(TP-1) PU501.16
LG_+V1.05S_VCCPP: PQ1219.4 PT8.1(TP-1) PU500.6
LGATE: PQ1221.4 PT2.1(TP-1) PU2.21
LGATE1: PQ1218.8 PT17.1(TP-1) PU700.23
LGATE1G: PQ1217.8 PT13.1(TP-1) PU700.34
LID_SW_IN#: JIOL1.27 R603.2 U34.H1
LPC_AD0: R1016.2 U34.N4 U652.26 UH1.A37
LPC_AD1: R1015.2 U34.K5 U652.23 UH1.A39
LPC_AD2: R1014.2 U34.M4 U652.20 UH1.C39
LPC_AD3: R1013.2 U34.N3 U652.17 UH1.C37
LPC_FRAME#: R1012.2 U34.K4 U652.22 UH1.K40
LX_3V: PC208.2 PL1207.2 PQ1207.1 PQ1207.2 PQ1207.3 PQ1208.5 PR208.1 PU501.9
LX_5V: PC209.1 PL201.1 PQ1209.1 PQ1209.2 PQ1209.3 PQ1210.5 PR209.1 PU501.17
M_CLK_DDR0: CD121.1 RD35.1 UCPU1.AU36 UD1.F7 UD2.F7 UD3.F7 UD4.F7 UD5.F7 UD6.F7 UD7.F7 UD8.F7
M_CLK_DDR2: CD122.1 RD36.1 UCPU1.BA34 UD9.F7 UD10.F7 UD11.F7 UD12.F7 UD13.F7 UD14.F7 UD15.F7 UD16.F7
M_CLK_DDR#0: CD121.2 RD37.1 UCPU1.AV36 UD1.G7 UD2.G7 UD3.G7 UD4.G7 UD5.G7 UD6.G7 UD7.G7 UD8.G7
M_CLK_DDR#2: CD122.2 RD38.1 UCPU1.AY34 UD9.G7 UD10.G7 UD11.G7 UD12.G7 UD13.G7 UD14.G7 UD15.G7 UD16.G7
M_ODT0: RD33.1 UCPU1.AY40 UD1.G1 UD2.G1 UD3.G1 UD4.G1 UD5.G1 UD6.G1 UD7.G1 UD8.G1
M_ODT2: RD34.1 UCPU1.AT43 UD9.G1 UD10.G1 UD11.G1 UD12.G1 UD13.G1 UD14.G1 UD15.G1 UD16.G1
MAG_DRDY: U636.E5 U637.9
MEM_CHA_EN: RH298.1 RH339.2 UH1.B44
MEM_CHB_EN: RH197.1 RH338.2 UH1.W3
MEM_CONFIG0: RH303.1 RH316.2 UH1.W1
MEM_CONFIG1: RH180.1 RH315.2 UH1.B40
MEM_CONFIG2: RH271.1 RH314.2 UH1.C43
MINI1_SMBCLK: JWLAN1.30 Q327.1 R724.1 R1019.1
MINI1_SMBDATA: JWLAN1.32 Q327.4 R725.1 R1018.1
MINI1CLK_REQ#: JWLAN1.7 RH103.1 UH1.B8
MSATA_DET#: JSATA1.51 RH188.1 UH1.K17
N_3V_001: PC217.1 PD903.1 PD906.1 PD907.2 PD909.1 PQ204.5 PR957.2 PR970.1
N_5V_001: PC1911.1 PD909.2 PQ204.2 PR957.1 PR958.1 PR969.2
NFC_IRQ: R517.1 R1100.2 UH1.C9
NTC: PH702.2 PR727.1 PU700.10
NTCG: PH700.1 PR704.2 PU700.4
P1: PJP507.1 PJP508.1 PR13.1
PBTN_OUT#: RH293.2 U34.H4
PBTN_OUT#_R: RH293.1 UH1.K19
PBTN_SW#: D85.1 JIOL1.29 R940.2 SW2.1 SW2.2 U34.N7
PCH_DP_AUXN: CV10.2 UH1.AU46
PCH_DP_AUXN_C: CV10.1 UV1.5
PCH_DP_AUXP: CV8.2 UH1.AU44
PCH_DP_AUXP_C: CV8.1 UV1.2
PCH_DP_CLK: RH281.2 UH1.M48 UV1.3
PCH_DP_DAT: RH282.2 UH1.U42 UV1.6
PCH_DP_HPD: QV1.3 RH300.2 UH1.BK44
PCH_DP_N0: CV4.2 UH1.BG51
PCH_DP_N0_C: CV4.1 DV1.1 DV1.10 JMDP1.5
PCH_DP_N1: CV7.2 UH1.BF42
PCH_DP_N1_C: CV7.1 DV1.5 DV1.6 JMDP1.11
PCH_DP_N2: CV12.2 UH1.BJ47
PCH_DP_N2_C: CV12.1 DV2.4 DV2.7 JMDP1.17
PCH_DP_N3: CV9.2 UH1.BL45
PCH_DP_N3_C: CV9.1 DV2.2 DV2.9 JMDP1.12
PCH_DP_P0: CV3.2 UH1.BG49
PCH_DP_P0_C: CV3.1 DV1.2 DV1.9 JMDP1.3
PCH_DP_P1: CV5.2 UH1.BD42
PCH_DP_P1_C: CV5.1 DV1.4 DV1.7 JMDP1.9
PCH_DP_P2: CV11.2 UH1.BL47
PCH_DP_P2_C: CV11.1 DV2.5 DV2.6 JMDP1.15
PCH_DP_P3: CV6.2 UH1.BJ45
PCH_DP_P3_C: CV6.1 DV2.1 DV2.10 JMDP1.10
PCH_DPWROK: RH126.1 RH309.2 UH1.A21
PCH_ENVDD: D93.2 RH158.2 UH1.M42
PCH_GPIO2: RH335.2 UH1.A47
PCH_GPIO3: RH330.2 UH1.C41
PCH_GPIO5: RH328.2 UH1.F40
PCH_GPIO12: RH290.1 UH1.C5
PCH_GPIO15: RH270.1 UH1.K6
PCH_GPIO18: RH95.1 UH1.U8
PCH_GPIO20: RH100.1 UH1.T4
PCH_GPIO21: RH32.2 UH1.M2
PCH_GPIO26: RH107.1 UH1.M19
PCH_GPIO27: RH186.2 RH310.2 RH311.2 UH1.C15
PCH_GPIO28: RH177.2 UH1.G1
PCH_GPIO36: RH193.1 UH1.W6
PCH_GPIO37: RH181.1 RH182.2 UH1.M6
PCH_GPIO39: RH263.1 UH1.U10
PCH_GPIO44: RH110.2 UH1.K8
PCH_GPIO45: RH116.2 UH1.J3
PCH_GPIO46: RH118.2 UH1.H4
PCH_GPIO52: RH329.2 UH1.K44
PCH_GPIO54: RH331.2 UH1.F46
PCH_GPIO70: RH308.1 UH1.D40
PCH_GPIO72: RH143.1 UH1.H10
PCH_GPIO73: RH91.2 UH1.M4
PCH_INTVRMEN: RH31.2 RH34.2 UH1.C21
PCH_INV_PWM: D92.2 UH1.L49
PCH_JTAG_TCK: RH53.1 UH1.M17
PCH_JTAG_TDI: RH40.2 RH46.1 UH1.U12
PCH_JTAG_TDO: RH38.2 RH44.1 UH1.M12
PCH_JTAG_TMS: RH39.2 RH45.1 UH1.M15
PCH_LID_SW_IN#: RH319.1 RH336.1 UH1.C23
PCH_PECI_R: RH175.1 UH1.AU12
PCH_PLTRST#: RH168.2 RH183.2 UH1.F7 UH5.1 UH5.2
PCH_PWR_EN#: C355.1 Q5.2 Q41.2 QH7.2 R894.1
PCH_PWROK: RH130.1 RH131.1 RH299.1 U34.D5
PCH_RSMRST#: RH133.2 RH159.1 U34.D4
PCH_RSMRST#_R: RH126.2 RH133.1 UH1.B20
PCH_RTCRST#: CH4.2 CLRP1.2 RH25.2 UH1.F19
PCH_RTCX1: CH2.1 RH2.1 UH1.A19 YH1.1
PCH_RTCX2: CH3.1 RH2.2 UH1.C19 YH1.2
PCH_SATALED#: RH35.2 UH1.W10
PCH_SMBCLK: DE2.2 JTP1.6 QH3.1 RH98.1 RH105.2 UD17.6 UD18.6
PCH_SMBDATA: DE2.3 JTP1.5 QH3.4 RH99.1 RH111.2 UD17.5 UD18.5
PCH_SMLCLK: QH4.1 R244.1 R983.2 U34.B8
PCH_SMLDATA: QH4.4 R247.1 R984.2 U34.A6
PCH_SPI_CLK: CH118.2 RH255.2 UH1.AD12
PCH_SPI_CLK_R: RH255.1 RH256.2 U48.6
PCH_SPI_CS#: RH57.1 U48.1 UH1.AB8
PCH_SPI_HOLD#: RH56.1 U48.7
PCH_SPI_SI: U48.5 UH1.W8
PCH_SPI_SO: U48.2 UH1.Y2
PCH_SPI_WP#: RH54.1 U48.3
PCH_SRTCRST#: CH5.1 CLRP2.1 RH23.2 UH1.A23
PCH_SUSWARN#: RH297.2 U34.D8
PCI_PIRQA#: RH333.2 UH1.D49
PCI_PIRQB#: RH334.2 UH1.C48
PCI_PIRQC#: RH332.2 UH1.C47
PCI_PIRQD#: RH327.2 UH1.C45
PCIE_MCARD1_DET#: JWLAN1.37 RH262.1 UH1.N3
PCIE_PRX_WLANTX_N3: JWLAN1.23 UH1.BH36
PCIE_PRX_WLANTX_P3: JWLAN1.25 UH1.BK36
PCIE_PTX_WLANRX_N3: CH11.1 JWLAN1.31
PCIE_PTX_WLANRX_N3_C: CH11.2 UH1.BF33
PCIE_PTX_WLANRX_P3: CH16.1 JWLAN1.33
PCIE_PTX_WLANRX_P3_C: CH16.2 UH1.BD33
PEG_A_CLKRQ#: RH141.1 UH1.R8
PEG_B_CLKREQ#: RH112.2 UH1.C4
PEG_COMP: RC2.2 UCPU1.G1 UCPU1.G3 UCPU1.G4
PHASE: PC22.2 PL1211.1 PQ1221.5 PQ1223.1 PQ1223.2 PQ1223.3 PR26.2 PU2.23
PHASE1: PC740.1 PL704.4 PQ1218.9 PR743.1 PT18.1(TP-1) PU700.22
PHASE1G: PC713.1 PL701.4 PQ1217.9 PR711.1 PT14.1(TP-1) PU700.33
PLT_RST#: JWLAN1.22 R929.2 R1017.1 RC130.1 RH168.1 RH171.1 U34.M5 U652.16 UC2.1 UC2.2 UH5.4
PM_CLKRUN#: RH248.2 U652.15 UH1.T2
PM_DRAM_PWRGD: RC4.1 UC1.1 UH1.B12
PM_PWROK_R: RH130.2 UH1.M22
PM_SLP_S3#: R249.1 UH1.D4
PM_SLP_S4#: U34.N1 UH1.K10
PM_SLP_S5#: R250.1 UH1.F6
PM_SLP_SUS#: Q32.2 R290.1 RH313.1 U34.B7
POK: PR516.1 PR905.1 PR910.1 PR911.1 RH309.1
PP: R975.1 U652.7
PRESSURE_INT#: T250.1(TP-1) U636.D1
PS_ID: PD901.1 PR901.1 PR902.2 U34.K6
PSID: JDCIN1.1 PL901.2
PSID-1: PQ901.2 PR903.1 PR906.2
PSID-2: PQ900.2 PQ901.1 PR904.1
PSID-3: PQ900.3 PR900.2 PR902.1
PWM3: PR721.2 PU700.24
PWMG2: PR716.2 PU700.35
PWR_SRC_ON: C613.2 Q70.3 R535.2 R536.1
PWRSHARE_EN#: R807.1 UI1.1
PWRSHARE_EN_EC#: R806.2 R807.2 U34.E7 U656.4
PWRSHARE_OE#: U34.E6 UI1.8
RBIAS_CPY: RH125.2 UH1.BK20
RBIAS_SATA3: RH48.1 UH1.AH4
RESET#: R1089.1 R1090.1 U636.C7
RF_+V1.05S_VCCPP: PR505.1 PU500.5
RFSW_IN: CRF2.1 JANT2.2
RFSW_IN_C: CRF2.2 URF1.5
RFSW_OUT1: CRF1.2 JANT1.2
RFSW_OUT1_C: CRF1.1 URF1.1
RFSW_OUT2: CRF3.2 JANT3.2
RFSW_OUT2_C: CRF3.1 URF1.3
RFSW_VCONT1: RH304.1 RRF1.2 UH1.U1
RFSW_VCONT2: RH258.1 RRF2.2 UH1.AA1
RI#: RH145.1 UH1.F12
ROTATION_LOCK_SW#: C1125.1 R957.2 RH324.1 UH1.H15
ROTATION_LOCK_SW#_C: JIOL1.31 R957.1
RUN_ON_CPU1.5VS3: CC139.1 QC3.4 QC4.3 RC101.2 RC105.1
RUN_ON_CPU1.5VS3#: Q37.2 Q38.2 QC1.2 QC4.5 QC4.6 RC102.2
S3_1.35V: PC1910.1 PR308.2 PR323.2 PU300.7
S5_1.35V: PC313.1 PR306.2 PU300.8
SA_PGOOD: PR611.1 R931.2
SATA3_COMP: RH43.1 UH1.AF10 UH1.AF12
SATA_COMP: RH41.1 UH1.AB10 UH1.AB12
SATA_PRX_DTX_N0: CS53.1 UH1.AN3
SATA_PRX_DTX_N0_C: CS53.2 JSATA1.25
SATA_PRX_DTX_P0: CS54.1 UH1.AN1
SATA_PRX_DTX_P0_C: CS54.2 JSATA1.23
SATA_PTX_DRX_N0: CS43.1 UH1.AU3
SATA_PTX_DRX_N0_C: CS43.2 JSATA1.31
SATA_PTX_DRX_P0: CS42.1 UH1.AU1
SATA_PTX_DRX_P0_C: CS42.2 JSATA1.33
SBD_INT#: T253.1(TP-1) U636.D6
SBD_WAKE#: T252.1(TP-1) U636.F8
SENSOR_I2C_SCL: R854.1 R985.2 U636.B5 U637.2 U638.2
SENSOR_I2C_SDA: R855.1 R986.2 U636.C5 U637.3 U638.3
SENSOR_RST#: JSATA1.20 R1090.2
SERIRQ: RH29.2 U34.M3 U652.27 UH1.Y4
SGATE: PR22.2 PU2.26
SH_DFU_EN#: RH307.1 U636.F2 UH1.K42
SH_PWR_CNTRL: C1207.1 Q334.2 R1105.1 RH257.1 UH1.W12
SH_VBAT: R1101.2 R1102.2 R1105.2 U636.C6
SM_INTRUDER#: RH11.2 UH1.K22
SM_RCOMP0: RC55.1 UCPU1.BF44
SM_RCOMP1: RC58.1 UCPU1.BE43
SM_RCOMP2: RC60.1 UCPU1.BG43
SMBALERT#: R812.1 UH1.H12
SMBCLK: Q327.6 QH3.6 R724.2 RH67.1 RH105.1 UH1.F17
SMBDATA: Q327.3 QH3.3 R725.2 RH69.1 RH111.1 UH1.F10
SML0CLK: RH70.1 UH1.K12
SML0DATA: RH72.1 UH1.A9
SML1CLK: QH4.6 RH73.1 UH1.D12
SML1DATA: QH4.3 RH74.1 UH1.C11
SNUB_1.5V: PC311.1 PR302.2
SNUB_1.5VSP: PC409.1 PR406.2
SNUB_1.8VSP: PC405.1 PR400.2
SNUB_3V: PC212.1 PR208.2
SNUB_5V: PC213.1 PR209.2
SOSCI: CH1202.1 U636.B8 Y1.2
SOSCO: CH1203.1 U636.B7 Y1.1
SUS_A#: T216.1(TP-1) UH1.C7
SUS_STAT#: T76.1(TP-1) UH1.G6
SUSACK#: T218.1(TP-1) U34.M13 UH1.F15
SUSCLK: CH102.2 RH132.2 UH1.D3
SUSCLK_R: R253.1 RH132.1
SUSP: Q4.2 Q34.2 Q330.1 R1024.2
SUSP#: PR308.1 PR402.1 PR405.1 PR503.1 Q330.2 R1027.1 RC104.1 U34.G4 U654.3 U655.5
SUSWARN#: RH154.1 RH297.1 UH1.C13
SW_1.35V: PC301.2 PL1210.2 PQ1215.1 PQ1215.2 PQ1215.3 PQ1226.5 PR302.1 PU300.16
SW_+V1.05S_VCCPP: PC504.2 PL1212.1 PQ1211.1 PQ1211.2 PQ1211.3 PQ1219.5 PR504.1 PU500.8
SW_USB20_N1: L40.1 R222.1 UI1.2
SW_USB20_P1: L40.4 R262.1 UI1.3
SYS_PRS: JBATT9.4 PR918.1
SYS_PWROK: RH272.1 RH273.2 UH1.M10
SYSON: PR306.1 Q35.5 R923.1 U34.B2
SYSON#: Q35.2 Q35.3 R295.2
SYSTEM_FAN_FB: D81.2 R884.1 U34.M11
SYSTEM_FAN_PWM: JFAN1.3 R1103.1 U34.N10
TABLET_MODE: JLVDS2.18 R980.1 U34.N2
TP_CLK: C1155.1 L60.1 R223.2 U34.A5
TP_CLK_C: C1157.1 DE1.2 JTP1.3 L60.2
TP_DATA: C1154.1 L59.1 R224.2 U34.B5
TP_DATA_C: C1156.1 DE1.3 JTP1.2 L59.2
TPM_DET: RH274.2 RH337.1 UH1.AA3
TRIP_+V1.05S_VCCPP: PR502.2 PU500.2
UG_3V: PQ1207.4 PT3.1(TP-1) PU501.8
UG_5V: PQ1209.4 PT4.1(TP-1) PU501.18
UG_+V1.05S_VCCPP: PQ1211.4 PT7.1(TP-1) PU500.9
UGATE: PQ1223.4 PT1.1(TP-1) PU2.24
UGATE1: PR940.1 PU700.21
UGATE1G: PR939.1 PU700.32
USB3RN0: L54.4 R892.1 UH1.BJ25
USB3RN0_RC_CON: D82.1 JUSB2.5 L54.3 R892.2
USB3RN1: L46.1 R560.1 UH1.BJ27
USB3RN1_RC_CON: D74.1 JUSB1.5 L46.2 R560.2
USB3RP0: L54.1 R893.1 UH1.BL25
USB3RP0_RC_CON: D82.2 JUSB2.6 L54.2 R893.2
USB3RP1: L46.4 R565.1 UH1.BL27
USB3RP1_RC_CON: D74.2 JUSB1.6 L46.3 R565.2
USB3TN0: C1108.1 UH1.BF26
USB3TN0_C: C1108.2 L53.4 R891.1
USB3TN0_RC_CON: D82.3 JUSB2.8 L53.3 R891.2
USB3TN1: C623.1 UH1.BB28
USB3TN1_C: C623.2 L45.4 R556.1
USB3TN1_RC_CON: D74.3 JUSB1.8 L45.3 R556.2
USB3TP0: C1107.1 UH1.BD26
USB3TP0_C: C1107.2 L53.1 R890.1
USB3TP0_RC_CON: D82.4 JUSB2.9 L53.2 R890.2
USB3TP1: C621.1 UH1.AY28
USB3TP1_C: C621.2 L45.1 R555.1
USB3TP1_RC_CON: D74.4 JUSB1.9 L45.2 R555.2
USB20_N0: L52.1 R888.1 UH1.F24
USB20_N0_CONN: D82.6 JUSB2.2 L52.2 R888.2
USB20_N1: UH1.C25 UI1.7
USB20_N1_CONN: D74.6 JUSB1.2 L40.2 R222.2
USB20_N4: L49.1 R742.1 UH1.M26
USB20_N4_R: JWLAN1.36 L49.2 R742.2
USB20_N9: D90.3 JLVDS1.18 UH1.C29
USB20_N12: L55.4 R1005.1 UH1.H30
USB20_N12_CONN: D50.1 JLVDS2.3 L55.3 R1005.2
USB20_N13: U636.C1 UH1.M33
USB20_P0: L52.4 R889.1 UH1.H24
USB20_P0_CONN: D82.5 JUSB2.3 L52.3 R889.2
USB20_P1: UH1.A25 UI1.6
USB20_P1_CONN: D74.5 JUSB1.3 L40.3 R262.2
USB20_P4: L49.4 R741.1 UH1.K26
USB20_P4_R: JWLAN1.38 L49.3 R741.2
USB20_P9: D90.1 JLVDS1.19 UH1.A29
USB20_P12: L55.1 R1004.1 UH1.F30
USB20_P12_CONN: D50.3 JLVDS2.2 L55.2 R1004.2
USB20_P13: R817.2 R1104.1 U636.C2 UH1.K33
USB_MCARD1_DET#: JWLAN1.40 RH301.1 UH1.A41
USB_OC0#: RH318.1 U657.5 UH1.C17
USB_OC1#: RH321.1 U656.5 UH1.A17
USB_OC2#: RH317.1 UH1.A13
USB_OC3#: RH320.1 UH1.D16
USB_OC4#: RH323.1 UH1.A11
USB_OC5#: RH322.1 UH1.B16
USB_PWR_EN#: R887.2 U34.L12 U657.4
USBCHG_DET#: D83.1 JUSB1.10
USBCHG_DET_D: PD906.2 Q321.1 R938.1
USBCHG_DET_EC#: D83.3 R935.1 U34.N8
USBCHG_DET_PWR_EN#: D83.2 Q321.2 R939.2 R941.2
USBRBIAS: RH163.1 UH1.A33 UH1.C33
V_DDR_REFA_R: QD1.3 RD27.2 RD29.1 UCPU1.BE7
V_DDR_REFB_R: QD2.3 RD30.2 RD32.1 UCPU1.BG7
VCIN0_PH: PH901.1 PR935.1 R925.1
VCIN0_PH_R: R925.2 U34.C2
VCIN1_PH: PC911.1 PR936.1 PR937.2 R926.1
VCIN1_PH_R: R926.2 U34.D2
VCOMP: PC33.1 PU2.7
VCOMP1: PC27.1 PC28.1 PC36.2 PD5.1 PQ103.1 PQ103.2 PQ103.3 PR25.1
VCOUT0_PH#: PR211.1 PR971.1 R922.1 U34.E4
VFB: PR36.2 PR37.1 PU2.8
VGATE: PR728.1 PU700.19 RH273.1 U34.M10
VLDOIN_1.35V: PR119.1 PU300.19
VOLUME_DOWN_SW#: C1124.1 R954.1 R955.2 U34.J1
VOLUME_DOWN_SW#_C: JIOL1.33 R955.1
VOLUME_UP_SW#: C1123.1 R952.1 R953.2 U34.A9
VOLUME_UP_SW#_C: JIOL1.35 R953.1
VR_HOT#: PC717.1 PR725.2 PU700.8 R265.2
VR_ON: PR723.1 U34.H5
VR_SVID_ALRT#: PU700.6 RC93.2 RC94.2
VR_SVID_CLK: PR719.2 PU700.5 RC92.2
