# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS: length 381.7
  TOP w0.122: v7(155.68,71.26) 156.67,71.26 v9(157.22,71.81) ; R884.2 4.61,22.11
  TOP w0.254: PR601.1 114.79,81.75 115.16,81.38 117.05,81.38 117.44,81.78 123.6,81.78 124.26,81.11 ; RH193.2 108.59,53.67 v7(108.59,53.05) ; RH100.2 110.38,53.14 v7(110.47,53.05) ; RH257.2 107.45,53.62 107.45,53.1 v7(107.47,53.07) 107.47,53.07 107.44,53.07 107.02,52.66 RH29.1 ; v2(176.22,47.09) 176.14,47.01 RH294.2 ; QH4.5 125.22,58.13 125.39,58.31 125.39,58.72 v7(125.56,58.89) 125.85,58.6 125.85,58.27 125.99,58.13 QH4.2 ; v7(109.56,53.05) 109.45,53.16 RH95.2 ; v2(111.21,72.73) 111.6,72.34 CH68.1 ; v2(110.18,72.29) 110.59,71.88 CH36.1 ; 4.61,22.11 v7(4.61,22.75) ; RH99.2 137.36,26.12 136.07,26.12 135.69,25.74 QH3.5 QH3.2 135.69,23.42 134.84,22.57 RH98.2 ; v2(108.11,63.23) 107.67,62.79 CH65.1 ; v2(106.38,57.59) 106,57.98 CH69.1
  TOP w0.305: v2(168.36,59.05) 168.02,58.72 RV2.2 ; RH302.2 118.83,77.4 118.83,77.32 v2(118.82,77.3)
  TOP w0.356: C1140.1 167.48,56.13 166.67,55.32 U652.10
  TOP w0.381: v7(158.68,54.5) 158.68,54.52 158.66,54.55 158.68,54.57 158.68,54.85 159.15,55.32 U652.19 ; UH5.5 136.25,78.02 135.57,78.7 134.36,78.7 133.79,79.27 133.34,79.27 v7(132.77,79.84) ; v7(158.54,51.57) 159.04,52.07 U652.24 ; Q328.2 178.25,33.2 v7(177.98,32.93) ; DH3.2 129.05,68.98 v7(129.5,69.43) ; v7(53.14,86.09) 53.14,85.26 53.57,84.83 C655.1 52.85,83.9 U635.5 ; RH181.2 112.25,53.37 v7(112.58,53.05) ; R218.1 135.78,58.64 v7(135.73,58.59) ; v7(173.36,62.04) 172.96,62.45 RH282.1 ; Q326.2 165.52,34.77 165.06,35.24 v7(165.06,35.39) ; C1139.1 167.11,52.63 166.55,52.07 U652.5
  TOP w0.457: RH307.2 RH271.2 118.73,74.17 119.03,74.46 v7(119.43,74.46) 119.62,74.26 RH180.2
  TOP w0.508: C1139.1 167.95,52.63 168.38,52.2 v2(168.38,51.94) ; v7(149.32,58.06) 148.88,58.51 R247.2 148.61,58.54 R223.1 R224.1 ; PR500.2 129.06,47.56 v7(129.7,47.56) ; v7(135.74,61.76) 135.77,61.79 135.77,62.01 135.97,62.22 RH174.2 ; v7(158.54,51.57) 157.91,51.57 157.56,51.23 157.56,47.94 C1136.1 C1135.1 159.19,47.71 159.86,48.38 U652.28 ; R1094.2 147.47,73.43 v7(148.04,72.86) 148.7,73.52 QH8.3 ; RH230.1 134.42,68.08 v7(133.87,68.64) ; RH281.1 169.26,62.45 v7(168.61,61.8) ; v7(168.94,55.17) 168.91,55.14 R975.2 C1140.1 ; v7(175.17,31.84) 176.16,32.83 177.3,32.83 177.4,32.93 v7(177.98,32.93) ; CH44.1 94.57,67.27 v7(93.5,68.34) ; C1137.1 154.9,68.1 154.9,70.83 155.33,71.26 v7(155.68,71.26)
  TOP w0.762: RH99.2 138.3,27.06 140.99,27.06 141.51,27.58 142.68,27.58 143.25,27.02 v7(143.25,26.38) 145.14,26.38 145.93,25.59 145.93,22.9 146.74,22.09 171,22.09 171.69,22.78 171.69,27.76 173.51,29.58 173.51,31.36 174.25,32.09 174.91,32.09 v7(175.17,31.84)
  GND1 w0.254: v3(107.68,63.41) 107.86,63.23 v2(108.11,63.23) ; v2(148.58,56.59) 148.58,56.8 v3(148.86,57.09) ; v3(106.43,58.03) 106.43,57.65 v2(106.38,57.59) ; v3(167.93,59.17) 167.94,59.18 168.23,59.18 v2(168.36,59.05) ; v2(111.21,72.73) 111.21,72.71 111.36,72.56 v3(111.36,72.33) ; v3(135.66,55.69) 135.85,55.88 v2(136.37,55.88) ; v2(110.18,72.29) v3(110.67,71.79) ; v2(179.25,40.51) v3(178.8,40.51)
  GND1 w0.381: v3(118.82,76.87) 118.83,76.89 118.83,77.29 v2(118.82,77.3)
  GND1 w0.508: v2(176.22,47.09) 176.17,47.05 v3(175.57,47.05) ; v2(168.38,51.94) 168.36,51.96 v3(168.36,52.39)
  IN1 w0.254: v3(178.8,40.51) 179.16,40.14 179.16,38.31 179.43,38.05 179.43,34.72 177.98,33.27 v7(177.98,32.93) ; v3(148.86,57.09) 148.55,57.09 v4(148.39,57.24) ; v4(105.92,58.03) v3(106.43,58.03) ; v3(111.36,72.33) 110.78,72.33 110.73,72.28 v4(110.75,72.28) ; v3(135.66,55.69) 135.89,55.69 v4(136.17,55.41) ; v4(107.5,63.87) 107.68,63.69 v3(107.68,63.41) ; v3(167.93,59.17) 167.39,59.17 v4(167.37,59.19) ; v7(29.68,77.12) 30.43,77.12 33.81,80.49 34.18,80.49 36.55,82.87 40.2,82.87 42.01,84.68 43.43,84.68 44.28,85.53 v4(44.98,85.53) ; v4(111.23,71.79) v3(110.67,71.79)
  IN1 w0.381: v4(118.49,76.52) 118.82,76.85 v3(118.82,76.87)
  IN1 w0.508: v4(175.57,46.42) v3(175.57,47.05) ; v3(168.36,52.39) v4(167.95,52.79)
  IN2 w0.381: v7(125.56,58.89) 125.85,59.18 127.97,59.18 129.2,57.95 135.1,57.95 v7(135.73,58.59)
  IN2 w0.508: v7(79.59,53.58) 80.78,54.78 v4(91.35,54.78)
  IN3 w0.254: v4(110.75,72.28) 109.61,73.42 102.32,73.42 101.1,72.2 101.1,71.59 101.15,71.54 101.15,71.16 100.62,70.64 99.84,70.64 98.53,69.33 97.34,69.33 96.15,68.14 93.71,68.14 v7(93.5,68.34) ; 103.94,54.17 103.92,54.19 103.92,56.02 v4(105.92,58.03) 106.99,59.09 107.89,59.09 108.16,59.36 108.16,59.75 107.83,60.08 107.02,60.08 106.76,60.34 106.76,62.06 107.68,62.98 107.68,63.69 v4(107.5,63.87)
  IN3 w0.508: v4(91.35,54.78) 91.7,54.42 95.41,54.42 95.66,54.17 105.09,54.17 v4(105.8,53.45)
  IN4 w0.254: v7(4.61,22.75) 6.56,22.75 8.85,25.03 10.22,25.03 10.37,24.88 10.9,24.88 11.77,25.74 v7(15.08,25.74) ; v4(44.98,85.53) 52.59,85.53 v7(53.14,86.09) 53.72,85.52 74.2,85.52 75.95,83.77 80.44,83.77 v4(80.65,83.55) ; v7(13.85,28.36) 14.28,28.79 14.28,33.21 12.86,34.63 12.86,38.82 v7(12.94,38.9) ; v5(107.7,64.33) 107.7,64.07 v4(107.5,63.87) ; v7(107.47,53.07) 106.99,53.07 106.99,53.07 106.37,53.07 105.99,53.45 v4(105.8,53.45) v5(105.25,53.45) ; v4(110.6,76.87) 110.5,76.77 v5(110.09,76.77) ; v5(110.73,71.79) v4(111.23,71.79) 111.23,72.25 v5(111.26,72.28) v4(110.75,72.28) ; v5(111.54,48.89) 111.56,48.92 v5(111.56,49.77) ; v5(106.43,58.03) v4(105.92,58.03) ; v7(93.5,68.34) 95.05,68.34 95.34,68.05 v5(95.83,68.05)
  GND5 w0.254: v5(105.25,53.45) 105.05,53.66 v6(104.79,53.66) ; v6(111.26,71.87) v5(111.26,72.28) ; v5(95.83,68.05) 95.95,68.05 96.33,67.67 v6(96.55,67.67) ; v5(107.7,64.33) 107.75,64.28 v6(107.75,63.92) ; v6(110.77,72.27) 110.73,72.22 v5(110.73,71.79) ; v7(112.83,50.53) 112.73,50.43 v6(111.56,50.43) v5(111.56,49.77) ; v6(105.98,58.03) v5(106.43,58.03) ; v6(110.09,77.2) v5(110.09,76.77)
  GND5 w0.508: v6(111.61,48.27) 111.61,48.81 v5(111.54,48.89)
  BOTTOM w0.203: JTP1.1 v7(143.25,26.38)
  BOTTOM w0.254: v7(132.77,79.84) 133.37,79.24 C1138.1 ; UH1.U37 110.39,71.46 UH1.T39 v6(110.77,72.27) ; v7(112.83,50.53) 112.5,50.86 RH32.1 ; PR728.2 29.8,77.24 v7(29.68,77.12) ; UH1.AB19 UH1.AC19 v6(107.75,63.92) ; RH276.1 v6(111.56,50.43) ; UH1.BK28 v6(96.55,67.67) ; UH1.R40 v6(111.26,71.87) ; UH1.U51 v6(110.09,77.2) ; v7(15.08,25.74) 15.1,25.72 JIOL1.6 ; v5(106.43,58.03) v6(105.98,58.03)
  BOTTOM w0.305: CC68.1 130.33,77.99 129.92,77.99 129.72,77.8 UC2.5
  BOTTOM w0.381: v7(158.85,72.59) 158.85,72.87 159.06,73.09 R1033.2 ; v7(110.47,53.05) 110.72,52.8 110.72,51.8 110.38,51.47 RH304.2 ; RH303.2 108.33,51.43 RH35.1 107.27,51.43 RH274.1 106.29,52.44 106.92,53.07 v7(107.47,53.07)
  BOTTOM w0.457: v7(119.43,74.46) 119.52,74.37 RH301.2 RH308.2
  BOTTOM w0.508: v7(129.19,77.2) 130.11,77.2 130.41,77.51 CC68.1 132.72,77.91 133.37,78.57 C1138.1 ; RH298.2 121.79,73.85 121.27,74.37 RH308.2 ; D90.5 v7(156.9,72.63) ; RH37.1 RH248.1 111.61,48.81 v6(111.61,48.27) ; v7(112.83,50.53) 113.37,51.07 RC42.2 ; v7(79.59,53.58) 75.5,53.58 74.81,54.27 70.72,54.27 v7(69.4,52.95) ; RH258.2 102.99,53.15 103.45,53.15 104.02,53.72 104.73,53.72 v6(104.79,53.66) ; v7(16.82,50.99) 16.82,46.32 15.73,45.22 15.73,44.09 15.02,43.38 15.02,43.01 14.82,42.81 14.82,41.39 13.88,40.45 13.88,39.81 12.96,38.9 v7(12.94,38.9)
  vias: v4(98.38,76.87) v4(98.81,77.28) v7(124.64,76.29) v7(126.85,76.29) v7(127.48,76.29) v7(166.16,44.75) v7(166.83,44.77) v7(167.84,69.98) v7(168.02,70.6) v7(169.39,57.49) v7(169.4,56.12) v7(172.47,77.28) v7(173.06,77) v7(173.69,77) v7(173.69,50.89) v7(173.69,50.25) v7(173.69,49.62) v7(173.72,48.98) v7(173.72,48.35) v7(174.33,77) v7(174.33,50.89) v7(174.33,50.25) v7(174.33,49.62) v7(200.57,73.01) v7(200.57,72.38) v7(201.2,73.01) v7(201.2,72.38)
+3VS_CAM: length 15.5
  TOP w0.508: Q47.1 181.29,74.66 v7(180.93,75.02) 181.46,75.55 C1159.1 181.46,76.57 182.15,77.25 C1158.1
  IN4 w0.254: v5(183.1,80.63) 183.06,80.63 182.23,79.79 182.23,77.66 180.93,76.37 v7(180.93,75.02)
  GND5 w0.104: v6(183.74,80.63) v5(183.1,80.63)
  BOTTOM w0.122: v1(181.93,72.81) 181.93,72.82 181.43,73.33 D50.5
  BOTTOM w0.254: D50.5 181.43,74.52 v7(180.93,75.02) ; v6(183.74,80.63) JLVDS2.4
+3VS_TS: length 22.6
  TOP w0.122: v1(168.18,79.63) v7(168.82,78.99)
  TOP w0.508: v7(168.82,78.99) 169.39,79.57 C1200.1 170.35,79.57 171.44,80.66 Q335.1 ; v7(169.3,76.2) 169.68,75.82 R1084.2
  IN2 w0.508: v7(168.82,78.99) 167,77.18 v7(158.55,77.18)
  IN4 w0.508: v7(169.3,76.2) 169.3,78.51 v7(168.82,78.99)
  BOTTOM w0.254: v7(158.55,77.18) 158.55,78.73 158.25,79.03 JLVDS1.17
+3VS_VCC_CLKF33: length 33.5
  TOP w0.254: v2(129.14,67.4) 129.76,66.78 129.76,65.76 CH66.1 130.37,66.09 130.37,66.75 v9(131.2,67.58) RH230.2 ; CH67.1 v2(110.29,70.95)
  GND1 w0.254: v3(129.14,67.88) v2(129.14,67.4) ; v2(110.29,70.95) v3(109.89,70.95)
  IN1 w0.254: v4(129.22,68.39) 129.14,68.31 v3(129.14,67.88) ; v3(109.89,70.95) 109.89,71.01 v4(109.56,71.34)
  IN3 w0.254: v4(109.56,71.34) 110.33,70.56 111.96,70.56 113.47,69.04 119.16,69.04 121.75,66.46 125.61,66.46 128.05,68.9 128.84,68.9 129.19,68.54 129.19,68.44 129.22,68.41 v4(129.22,68.39)
  IN4 w0.254: v5(109.86,71.84) 109.86,71.64 v4(109.56,71.34)
  GND5 w0.254: v6(109.86,71.44) v5(109.86,71.84)
  BOTTOM w0.254: UH1.V37 109.86,71.17 v6(109.86,71.44) 109.86,71.79 UH1.V39
+3VS_WLAN: length 20.8
  TOP w0.122: C713.1 180.22,48.79 180.66,48.35 v7(181.16,48.35)
  TOP w0.254: Q327.5 Q327.2 176.98,38.4 R1019.2
  TOP w0.305: 176.89,42.4 176.98,42.3 Q327.5
  TOP w0.381: v7(178.13,29.67) 177.9,29.9 R1020.1
  TOP w0.508: JWLAN1.24 180.9,36.95 180.23,36.28 179.92,36.28 C714.1 179.91,35.73 180.88,35.73 v7(181.31,36.16) ; JWLAN1.2 180.83,24.95 180.39,25.39 179.7,25.39 R942.1 C715.1 178.02,25.46 v7(178.01,25.46) ; C712.1 176.89,43.24 176.89,42.4 ; C716.1 179.87,33.01 v7(180.3,33.44)
  IN1 w0.508: v7(181.16,48.35) 181.36,48.15 JWLAN1.52
  vias: v7(177.38,54.8) v7(177.76,55.38) v7(178.01,54.8) v7(178.44,55.33) v7(178.65,54.72) v7(178.57,43.24) v7(178.57,42.61) v9(177.02,55.54)
+5V_CHGUSB: length 19.7
  TOP w0.508: v7(220.66,27.65) 217.71,27.65 216.75,28.61 216.75,32.93 JUSB1.1
  IN4 w0.508: JUSB1.1 217.42,32.69 216.78,32.06 216.78,28.64 217.77,27.65 v7(220.66,27.65)
  BOTTOM w0.381: v7(216.4,21.96) 216.4,21.43 D74.8
  vias: v7(215.07,55.21) v7(215.7,55.21) v7(216.75,54.19) v7(216.75,53.56) v7(217.38,53.4) v7(220.26,21.95) v7(220.66,27.01) v7(220.66,26.38) v7(221.53,26.57) v9(216.17,57.52)
+5V_PCH: length 5.8
  TOP w0.122: RH295.1 134.07,66 v1(134.3,66.23)
  TOP w0.254: RH295.1 RH222.1 133.37,64.54 CH116.1 132.52,64.19 132.47,64.24 132,64.24 131.25,63.49 QH7.1
+5V_USB_P0: length 4.6
  TOP w0.122: v9(215.86,62.65) 215.86,62.19 215.13,61.47
  BOTTOM w0.254: D82.8 216.55,56.39 216.75,56.2 v7(216.75,56.17)
  BOTTOM w0.508: C1110.1 215.83,50.25 v7(216.85,51.27)
  vias: v7(215.25,60.81) v7(215.22,60.13) v7(215.68,61.3) v7(215.89,60.68)
+5VALW: length 453
  TOP w0.203: U654.4 173.36,65.21 173.31,65.17 173.31,64.1 C1161.1 ; C1167.1 169.73,51.96 170.37,52.59 U655.4
  TOP w0.254: UI1.5 210.51,54.43 210.29,54.65 208.95,54.65 C961.2 ; PR904.2 189.29,83.91 188.53,83.91 188.2,83.58 188.2,81.8 188.09,81.7 188.09,80.5 PD901.3 ; v7(30.49,19.42) 30.49,19.47 30.72,19.7 30.72,19.71 30.97,19.96 PU300.12 ; PU500.7 124.65,44.27
  TOP w0.381: C1167.1 169.74,51.91 170.35,51.91 170.45,52.01 v7(170.49,52.01) ; v2(185.27,82.23) 185.27,81.85 186.16,80.96 187.03,80.96 PD901.3
  TOP w0.508: R287.1 128.59,52.27 128.14,52.73 128.14,53.62 127.69,54.06 127.31,54.06 ; QH7.3 130.97,61.4 v7(130.51,61.86) ; PR303.1 26.92,19.19 v7(26.94,19.17) ; C961.2 208.74,54.7 208.26,55.18 v7(207.86,55.18) ; PR603.2 112.87,84.95 PC601.2 113.55,84.53 v7(113.84,84.24) ; 124.65,44.27 124.62,44.23 124.62,43.7 123.95,43.03 PC506.1 123.83,42.63 122.61,43.85 122.61,48.22 121.95,48.88 121.95,49.75 121.37,50.33 121.37,50.91 121.91,51.46 122.35,51.46 v9(122.67,51.79) 123.2,52.31 v7(126.47,52.31) 126.93,52.77 126.93,53.68 127.31,54.06 ; v7(174.02,62.93) 173.83,63.12 C1161.1 ; 127.31,54.06 127.31,54.76 126.93,55.14 v2(126.93,56.35) ; v7(18.37,18.99) 18.37,19 17.65,19.72 16.19,19.72 v7(14.99,20.92) 14.99,20.64 14.26,19.9 C1098.2 ; R295.1 v7(149.19,66.42) ; v7(186.32,78.63) 186.4,78.63 187.79,80.02 PD901.3 ; v7(216.67,52.62) 216.66,52.62 216.05,53.23 R808.1
  GND1 w0.254: v3(184.94,82.84) 184.94,82.56 v2(185.27,82.23) ; v2(231.5,8) v3(230.75,8) ; v2(231.5,15.2) v3(230.72,15.2) ; v2(231.5,4.4) v3(230.65,4.4) ; v2(231.5,11.6) v3(230.57,11.6) ; v2(231.5,0.8) v3(231.5,1.59)
  GND1 w0.508: v2(126.93,56.35) 127.29,56.71 v3(127.29,57.02)
  IN1 w0.254: v3(230.72,15.2) v4(230.72,15.99) ; v3(231.5,1.59) 230.97,1.59 v4(230.8,1.75) ; v3(230.65,4.4) v4(230.65,5.11) ; v3(230.57,11.6) v4(230.57,12.49) ; v3(230.75,8) v4(230.75,8.79)
  IN1 w0.508: v3(127.29,57.02) 127.53,57.02 130.13,59.61 130.13,60.87 130.51,61.25 v7(130.51,61.86) ; v7(14.99,20.92) 14.41,20.92 14.31,20.82 13.09,20.82 11.79,22.11 11.79,23.66 12.53,24.4 12.53,27.95 13.72,29.15 13.95,29.15 14.29,29.49 14.29,29.97 14.69,30.36 14.69,33.95 14.08,34.56 14.08,38.86 15.48,40.26 15.48,41.85 15.89,42.27 16.89,42.27 18.14,43.52 21.72,43.52 22.33,44.13 v4(22.33,44.66) ; v7(26.94,19.17) 26.92,19.14 24.54,19.14 24.01,19.67 19.06,19.67 v7(18.37,18.99) ; v3(184.94,82.84) 179.43,82.84 178.72,83.55 171.66,83.55 170.16,85.05 166.78,85.05 166.38,84.65 162.47,84.65 162.06,85.05 153.47,85.05 149.1,80.68 134.87,80.68 133.5,82.05 128.39,82.05 127.06,83.39 125.41,83.39 124.2,82.18 117.86,82.18 117.57,81.89 114.03,81.89 113.05,82.87 113.05,83.74 113.55,84.24 v7(113.84,84.24)
  IN2 w0.508: v7(30.49,19.42) 30.21,19.14 26.97,19.14 v7(26.94,19.17) ; v7(186.32,78.63) 183.85,76.16 183.85,75.12 181.72,72.99 172.85,72.99 169.83,69.96 169.83,67.96 170.49,67.3 170.49,66.26 v7(171.38,65.37)
  IN3 w0.254: 119.25,71.27 119.13,71.14 ; 119.13,71.14 118.56,70.57 116.31,70.57 116.11,70.78 116.06,70.78 ; 119.13,71.14 118.66,71.6 116.38,71.6 115.55,70.78
  IN3 w0.508: 130.51,72.71 133.74,72.71 136.02,70.42 137.22,70.42 137.57,70.07 140.57,70.07 140.94,70.44 140.96,70.44 141.1,70.57 146.01,70.57 148.74,67.84 148.74,66.87 v7(149.19,66.42) 149.66,66.89 149.66,69.33 150.03,69.7 151.63,69.7 153.28,68.05 156.69,68.05 157.46,67.27 161.7,67.27 162.59,68.16 165.79,68.16 169.07,64.88 170.19,64.88 170.97,64.1 v7(171.38,64.1) ; 130.51,72.71 121.26,72.71 120.25,71.69 119.68,71.69 119.25,71.27 ; 130.51,72.71 130.51,71.46 131.28,70.69 131.28,62.63 v7(130.51,61.86) ; v4(22.33,44.66) 22.33,43.56 24.19,41.69 25.1,41.69 26.09,40.7 28.2,40.7 29.19,41.69 30.79,41.69 32.06,42.96 36.67,42.96 50.49,56.78 50.49,63.68 53.11,66.3 53.11,66.97 54.32,68.18 54.84,68.71 58.62,68.71 59.99,70.08 59.99,71.94 60.79,72.73 71.03,72.73 72.19,71.56 72.88,71.56 73.24,71.21 73.39,71.21 73.77,70.83 73.77,70.68 74.58,69.86 75.39,69.86 75.75,69.51 75.75,68.54 76.33,67.96 76.33,65.6 77.27,64.66 90.51,64.66 91.98,66.13 94.37,66.13 94.72,66.48 97.8,66.48 98.97,65.32 100.85,65.32 101.38,65.85 103.18,65.85 103.94,66.61 103.94,68.59 105.14,69.79 105.14,70.24 106.53,71.64 107.09,71.64 108.34,72.89 109.13,72.89 110.88,71.13 112.2,71.13 112.81,70.52 115.3,70.52 115.55,70.78 116.06,70.78
  BOTTOM w0.254: v7(14.99,20.92) 15.1,20.81 JIOL1.5 ; v7(14.99,20.92) 14.99,20.94 14.97,20.92 v7(14.99,20.92)
  BOTTOM w0.508: v7(170.49,52.01) 170.49,52.04 169.98,52.55 169.98,55.45 172.09,57.56 172.09,62.98 ; v7(30.49,19.42) 30.49,19.27 30.97,18.78 30.97,18.68 31.33,18.33 33.2,18.33 33.66,18.78 PC307.2
  vias: v7(171.38,64.73) v7(172.02,64.66) v7(172.32,64.07) v7(205.8,71.21) v7(206.43,71.21) v7(206.38,70.19) v7(207.02,70.19) v7(207.07,71.21) v7(207.44,60.41) v7(207.44,59.78) v7(207.65,70.19) v7(207.91,70.78) v7(208.07,60.41) v7(208.29,70.19) v7(210.47,70.19) v7(210.89,70.85) v7(211.2,70.19) v7(211.55,70.87) v9(207.77,68.25) v9(211.86,68.99)
+5VS: length 215.3
  TOP w0.254: v7(20.3,74.33) v9(18.12,76.52) 17.84,76.8 v7(17.84,79.01) 17.76,79.08 PR716.1 ; QV1.2 210.22,77 v7(210.87,77.65)
  TOP w0.508: C1099.2 14.03,24.69 13.77,24.96 v7(13.34,24.96) ; C1146.2 13.96,21.09 14,21.13 v7(14,21.45) ; v7(129.09,75.15) 128.96,75.02 RH227.1 129.56,72.45 130.49,73.37 133.93,73.37 134.82,72.48 QH1.2
  TOP w1.016: 174.43,45.68 173.79,45.05 173.79,35.9 172.07,34.18 172.07,34.02 Q329.3
  IN1 w0.254: v7(17.84,79.01) 17.84,84.67 18.73,85.56 21.22,85.56 21.98,86.32 v7(21.98,86.58)
  IN1 w0.508: v7(15.76,25.74) 15.76,26.58 15.35,26.99 15.35,28.82 15.51,28.98 15.51,29.46 15.91,29.85 15.91,37.27 16.76,38.13 16.76,39.64 17.91,40.79 17.91,41.21 18.93,42.23 19.34,42.23 19.87,41.69 21.84,41.69 23.67,43.52 v7(23.67,44.68)
  IN1 w1.016: v7(178.75,62.32) v7(177.88,62.32) 177.88,63.39 178.24,63.74 178.24,67.48 v7(178.49,67.73) 178.49,67.81 179.4,68.71 179.41,68.71 v7(179.45,68.75)
  IN2 w0.508: v7(210.87,77.65) 202.45,77.65 200.21,79.89 198.64,79.89 197.03,81.5 190.05,81.5 184.46,75.91 184.46,74.87 181.97,72.38 174.07,72.38 v4(173.16,71.46)
  IN4 w0.254: v7(29.57,86.09) 28.25,84.77 27.19,84.77 27.03,84.92 23.63,84.92 v7(21.98,86.58)
  IN4 w0.508: 17.96,50.38 17.43,50.91 17.43,63.41 16.26,64.58 16.26,73.57 17.03,74.33 v7(20.3,74.33)
  IN4 w1.016: 171.04,83.38 179.93,83.38 ; v7(177.88,62.32) v7(178.75,62.32) 178.75,60.97 184.23,55.49 184.23,52.79 183.13,51.69 181.35,51.69 180.86,52.18 179.48,52.18 176.08,48.78 176.08,47.46
  GND5 w0.104: v6(170.85,83.91) v5(170.85,84.35) ; v6(180.66,84.12) v5(180.66,83.69) ; v6(171.29,83.9) v5(171.29,84.33) ; v6(181.11,84.12) v5(181.11,83.69)
  BOTTOM w0.254: v7(21.98,86.58) 21.98,86.41 22.47,85.92 PR720.1 ; v7(14,21.45) 14,20.76 ; PR736.1 29.6,86.07 v7(29.57,86.09) ; JIOL1.3 14.6,20.46 ; 14.1,20.67 JIOL1.1
  BOTTOM w0.508: v7(20.3,74.33) 21.6,74.33 21.97,74.7 PR722.2 PR724.2 23.95,74.7 PR721.1 ; v7(164.62,33.25) 165.21,33.25 C1153.1 166.37,33.88 R989.2
  BOTTOM w1.016: 170.99,83.11 170.99,77.9 171.41,77.48 C1198.1 171.41,71.6
  vias: v7(7.39,19.67) v7(8.02,19.7) v7(13.34,24.32) v7(13.34,21.45) v7(28.43,49.39) v7(29.06,49.39) v7(29.17,48.3) v7(29.8,48.3) v7(156.93,32.04) v7(157.56,32.04) v7(169.63,34.12) v7(170.47,69.3) v7(170.52,34.12) v7(171.43,67.93) v7(171.48,68.57) v7(172.14,68.57) v7(173.01,69.53) v7(173.97,47.36) v7(174.35,46.85)
+5VS_KBL:
  vias: v9(171.36,32.44)
+V1.05S_VCCP_PWRGOOD: length 64.1
  TOP w0.122: v7(108.24,80.25) 108.62,80.63 108.62,83.31 107.88,84.05 PR604.2 ; v7(128.12,46.93) PR500.1 127.79,47.92 PU500.1
  IN4 w0.071: v5(120.76,79.84) 120.74,79.86 119.49,79.86 117.72,81.64 111.75,81.64 111.19,81.08 109.07,81.08 108.24,80.25 v7(108.24,80.25)
  GND5 w0.104: v5(120.76,79.84) 120.85,79.93 v6(121.19,79.93)
  BOTTOM w0.122: v6(121.19,79.93) 121.74,80.48 124.12,80.48 125.6,79.01 125.6,77.98 125.46,77.84 125.46,76.75 125.58,76.62 v1(125.58,76.06) 125.93,75.72 127.67,75.72 128.04,75.35 128.04,74.7 127.48,74.15 127.48,73.68 128.68,72.48 128.68,71.26 127.92,70.5 127.92,68.74 127.85,68.67 127.85,67.42 127.68,67.25 127.68,64.3 127.63,64.26 127.63,60.3 126.08,58.75 126.08,54.55 125.78,54.25 125.78,52.25 127.31,50.71 127.31,47.74 v7(128.12,46.93)
+V1.05S_VCCPP_B+: length 3.2
  TOP w0.122: 116.72,41.42 v9(119.92,41.42)
+V18R: length 2.7
  TOP w0.254: U34.L1 140.23,62.3 140.23,62.67 139.78,63.12 v1(139.78,63.28) 139.78,63.92 139.4,64.3 C293.1
+VCC_CORE: length 24.6
  TOP w0.381: PC1226.1 53.55,83.1 50.77,83.1 RC97.1
  IN4 w0.254: v5(64.22,79.79) 63.74,79.79 v4(63.66,79.87) ; v5(65.29,77.18) 65.29,76.82 v4(65.44,76.67) ; v4(68.89,77.46) 69.17,77.46 v5(69.37,77.25) ; v5(64.9,75.86) v4(64.9,76.34) ; v5(66.02,76.62) 66.12,76.52 v4(66.12,76.14) ; v4(68.08,74.66) 68.08,74.23 v5(68,74.16) ; v4(62.08,76.67) 61.98,76.57 v5(61.98,76.16) ; v5(67.11,77.2) 66.68,77.2 66.58,77.3 v4(66.58,77.36) ; v4(64.68,76.9) 64.65,76.87 64.62,76.87 64.5,76.75 v5(64.17,76.75) ; v4(68.94,74.43) 68.94,74.03 v5(69.02,73.95) ; v5(67.27,74.05) v4(67.27,73.57) ; v5(69.37,74.21) v4(69.86,74.21) ; v5(68.99,76.39) v4(68.99,76.87) ; v5(66.71,75.12) v4(66.71,75.96) ; v5(65.49,74.16) 65.44,74.1 v4(65.44,73.67) ; v5(68.18,77.3) v4(68.18,76.82) ; v5(63.63,74.18) v4(64.12,74.18) ; v5(67.16,76.75) v4(66.68,76.75) ; v5(66.3,74.84) v6(66.3,74.36)
  GND5 w0.254: v6(64.9,75.43) v5(64.9,75.86) ; v6(66.71,75.55) v5(66.71,75.12) ; v5(69.37,74.21) 69.76,74.21 v6(69.83,74.28) ; v6(66.73,77.48) 66.83,77.48 v5(67.11,77.2) ; v6(66.02,76.19) v5(66.02,76.62) ; v6(64.22,79.34) v5(64.22,79.79) ; v5(65.49,74.16) 65.46,74.13 v6(65.46,73.62) ; v6(66.73,76.75) v5(67.16,76.75) ; v6(68,74.59) v5(68,74.16) ; v6(68.99,77.51) 69.12,77.51 v5(69.37,77.25) ; v6(65.29,76.75) v5(65.29,77.18) ; v6(63.63,73.75) v5(63.63,74.18) ; v6(68.99,76.82) v5(68.99,76.39) ; v5(64.17,76.75) 63.99,76.92 v6(63.71,76.92) ; v6(68.18,76.87) v5(68.18,77.3) ; v6(66.3,74.36) v5(66.3,74.84) ; v6(67.27,73.62) v5(67.27,74.05) ; v6(69.02,73.52) v5(69.02,73.95) ; v6(61.98,76.59) v5(61.98,76.16)
  BOTTOM w0.254: UCPU1.A42 62.19,79.73 62.19,79.13 UCPU1.C42
  vias: v7(31.93,73.88) v7(32.7,73.88) v7(32.82,72.1) v7(33.46,73.24) v7(33.84,71.97) v7(34.47,74.26) v7(34.6,72.86) v7(34.86,76.54) v7(34.86,75.27) v7(34.98,71.97) v7(35.36,74.13) v7(35.62,73.24) v7(36,72.22) v7(36.76,73.11) v7(37.01,73.88) v7(37.27,72.1) v7(37.78,73.88) v7(37.78,73.24) v7(54.67,86.07) v7(55.3,86.07) v7(55.94,86.07) v7(56.57,86.07) v7(57.21,86.07) v7(61.14,75.86) v7(62.19,73.45) v7(63.43,82) v7(63.43,80.73) v7(63.56,86.07) v7(64.09,73.45) v7(64.19,86.07) v7(64.19,80.33) v7(64.32,81.24) v7(64.83,86.07) v7(65.34,82) v7(65.34,80.73) v7(65.46,86.07) v7(65.97,81.24) v7(66.01,73.45) v7(66.1,86.07) v7(66.61,82) v7(66.73,86.07) v7(67.24,81.24) v7(67.37,86.07) v7(67.44,80.35) v7(67.88,82) v7(67.87,73.45) v7(68,86.07) v7(68.51,81.24) v7(68.64,86.07) v7(69.15,82) v7(69.27,86.07) v7(69.65,73.49) v7(69.78,81.24) v7(69.91,77.46) v7(69.91,76.82) v7(69.91,76.16) v7(70.42,82) v7(71.18,80.73) v7(71.69,82) v7(72.32,81.24) v7(72.96,82) v7(73.34,80.86) v9(61.23,74.74)
+VCC_GFXCORE_AXG: length 17.1
  TOP w0.254: RC135.1 56.32,82 55.71,82.61 51.24,82.61 50.98,82.36 50.98,81.8 51.25,81.54 51.25,80.98 52.46,79.77 52.46,78.14 54.69,75.91 55.38,75.22 55.38,74.51 55.01,74.14 55.01,73.25 55.1,73.16
  vias: v7(37.01,67.91) v7(37.01,66.89) v7(37.01,65.37) v7(37.01,64.22) v7(37.01,62.32) v7(37.65,66) v7(37.78,63.08) v7(38.16,68.67) v7(38.16,67.4) v7(39.17,68.41) v7(39.3,69.94) v7(39.3,67.4) v7(39.94,69.18) v7(39.94,67.4) v7(40.19,68.29) v7(40.44,70.07) v7(40.95,69.18) v7(41.13,68.21) v7(41.59,70.07) v7(42.6,69.94) v7(42.98,70.83) v7(42.98,68.03) v7(43.75,69.68) v7(43.75,68.92) v7(43.75,68.03) v7(44.51,70.83) v7(44.51,69.3) v7(44.51,68.03) v7(45.27,70.57) v7(45.27,69.68) v7(45.27,68.92) v7(45.27,68.03) v7(45.9,71.84) v7(45.9,70.95) v7(45.9,69.3) v7(45.9,68.54) v7(46.54,71.34) v7(46.51,70.47) v7(46.54,69.68) v7(46.54,68.87) v7(46.54,68.03) v7(47.17,71.84) v7(47.17,70.95) v7(47.17,70.19) v7(47.17,69.3) v7(47.81,72.1) v7(47.81,71.34) v7(47.84,70.6) v7(47.81,69.68) v7(47.81,68.03) v7(48.44,71.84) v7(48.44,70.19) v7(48.44,69.3) v7(48.44,68.54) v7(48.49,71.03) v7(49.08,72.22) v7(49.08,70.57) v7(49.08,69.68) v7(49.08,68.03) v7(51.35,69.35) v7(52,69.35) v9(40.02,65.76) v10(52.01,72) v10(53.51,71.81) v10(53.46,70.02) v10(53.5,69.11) v10(53.6,71) v10(54.2,69.22) v10(54.43,72.65) v10(54.38,71.16) v10(54.38,70.45) v10(55.1,72.63) v10(55.1,70.37) v10(55.74,70.38) v10(55.76,72.64) v10(56.39,72.64) v10(56.39,70.37) v10(57.04,70.37) v10(57.06,72.64) v10(57.7,72.64) v10(57.7,70.39) v10(59.03,72.7) v10(59.02,70.91) v10(58.98,70.02)
+VCCA_DPLL_L: length 2
  BOTTOM w0.122: v9(84.41,71.46) 85.1,70.78 86.16,70.78
+VCCA_USBSUS: length 4.1
  TOP w0.127: v2(101.07,68.44) 100.95,68.44 100.72,68.21 v1(100.48,68.21)
  TOP w0.508: v2(101.07,68.44) 101.6,68.44 CH55.1
  GND1 w0.508: v2(101.07,68.44) 101.11,68.48 v3(101.51,68.48)
  IN1 w0.508: v4(101.28,69.3) 101.5,69.08 101.5,68.48 v3(101.51,68.48)
  IN4 w0.254: v5(101.33,68.8) 101.33,69.25 v4(101.28,69.3)
  GND5 w0.254: v5(101.33,68.8) 101.48,68.95 v6(101.81,68.95)
  BOTTOM w0.254: UH1.AU31 v6(101.81,68.95)
+VCCACLK: length 7
  TOP w0.254: RH213.1 v9(105.98,75.53) 105.98,75.93 v2(107.14,77.1)
  GND1 w0.254: v3(107.58,77.1) v2(107.14,77.1)
  IN1 w0.254: v3(107.58,77.1) 107.83,77.36 108.69,77.36 108.9,77.15 v4(108.9,76.97)
  IN4 w0.254: v5(108.39,76.97) v4(108.9,76.97)
  GND5 w0.254: v5(108.39,76.97) 108.21,77.15 v6(107.96,77.15)
  BOTTOM w0.254: v6(107.96,77.15) 107.93,77.15 107.65,76.87 UH1.AC51
+VCCAFDI_VRM: length 38.1
  TOP w0.122: RH211.1 103.12,57.7 101.8,56.38 v1(101.8,56.05)
  TOP w0.508: v2(103.18,58.38) RH211.1
  GND1 w0.508: v2(103.18,58.38) v3(103.18,58.79)
  IN1 w0.508: v3(103.18,58.79) v4(103.18,59.37)
  IN2 w0.254: v4(101.38,63.49) 101.53,63.49 101.99,63.03 101.99,62.27 103.61,60.64 103.61,59.8 v4(103.18,59.37)
  IN3 w0.254: v4(103.18,59.37) 103.49,59.68 103.49,60.77 103.39,60.87 103.39,61.38 103.59,61.58 103.59,62.14 102.94,62.79 102.25,62.79 101.56,63.49 v4(101.38,63.49) 102.22,64.33 102.92,64.33 103.37,64.78 104.17,64.78 104.46,64.49 104.62,64.49 v4(106.08,63.03) 106.1,63.05 106.1,64.13 106.33,64.36 107.28,64.36 107.58,64.66 107.58,65.37 108.26,66.05 108.59,66.05 109.1,66.56 109.1,66.71 110.12,67.73 110.12,70.12 108.8,71.44 v4(108.8,72.28)
  IN4 w0.254: v5(106.43,62.67) 106.43,62.68 v4(106.08,63.03) ; v4(101.38,63.49) 101.38,63.54 101.03,63.88 v5(101.03,63.89) ; v5(108.31,72.28) v4(108.8,72.28)
  GND5 w0.254: v6(101.03,63.49) v5(101.03,63.89) ; v6(107.88,72.28) v5(108.31,72.28) ; v6(106.43,63.08) v5(106.43,62.67)
  BOTTOM w0.254: UH1.AF17 v6(106.43,63.08) 106.55,63.08 106.97,63.5 UH1.AE19 ; UH1.AW18 v6(101.03,63.49) ; UH1.AC39 v6(107.88,72.28)
+VCCAPLL_CPY: length 3.2
  TOP w0.122: RH216.2 92.13,73.39 v1(91.93,73.6)
  TOP w0.508: RH216.2 92.23,71.97 LH4.1
+VCCAPLL_CPY_PCH: length 10.2
  TOP w0.508: v2(100.62,68.85) 99.65,68.85 98.31,70.19 v9(97.11,70.19) CH49.1 95.13,71.91 LH4.2
  GND1 w0.279: v3(100.67,69.25) 100.62,69.2 v2(100.62,68.85)
  IN1 w0.279: v3(100.67,69.25) 100.67,68.85 v4(100.74,68.77)
  IN4 w0.279: v4(100.74,68.77) 100.62,68.9 v5(100.62,69.27)
  GND5 w0.279: v6(101.03,69.27) v5(100.62,69.27)
  BOTTOM w0.279: UH1.AW31 v6(101.03,69.27)
+VCCAPLLEXP: length 20
  TOP w0.508: LH3.2 99.73,58.38 CH35.1 99.8,58.46 v2(100.77,58.46)
  GND1 w0.508: v2(100.77,58.46) v3(100.36,58.46)
  IN1 w0.508: v3(100.36,58.46) v4(100.92,58.46)
  IN3 w0.254: 105.06,62.95 105.04,62.93 ; 105.04,62.93 105.04,63.57 104.47,64.13 104.31,64.13 104.02,64.43 103.58,64.43 103.28,64.13 103.28,63.89 103.16,63.77 v4(102.8,63.77) 102.66,63.77 102.53,63.64 102.53,63.36 102.72,63.17 103.08,63.17 103.32,62.93 105.04,62.93
  IN3 w0.508: v4(100.92,58.46) 103.09,58.46 105.54,60.91 105.54,61.48 105.75,61.68 105.75,62.42 105.21,62.95 105.06,62.95
  IN4 w0.254: v4(102.8,63.77) 102.85,63.82 v5(102.85,64.25)
  GND5 w0.254: v5(102.85,64.25) 103.13,63.97 v6(103.13,63.92)
  BOTTOM w0.254: UH1.AP19 v6(103.13,63.92)
+VCCAPLLEXP_R: length 3.1
  TOP w0.122: LH3.1 96.68,58.42 95.68,58.42 95.64,58.38 v9(95.45,58.38)
  TOP w0.508: LH3.1 96.72,56.64 RH201.1
+VCCDPLL_CPY: length 14.8
  IN3 w0.254: v4(102.83,66.46) 102.27,66.46 101.48,67.25 97.64,67.25 97.44,67.04 94.39,67.04 v7(94.09,66.74)
  IN4 w0.254: v4(102.83,66.46) 102.8,66.48 v5(102.8,67.02)
  GND5 w0.254: v6(103.13,67.27) 103.05,67.27 v5(102.8,67.02)
  BOTTOM w0.254: RH219.1 92.89,70.07 94.09,68.87 v9(94.09,67.68) v7(94.09,66.74) ; UH1.AP27 v6(103.13,67.27)
+VCCP: length 321.3
  TOP w0.254: v7(104.46,53.09) 104.02,53.53 RH43.2 ; v7(44.4,86.18) v9(44.4,83.26) 44.4,83.2 44.63,82.96 45.49,82.96 49.35,79.1 49.35,78.66 49.78,78.22 RC45.2 RC47.2 49.78,77.07 v2(49.46,76.75) ; RH124.1 94.09,64.1 v7(93.56,63.56) ; R297.1 105.88,41.69
  TOP w0.305: RC95.2 61.34,79.71 v2(61.37,79.75) 61.53,79.75 61.81,80.02 61.81,80.56 61.67,80.69 RC93.1 ; PC1316.1 v2(74.12,69.94) ; PC1304.1 v2(73.21,67.27) ; PC1322.1 v2(75.32,68.35) ; v2(75.24,65.35) PC1307.1 ; v2(71.53,65.6) 71.53,65.14 PC1272.1 ; PC1318.1 v2(75.89,64.63) ; v2(73.4,64.03) 73.79,64.43 PC1305.1 ; PC1303.1 v2(71.9,69.49) ; PC1317.1 v2(75.75,70.71) ; v2(76.13,69.3) 76.05,69.38 PC1297.1 ; PC1306.1 72.89,65.48 v2(72.4,64.99) ; RC32.1 v2(59.87,80.33)
  TOP w0.381: PC1300.1 101.7,62.03 CH42.1 ; v2(104.91,62.88) 105.21,62.57 CH72.1 ; RC126.1 75.05,62.1 75.57,62.62 75.57,64.07 74.68,64.96 74.68,65.35 PC1307.1 ; CC222.1 78.1,68.65 78.06,68.62 RC137.2 77.63,68.66 v2(77.63,69.28) ; CH42.1 CH40.1 ; CH42.1 100.88,62.01 PC1320.1 ; CH50.1 111.22,65.08 v2(111.72,64.58) ; v2(103.49,62.83) 103.82,63.16 CH80.1 ; v2(75,67.46) CC221.1 ; PC1308.1 v2(73.4,64.03) ; PC1313.1 58.48,65.06 v2(58.22,65.32) ; v7(69.6,66.69) 70.02,66.27 PC1301.1 ; v2(105.98,65.24) CH28.1 ; CH60.1 v2(107.12,67.4) ; PC1269.1 57.02,64.92 57.46,65.37 57.46,65.93 PC1311.1 ; PC1309.1 v2(69.35,66.05)
  TOP w0.508: RH201.2 98.15,55.66 v2(98.18,55.64) ; PC1266.1 v2(104.93,65.49) ; RH113.2 107.85,72.45 CH74.1 CH77.1 v2(108.39,70.19) ; CH38.1 CH39.1 101.55,65.93 PC1321.1 v2(101.55,64.5) ; PC1300.1 102.45,62.24 v2(102.93,62.73) CH81.1 ; PC1314.1 86.8,66.59 v7(87.28,66.1) ; PC1267.1 v7(84.82,66.57) ; RH213.2 105.18,72.81 104.92,73.06 103.68,73.06 103.04,72.42 CH43.1 v2(103.04,71.23) ; CH25.1 CH26.1 CH28.1 ; CH41.1 v2(101.28,69.81) ; LH6.2 96.72,52.76 v7(97.1,52.37) ; PC1271.1 v2(100.87,54.89) ; v7(58.27,66.54) 57.81,66.07 PC1311.1 ; v2(108.01,67.4) CH61.1 CH62.1 ; v2(104.76,61.68) 104.2,62.24 CH79.1 ; RH292.1 v2(108.11,59.07) ; PC1265.1 v2(103.7,68.06) ; PC1273.1 59.72,67.35 v7(60.18,66.89) 59.76,66.89 PC1268.1 ; v7(60.89,64.4) 60.48,64.81 PC1310.1 PC1312.1 ; RH216.1 v7(91.35,71.16)
  GND1 w0.254: v2(49.46,76.75) 49.51,76.8 v3(49.92,76.8)
  GND1 w0.305: v2(74.12,69.94) v3(74.12,70.37) ; v2(75.89,64.63) 75.89,64.54 v3(75.62,64.27) ; v2(72.4,64.99) 72.55,65.14 v3(72.55,65.39) ; v2(71.9,69.49) v3(72.6,69.49) ; v2(73.21,67.27) v3(73.21,67.7) ; v3(75.7,69.41) 75.7,69.41 75.78,69.33 75.78,69.33 75.8,69.3 v2(76.13,69.3) ; v3(71.61,65.16) 71.53,65.24 v2(71.53,65.6) ; v2(75.24,65.35) v3(75.24,65.82) ; v2(75.32,68.35) v3(75.75,68.35) ; v2(75.75,70.71) v3(75.27,70.71) ; v2(59.87,80.33) v3(59.87,80.84) ; v2(61.37,79.75) v3(60.94,79.75)
  GND1 w0.381: v2(107.12,67.4) v3(107.12,67.86) ; v2(69.35,66.05) 69.35,65.72 v3(69.2,65.57) ; v2(77.63,69.28) v3(77.2,69.28) ; v2(105.98,65.24) v3(105.98,65.67) ; v2(104.91,62.88) v3(105.32,62.88) ; v3(73.46,64.48) 73.4,64.41 v2(73.4,64.03) ; v2(75,67.46) 74.83,67.46 v3(74.58,67.7) ; v2(111.72,64.58) 111.72,64.1 v3(111.61,64) ; v2(103.49,62.83) v3(103.79,63.13) ; v2(58.22,65.32) 58.42,65.32 v3(58.62,65.11)
  GND1 w0.508: v2(108.11,59.07) v3(107.7,59.07) ; v2(108.39,70.19) 108.19,70.19 107.83,70.55 v3(107.83,70.6) ; v2(108.01,67.4) 108.01,67.5 v3(108.34,67.83) ; v2(103.7,68.06) v3(103.7,67.65) ; v2(98.18,55.64) v3(98.18,54.9) ; v2(101.28,69.81) v3(100.87,69.81) ; v2(101.55,64.5) v3(102.24,64.5) ; v3(104.07,61.63) 104.71,61.63 v2(104.76,61.68) ; v3(102.6,71.16) 102.67,71.23 v2(103.04,71.23) ; v2(102.93,62.73) v3(102.93,63.13) ; v2(104.93,65.49) v3(104.93,65.09) ; v2(100.87,54.89) v3(100.87,55.54)
  IN1 w0.254: v4(50.3,77.15) 49.94,76.8 v3(49.92,76.8) ; v3(59.87,80.84) 60.36,80.35 v4(60.36,80) ; v7(26.09,86.55) 26.09,85.9 27.24,84.76 28.2,84.76 28.49,85.05 30.35,85.05 30.6,84.8 32.6,84.8 34.16,83.24 40.06,83.24 41.87,85.04 43.25,85.04 v7(44.4,86.18)
  IN1 w0.305: v4(73.62,69.96) 74.02,70.37 v3(74.12,70.37) ; v3(72.6,69.49) 72.61,69.49 72.93,69.18 v4(72.93,69.13) ; v4(76.11,64.99) 76.11,65.01 76.08,65.04 76.03,65.04 76,65.06 76,64.66 v3(75.62,64.27) ; v4(75.72,67.73) 75.75,67.75 v3(75.75,68.35) ; v4(72.04,65.57) 72.22,65.39 v3(72.55,65.39) ; v3(75.7,69.41) 75.7,70.4 v4(75.67,70.42) 75.38,70.71 v3(75.27,70.71) ; v3(60.94,79.75) v4(60.94,79.24) ; v4(72.88,68.26) 73.21,67.93 v3(73.21,67.7) ; v3(105.32,62.88) 105.19,62.75 105.19,62.22 v4(105.14,62.17) ; v3(71.61,65.16) 71.23,65.16 v4(71.13,65.27) ; v3(75.24,65.82) 75.24,65.11 v4(75.42,64.94)
  IN1 w0.381: v3(102.93,63.13) v3(103.79,63.13) 103.96,63.13 v4(104.28,63.44) ; v3(74.58,67.7) 75.09,67.7 75.11,67.68 v4(75.11,67.65) ; v4(106.18,66.28) 105.98,66.07 v3(105.98,65.67) ; v4(73.26,63.97) 73.26,64.27 v3(73.46,64.48) ; v6(69.73,65.82) 69.48,65.57 v3(69.2,65.57) ; v4(107.12,68.34) v3(107.12,67.86) ; v4(59.11,65.45) 58.77,65.11 v3(58.62,65.11) ; v3(77.2,69.28) 76.77,69.71 v4(76.46,69.71) ; v3(111.61,64) v4(111.61,63.44)
  IN1 w0.508: v3(100.87,55.54) 100.46,55.54 v4(100.35,55.65) ; v3(102.6,71.16) v4(102.6,71.72) ; v3(104.93,65.09) 104.5,65.09 v4(104.43,65.16) ; v3(104.07,61.63) 104.02,61.68 v4(104.02,62.34) ; v3(107.83,70.6) 107.83,70.62 108.06,70.85 v4(108.33,70.85) ; v4(102.72,64.78) 102.72,64.73 102.5,64.5 v3(102.24,64.5) ; v3(98.18,54.9) v4(97.62,54.9) ; v3(100.87,69.81) 100.87,70.14 v4(101.03,70.3) ; v3(107.7,59.07) v4(107.7,59.55) ; v3(103.7,67.65) v4(103.21,67.65) ; v3(108.34,67.83) v4(108.34,68.31)
  IN4 w0.254: v5(75.93,68.87) 75.93,69.18 v4(76.46,69.71) ; v5(59.65,64.78) v4(60,65.14) ; v4(72.27,70.02) 72.27,69.96 v5(72.63,69.61) ; v4(50.3,77.15) 50.05,77.15 48.62,75.73 v5(47.63,75.73)
  IN4 w0.279: v5(109.73,66.02) 109.73,66.33 v4(109.58,66.48) ; v5(101.61,70.21) 101.61,70.58 v4(101.5,70.68) ; v5(107.75,67.54) 107.94,67.36 107.94,67.04 v4(107.94,67.04) ; v5(105.77,67.68) v4(105.77,67.19) ; v4(102.32,68.18) 102.08,67.94 v5(102.08,67.76) ; v4(110.42,65.52) 110.42,65.54 110.39,65.52 v5(110.39,65.01) ; v5(101.03,69.8) v4(101.03,70.3) ; v5(103.79,70.2) 103.79,70.5 v4(103.6,70.69) ; v4(110.95,63.03) 110.95,63.07 110.98,63.09 110.98,63.51 v5(110.98,63.51) ; v4(105.14,62.17) 105.11,62.2 v5(105.11,62.67) ; v5(106.66,64.36) 106.43,64.59 v4(106.43,64.83) ; v5(106.91,71.85) v4(106.91,72.34) ; v5(107.09,71.04) 107.09,70.61 v4(107.02,70.53) ; v5(109.73,65.04) 109.73,65.44 v4(109.66,65.52) ; v5(108.41,64.33) 108.41,64.34 v4(108.06,64.69) ; v5(107.75,68.53) v4(107.75,68.03) ; v5(107.75,71.05) 107.94,70.85 v4(108.33,70.85) ; v5(104.45,69.36) v4(104.45,69.94) ; v5(109.07,66.85) v4(109.07,67.35) ; v5(105.77,65.18) v4(105.77,64.69) ; v5(104.13,68.62) 103.79,68.62 v4(103.41,69) ; v5(105.11,69.37) v4(105.11,68.89) ; v5(109.07,69.35) v4(109.07,69.85) ; v4(102.19,59.78) 102.24,59.83 102.24,60.36 101.99,60.62 v5(101.99,60.74) ; v5(101.81,68.51) 102.04,68.75 v4(102.39,68.75) ; v5(103.12,71.93) 103.04,71.86 102.74,71.86 v4(102.6,71.72) ; v4(103.82,63.97) 103.82,63.94 103.79,63.97 103.79,64.04 v5(103.43,64.4) ; v5(108.41,67.69) 108.41,67.27 v4(108.53,67.16) ; v5(109.56,64.3) 109.88,64.62 v4(109.98,64.62) ; v5(104.82,66.97) 104.6,66.76 v4(104.6,66.23) ; v4(101.48,66.43) 101.81,66.11 v5(101.81,66.01) ; v4(109.08,65.5) 109.07,65.51 v5(109.07,66.03) ; v4(109.02,64.94) 109.01,64.92 v5(109.01,64.33) ; v5(102.22,65.59) v4(102.22,65.1) ; v5(101.03,62.12) 101.03,62.73 101.23,62.93 v4(101.43,62.93) ; v5(111.48,66.42) 111.48,65.94 v4(111.44,65.9) ; v5(107.09,64.34) v4(107.09,64.83) ; v5(108.41,69.37) 108.4,69.37 108.08,69.7 v4(108.02,69.7) ; v5(102.65,67.65) v4(103.21,67.65) ; v5(107.22,66) 107.22,65.66 v4(107.09,65.53) ; v5(108.41,65.05) v4(108.41,65.54) ; v5(106.71,65.94) 106.7,65.94 106.48,65.72 v4(106.48,65.49) ; v5(111.06,64.99) v4(111.06,64.49) ; v4(103.29,69.59) 103.55,69.59 103.77,69.36 v5(103.79,69.36) ; v5(105.11,65.16) 105.11,65.24 v4(105.45,65.57) ; v5(108.41,66.03) v4(108.41,66.52) ; v5(101.51,61.89) 101.51,62.34 v4(101.53,62.37) ; v5(103.79,63.48) 104.24,63.48 v4(104.28,63.44) ; v4(110.39,66.5) v5(110.39,66.02) ; v5(107.75,66) v4(107.75,66.49) ; v5(110.39,63.5) v4(110.39,63.99) ; v4(108.26,70.21) v5(107.75,70.21)
  IN4 w0.305: v5(75.67,69.84) v4(75.67,70.42) 75.22,69.96 v5(75.22,69.79) ; v4(73.72,67.4) 73.72,67.81 v5(73.64,67.88) ; v4(75.72,67.73) 75.7,67.7 v5(75.7,67.2) ; v5(75.11,66) 75.57,66 v4(75.67,66.1) ; v4(74.89,68.59) 75.22,68.26 v5(75.27,68.26) 75.29,68.29 v5(75.98,68.29) ; v5(75.85,64.55) 76.11,64.81 v4(76.11,64.99) ; v5(73.62,65.39) v4(74.1,65.39) ; v5(105.49,68.5) 105.49,68.5 105.15,68.16 v4(105.11,68.16) ; v5(74.63,67.86) 74.86,67.63 75.09,67.63 v4(75.11,67.65) ; v4(75.72,65.52) 76.33,65.52 76.44,65.42 v5(76.44,65.44) ; v4(75.42,64.94) 75.14,65.21 v5(75.14,65.42) ; v4(106.35,68.04) 106.58,67.81 v5(106.79,67.81) ; v4(72.73,67.04) 72.73,66.61 v5(72.68,66.56) ; v5(59.01,66.99) v4(59.01,67.48) ; v5(72.04,65.09) v4(72.04,65.57) ; v5(107.45,67) 107.45,67.02 107.15,67.32 v4(106.92,67.32) ; v5(58.12,67.07) 58.12,67.3 58.35,67.53 v4(58.35,67.55) ; v4(104.53,68.16) 104.5,68.16 104.22,67.88 v5(104.22,67.7) ; v5(69.37,65.49) 69.4,65.49 v6(69.73,65.82) ; v5(57.08,67.12) v4(57.08,67.6) ; v5(71.81,67.37) v4(71.81,67.91) ; v5(71.13,65.75) v4(71.13,65.27) ; v5(73.29,68.77) v4(72.93,69.13) ; v5(71.89,66.93) 71.45,66.93 71.38,66.99 v4(71.38,67.04) ; v5(58.63,65.45) v4(59.11,65.45) ; v5(74.66,67.04) v4(75.17,67.04) ; v5(57.67,67.02) v4(57.67,67.5) ; v5(105.77,66) 105.68,66.09 v4(105.68,66.61) ; v4(105.11,66.48) v5(105.11,66) ; v5(74.38,68.67) v4(74.38,69.18) ; v5(107.09,68.52) v4(107.09,69) ; v5(71.89,66.1) v4(72.37,66.1) ; v4(73.62,69.96) 73.69,69.96 v5(74.02,69.63) ; v5(71.89,68.82) v4(71.53,69.18) ; v5(73.36,66.23) v4(73.9,66.23) ; v5(73.97,70.52) 73.11,70.52 73.08,70.55 v4(73.13,70.55) ; v5(73.36,68.26) v4(72.88,68.26) ; v5(62.69,63.97) v4(62.21,63.97) ; v5(60.94,65.57) v4(60.94,65.09) ; v5(59.98,66.26) v4(59.98,65.72)
  IN4 w0.508: v4(91.19,66.56) v5(91.62,66.13)
  GND5 w0.254: v6(59.98,65.09) 59.95,65.09 v5(59.65,64.78) ; v5(72.63,69.61) 72.3,69.94 v6(72.3,69.99) ; v6(47.63,76.42) v5(47.63,75.73) ; v5(75.93,68.87) v6(75.93,69.3)
  GND5 w0.279: v5(109.56,64.3) 109.74,64.12 109.74,63.93 v6(109.73,63.93) ; v5(106.71,65.94) 106.71,65.93 106.43,65.64 v6(106.43,65.59) ; v6(103.79,64.75) v5(103.43,64.4) ; v6(110.39,63.92) v5(110.39,63.5) ; v6(104.45,69.79) v5(104.45,69.36) ; v5(109.01,64.33) 109.01,64.69 v6(109.07,64.76) ; v6(109.73,66.43) v5(109.73,66.02) ; v5(101.51,61.89) 101.51,61.91 101.81,62.22 v6(101.81,62.23) ; v6(107.75,68.96) v5(107.75,68.53) ; v6(107.09,65.59) 107.22,65.72 v5(107.22,66) ; v6(110.39,65.59) v5(110.39,65.01) ; v6(103.79,63.08) v5(103.79,63.48) ; v6(109.73,65.58) v5(109.73,65.04) ; v6(101.03,70.26) v5(101.03,69.8) ; v6(109.07,66.44) v5(109.07,66.03) ; v6(108.4,63.93) 108.4,64.33 v5(108.41,64.33) ; v6(105.11,68.94) v5(105.11,69.37) ; v5(103.12,71.93) 103.04,71.86 102.78,71.86 102.78,71.85 v6(102.64,71.85) ; v6(101.03,62.52) v5(101.03,62.12) ; v6(105.11,64.75) v5(105.11,65.16) ; v6(111.05,66.42) v5(111.48,66.42) ; v6(105.11,67.27) 105.11,67.27 v5(104.82,66.97) ; v6(104.45,68.94) 104.45,68.94 v5(104.13,68.62) ; v5(102.65,67.65) 102.47,67.48 102.47,67.28 v6(102.47,67.28) ; v6(102.47,68.1) 102.43,68.1 102.08,67.76 v5(102.08,67.76) ; v5(111.06,64.99) 111.06,65.03 111.05,65.02 v6(111.05,65.58) ; v6(107.09,64.75) v5(107.09,64.34) ; v6(108.41,68.94) v5(108.41,69.37) ; v6(109.07,68.94) v5(109.07,69.35) ; v5(110.98,63.51) 111.05,63.44 v6(111.05,63.09) ; v6(106.43,64.75) 106.43,64.59 v5(106.66,64.36) ; v6(110.39,66.43) v5(110.39,66.02) ; v6(101.81,66.42) v5(101.81,66.01) ; v6(105.11,63.07) v5(105.11,62.67) ; v6(107.75,66.44) v5(107.75,66) ; v6(108.41,65.58) v5(108.41,65.05) ; v6(105.77,65.59) v5(105.77,65.18) ; v6(107.75,71.45) v5(107.75,71.05) ; v6(101.81,65.59) v5(102.22,65.59) ; v6(107.09,71.45) v5(107.09,71.04) ; v6(103.79,70.62) v5(103.79,70.2) ; v6(102.09,61.46) 102.09,60.84 v5(101.99,60.74) ; v6(106.91,72.27) v5(106.91,71.85) ; v6(107.75,70.63) v5(107.75,70.21) ; v6(101.81,68.1) v5(101.81,68.51) ; v6(108.41,68.1) v5(108.41,67.69) ; v6(105.77,67.27) v5(105.77,67.68) ; v6(107.75,68.11) v5(107.75,67.54) ; v6(109.07,67.26) v5(109.07,66.85) ; v6(108.41,66.43) v5(108.41,66.03) ; v5(101.61,70.21) 101.61,70.42 v6(101.81,70.61) ; v6(103.79,69.78) v5(103.79,69.36)
  GND5 w0.305: v5(74.66,67.04) 74.53,67.04 v6(74.28,67.3) ; v6(107.09,67.27) 107.23,67.27 107.45,67.06 v5(107.45,67) ; v5(74.63,67.86) 74.67,67.81 v6(75.14,67.81) ; v5(76.44,65.44) 76.44,65.42 76.26,65.6 v6(76.26,65.87) ; v6(58.38,67.42) 58.38,67.32 v5(58.12,67.07) ; v5(75.22,69.79) 75.17,69.79 v6(74.89,70.07) ; v6(62.69,64.43) v5(62.69,63.97) ; v6(73.64,70.02) v5(74.02,69.63) ; v6(107.09,68.11) v5(106.79,67.81) ; v5(75.85,64.55) 75.85,64.58 v6(76.18,64.91) ; v6(59.01,66.56) v5(59.01,66.99) ; v6(105.11,68.11) 105.11,68.13 v5(105.49,68.5) ; v6(73.64,67.35) v5(73.64,67.88) ; v6(72.96,69.13) 72.96,69.1 v5(73.29,68.77) ; v5(74.38,68.67) 74.38,69.02 v6(74.3,69.1) ; v6(60.94,65.14) v5(60.94,65.57) ; v6(72.93,68.26) v5(73.36,68.26) ; v6(107.09,68.95) v5(107.09,68.52) ; v6(71.56,66.43) v5(71.89,66.1) ; v5(105.77,66) v6(105.77,66.43) ; v5(104.22,67.7) 104.22,67.87 104.45,68.1 v6(104.45,68.11) ; v5(75.14,65.42) 75.14,65.04 v6(75.09,64.99) ; v5(73.62,65.39) v6(73.29,65.06) ; v6(58.2,65.45) v5(58.63,65.45) ; v6(57.08,66.69) v5(57.08,67.12) ; v6(71.56,69.15) v5(71.89,68.82) ; v5(69.37,65.49) 69.7,65.82 v6(69.73,65.82) ; v6(75.7,66.76) v5(75.7,67.2) ; v6(71.56,65.75) v5(71.13,65.75) ; v6(72.24,67.37) v5(71.81,67.37) ; v6(75.55,66) v5(75.11,66) ; v6(73.36,65.8) v5(73.36,66.23) ; v6(74.84,68.26) v5(75.27,68.26) ; v6(75.65,67.96) v5(75.98,68.29) ; v6(71.61,65.09) v5(72.04,65.09) ; v6(59.98,65.82) v5(59.98,66.26) ; v6(72.24,66.56) v5(72.68,66.56) ; v5(105.11,66) v6(105.11,66.43) ; v6(57.67,66.59) v5(57.67,67.02) ; v6(71.46,66.93) v5(71.89,66.93) ; v6(75.67,70.27) v5(75.67,69.84) ; v6(73.62,70.88) v5(73.97,70.52)
  GND5 w0.508: v6(91.94,65.81) v5(91.62,66.13)
  BOTTOM w0.254: RC48.2 RC46.2 v6(47.63,76.42) ; UCPU1.AN45 60.57,64.08 v7(60.89,64.4) ; v6(72.3,69.99) 72.62,69.67 UCPU1.AB20 ; UCPU1.AM47 59.66,64.77 v6(59.98,65.09) ; UCPU1.AC13 76.29,68.94 v6(75.93,69.3) ; PR719.1 PR717.1 PR725.1 26.09,86.04 v7(26.09,86.55) ; UH1.AT13 v6(102.09,61.46) ; v7(44.4,86.18) 44.4,85.4 44.97,84.83 RC43.2
  BOTTOM w0.279: UH1.V23 v6(109.73,65.58) ; UH1.AU15 v6(101.81,62.23) ; UH1.U25 v6(110.39,66.43) ; UH1.AM33 v6(103.79,69.78) ; UH1.AG27 v6(105.77,67.27) ; UH1.AC27 v6(107.75,66.44) ; UH1.AK33 v6(104.45,69.79) ; UH1.AC29 v6(107.75,68.11) ; UH1.AG21 UH1.AG23 v6(105.77,65.59) ; UH1.AC23 UH1.AB23 v6(108.41,65.58) ; UH1.AK21 UH1.AJ21 v6(105.11,64.75) ; UH1.V21 v6(109.73,63.93) UH1.V19 ; UH1.Y29 v6(109.07,67.26) v5(109.07,66.85) ; UH1.AJ17 v6(105.11,63.07) ; UH1.AB29 v6(108.41,68.1) ; v6(109.07,66.44) UH1.Y25 UH1.Y23 ; v6(110.39,65.59) UH1.U23 UH1.U21 ; UH1.AC31 v6(107.75,68.96) ; UH1.AE23 v6(107.09,65.59) ; UH1.AM23 v6(103.79,64.75) UH1.AM21 ; UH1.AK31 v6(104.45,68.94) ; UH1.Y21 v6(109.07,64.76) ; UH1.R23 v6(111.05,65.58) ; UH1.AM35 v6(103.79,70.62) ; UH1.AW16 v6(101.03,62.52) ; UH1.AW34 v6(101.03,70.26) ; UH1.AR23 UH1.AU23 v6(101.81,65.59) ; UH1.AE21 v6(107.09,64.75) ; UH1.AR25 UH1.AU25 v6(101.81,66.42) ; UH1.AC21 UH1.AB21 108.41,63.93 v6(108.4,63.93) ; UH1.U19 v6(110.39,63.92) ; UH1.AE39 v6(106.91,72.27) ; v6(105.11,67.27) UH1.AJ27 ; UH1.AE37 v6(107.09,71.45) ; UH1.AR15 102.47,61.81 102.12,61.46 v6(102.09,61.46) ; UH1.AF21 v6(106.43,64.75) ; UH1.AR27 v6(102.47,67.28) ; UH1.N18 111.08,63.07 v6(111.05,63.09) UH1.R19 ; UH1.V25 v6(109.73,66.43) ; UH1.AJ25 UH1.AJ23 ; UH1.AB27 v6(108.41,66.43) ; UH1.AC35 v6(107.75,70.63) ; UH1.AU35 v6(101.81,70.61) ; UH1.AB31 v6(108.41,68.94) ; UH1.R25 v6(111.05,66.42) ; UH1.Y31 v6(109.07,68.94) ; v6(101.81,68.1) UH1.AU29 UH1.AU27 ; UH1.AC37 v6(107.75,71.45) ; UH1.AF23 v6(106.43,65.59) ; UH1.AP39 v6(102.64,71.85) ; UH1.AJ31 v6(105.11,68.94) ; UH1.AM17 v6(103.79,63.08) ; UH1.AR29 v6(102.47,68.1)
  BOTTOM w0.305: v7(60.18,66.89) 60.15,66.89 59.84,67.2 UCPU1.AF46 ; v6(72.24,66.56) 72.61,66.93 UCPU1.AG20 ; UCPU1.AL45 60.35,65.45 v6(59.98,65.82) 59.66,66.14 UCPU1.AJ47 ; UCPU1.AJ17 73.7,66.14 v6(73.36,65.8) 73.02,65.45 UCPU1.AL20 ; v6(76.26,65.87) 75.93,66.2 UCPU1.AJ14 ; UH1.AJ29 v6(105.11,68.11) ; v6(73.62,70.88) 73.99,70.5 UCPU1.W17 ; v6(74.89,70.07) 74.68,70.28 UCPU1.W16 ; v6(72.93,68.26) 73.3,67.89 UCPU1.AF18 ; UCPU1.AJ25 70.23,66.14 69.68,66.69 69.65,66.69 69.6,66.64 v7(69.6,66.69) ; UH1.AE27 v6(107.09,67.27) ; UCPU1.AG50 58.03,67.08 v6(58.38,67.42) ; v6(72.24,67.37) 72.62,67.75 UCPU1.AF20 ; UCPU1.AG15 75.28,67.18 v6(75.7,66.76) ; v6(59.01,66.56) 58.68,66.89 UCPU1.AG48 ; v6(75.65,67.96) 75.96,68.27 UCPU1.AE14 ; v6(73.29,65.06) 73.5,65.06 UCPU1.AM17 ; UCPU1.AE15 75.25,68.26 v6(74.84,68.26) ; UCPU1.AD16 74.68,68.73 v6(74.3,69.1) ; UCPU1.AK50 57.94,66.2 v7(58.27,66.54) ; UCPU1.AN42 62.35,64.08 v6(62.69,64.43) ; v6(72.96,69.13) 73.3,68.78 UCPU1.AD18 ; UCPU1.AL15 UCPU1.AL14 75.98,65.11 v6(76.18,64.91) ; UCPU1.AG17 73.99,66.93 73.64,67.27 v6(73.64,67.35) ; UCPU1.AJ15 75.28,66.27 v6(75.55,66) ; v6(71.61,65.09) 71.93,64.77 UCPU1.AM21 72.7,64.08 UCPU1.AN20 ; UCPU1.AM43 61.31,64.77 v6(60.94,65.14) ; v6(74.28,67.3) 74.65,66.93 UCPU1.AG16 ; UH1.AK29 v6(104.45,68.11) ; UCPU1.AB17 73.99,69.67 v6(73.64,70.02) ; UCPU1.AJ43 61.38,66.14 v7(61.78,66.54) ; UCPU1.AJ21 71.85,66.14 v6(71.56,66.43) ; UCPU1.AK51 57.28,66.21 v6(57.67,66.59) ; UCPU1.AD21 71.93,68.78 v6(71.56,69.15) ; UCPU1.AG51 57.37,66.98 v6(57.08,66.69) ; UCPU1.AL22 71.26,65.45 v6(71.56,65.75) ; UCPU1.AA15 75.31,69.9 v6(75.67,70.27) 75.96,69.99 UCPU1.AA14 ; UCPU1.AG21 v6(71.46,66.93) ; UCPU1.AF16 v6(75.14,67.81) ; UCPU1.AM47 58.88,64.08 UCPU1.AN48 ; v6(69.73,65.82) 69.36,65.45 UCPU1.AL26 ; UCPU1.AL16 74.61,65.38 74.61,64.84 UCPU1.AM16 74.87,64.77 v6(75.09,64.99) ; UH1.AE31 v6(107.09,68.95) ; UH1.AE29 v6(107.09,68.11) ; UCPU1.AL48 v6(58.2,65.45) ; UH1.AG25 v6(105.77,66.43) ; v6(105.11,66.43) UH1.AJ25
  BOTTOM w0.381: RC2.1 85.15,74.92 85.15,73.34 v7(84.84,73.04)
  BOTTOM w0.508: v7(84.31,68.54) 84.61,68.85 RH247.1 ; RH280.1 87.85,43.95 86.68,45.12 86.68,47.12 87.4,47.84 88.12,47.84 88.52,47.44 CH37.1 ; RC36.1 86.27,65.59 v7(86.47,65.39)
  vias: v7(90.35,69.2) v7(90.35,66.81) v7(90.35,66.18) v7(103.13,46.19) v7(103.77,46.19) v7(103.77,45.55) v7(104.4,46.19) v7(104.4,45.55) v7(104.45,44.92) v7(105.04,46.19) v7(105.04,45.55) v7(105.09,44.92) v7(105.67,46.19) v7(105.67,45.55) v7(105.72,44.92) v7(106.31,46.82) v7(106.31,46.19) v7(106.31,45.55) v7(106.31,44.26) v7(106.31,43.62) v7(106.31,42.99) v7(106.36,44.89)
+VCCP_D: length 2.5
  TOP w0.122: Q4.1 106.28,38.7 v1(105.98,38.39)
  TOP w0.254: R297.2 107.18,39.32 Q4.1
+VCCRTCEXT: length 4.3
  TOP w0.254: CH71.1 110.56,61.49 v2(110.95,61.1)
  GND1 w0.254: v3(110.75,61.46) 110.8,61.46 110.95,61.3 v2(110.95,61.1)
  IN1 w0.254: v4(110.9,61.94) 110.9,61.61 v3(110.75,61.46)
  IN4 w0.254: v4(110.9,61.94) 110.9,61.84 v5(111.56,61.18)
  GND5 w0.254: v5(111.56,61.18) 111.56,61.2 111.31,61.46 v6(111.26,61.46)
  BOTTOM w0.254: v6(111.26,61.46) 111.26,61.61 111.05,61.81 UH1.R15 111.02,61.86 110.43,61.86 UH1.U15
+VCCSA: length 38
  GND1 w0.254: v3(71.93,72.33) v2(71.93,72.76) ; v3(73.74,74.06) v2(73.31,74.06) ; v5(74.71,71.31) v2(75.14,71.31) ; v5(72.62,73.22) v2(73.06,73.22) ; v3(73.97,71.34) 74.1,71.34 v2(74.35,71.59) ; v3(72.03,74.75) v2(72.46,74.75) ; v5(74.71,74.06) v2(75.17,74.06) ; v2(73.62,71.74) 73.31,71.44 v5(73.31,71.41) ; v3(71.15,74.06) v2(71.58,74.06) ; v5(71.93,71.39) v2(71.93,71.84) ; v3(73.79,74.82) v2(73.79,75.25) ; v2(72.73,70.93) 72.73,70.61 v5(72.62,70.5) ; v5(74.68,72.28) v2(74.68,72.71) ; v5(73.3,72.28) v2(73.3,72.71) ; v5(75.3,71.79) v6(75.3,72.22) ; v5(74,73.29) v2(74.43,73.29)
  IN1 w0.254: v4(71.64,74.06) v3(71.15,74.06) ; v4(71.93,72.86) v3(71.93,72.33) ; v4(74,72.81) v5(74,73.29) ; v4(75.19,74.06) v5(74.71,74.06) ; v4(74.68,72.76) v5(74.68,72.28) ; v4(74.71,71.79) v5(74.71,71.31) ; v5(73.31,71.41) 73.64,71.74 v4(73.64,71.77) ; v4(72.62,70.98) v5(72.62,70.5) ; v4(73.3,72.76) v5(73.3,72.28) ; v4(75.3,72.28) v5(75.3,71.79) ; v4(73.26,74.06) v3(73.74,74.06) ; v4(72.52,74.75) v3(72.03,74.75) ; v3(73.97,71.34) 74.35,70.95 v4(74.35,70.93) ; v4(73.79,75.3) v3(73.79,74.82) ; v4(72.62,73.7) v5(72.62,73.22) ; v4(71.93,70.9) v5(71.93,71.39)
  IN4 w0.254: v5(72.03,74.75) v4(72.52,74.75) ; v5(72.62,73.22) v4(72.62,73.7) ; v5(74,73.29) v4(74,72.81) ; v5(73.3,72.28) v4(73.3,72.76) ; v5(73.79,74.06) v4(73.26,74.06) ; v5(72.62,70.5) v4(72.62,70.98) ; v5(74.71,71.31) v4(74.71,71.79) ; v5(74.71,74.06) v4(75.19,74.06) ; v5(71.93,71.39) v4(71.93,70.9) ; v5(71.13,74.06) v4(71.64,74.06) ; v5(75.3,71.79) v4(75.3,72.28) ; v4(73.64,71.77) 73.31,71.44 v5(73.31,71.41) ; v5(73.79,74.79) v4(73.79,75.3) ; v5(71.93,72.28) v4(71.93,72.86) ; v5(74.68,72.28) v4(74.68,72.76) ; v5(73.95,71.34) v4(74.35,70.93)
  GND5 w0.254: v6(75.14,74.06) v5(74.71,74.06) ; v6(72.62,70.94) v5(72.62,70.5) ; v6(74.68,72.72) v5(74.68,72.28) ; v6(71.93,70.91) v5(71.93,71.39) ; v6(74.28,70.98) 74.28,71.01 v5(73.95,71.34) ; v6(73.59,71.77) 73.59,71.69 v5(73.31,71.41) ; v6(73.36,74.06) v5(73.79,74.06) ; v6(72.47,74.75) v5(72.03,74.75) ; v6(73.3,72.72) v5(73.3,72.28) ; v6(71.93,72.72) v5(71.93,72.28) ; v6(73.79,75.22) v5(73.79,74.79) ; v6(74.86,71.79) 74.86,71.46 v5(74.71,71.31) ; v6(75.3,72.22) v5(75.3,71.79) ; v6(74.33,73.62) v5(74,73.29) ; v6(71.58,74.06) v5(71.13,74.06) ; v6(72.62,73.67) v5(72.62,73.22)
  BOTTOM w0.254: v6(74.28,70.98) 73.99,71.27 UCPU1.V17 ; UCPU1.U15 v6(75.3,72.22) ; v6(74.33,73.62) 73.99,73.28 UCPU1.P17 ; UCPU1.V16 74.86,71.55 v6(74.86,71.79) ; UCPU1.R18 v6(73.3,72.72) ; v6(73.59,71.77) 73.3,71.48 UCPU1.V18 ; UCPU1.L21 v6(72.47,74.75) ; UCPU1.L17 v6(73.79,75.22) ; UCPU1.P20 v6(72.62,73.67) ; UCPU1.V21 v6(71.93,70.91) ; UCPU1.W20 v6(72.62,70.94) ; UCPU1.R16 v6(74.68,72.72) ; UCPU1.R21 v6(71.93,72.72) ; UCPU1.N22 v6(71.58,74.06) ; UCPU1.N20 v6(73.36,74.06) ; UCPU1.N16 v6(75.14,74.06)
  vias: v7(87.18,85.94) v7(87.81,85.94) v7(88.45,85.94) v7(89.08,85.94) v7(89.72,85.94) v7(90.35,85.94) v7(90.99,85.94) v7(91.62,85.94) v9(84.56,76.19)
+VCCSA_BT: length 1.1
  TOP w0.122: v7(107.14,84.44) 106.33,84.44 v1(106.15,84.62)
  vias: v7(107.02,83.81)
+VCCSA_BT_1: length 2.9
  TOP w0.122: v1(107.35,80.05) 107.35,80.64 PC602.1
  TOP w0.508: PC602.1 PR605.2
+VCCSA_EN: length 3.2
  TOP w0.122: v7(107.75,86.07) 107.31,86.07 v1(106.9,85.66)
  TOP w0.254: v7(107.75,86.07) 107.88,85.94 PR604.1
  BOTTOM w0.254: PU600.13 108.66,85.16 v7(107.75,86.07)
+VCCSA_PHASE: length 2.5
  TOP w0.122: v7(105.8,80.56) v1(105.8,79.72)
  TOP w0.508: PC602.2 105.93,81.37 PC603.1 v7(105.8,80.56)
+VCCSA_PWR_SRC: length 1.6
  TOP w0.508: PC613.1 113.04,81.33 113.41,80.96 v7(113.41,80.87) ; PC612.2 111.88,80.58 v7(111.87,80.57)
  vias: v9(117.81,82.16)
+VCCSATAPLL: length 8.9
  TOP w0.508: v7(99.24,54.83) CH73.1 97.52,54.83 97.35,54.99 LH6.1
  BOTTOM w0.305: UH1.AM2 103.99,55.81
  BOTTOM w0.508: v7(99.24,54.83) 99.69,54.38 v1(100.55,54.38) 101.14,54.97 102.8,54.97 103.44,55.6 103.78,55.6 103.99,55.81
