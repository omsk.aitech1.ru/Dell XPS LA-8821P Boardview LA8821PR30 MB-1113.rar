# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D13: length 44.7
  TOP w0.076: v10(58.69,37.1) 59.52,36.27 59.52,35.79 UD10.E7
  IN4 w0.071: v10(58.69,37.1) 59.11,37.52 59.11,40.11 60.69,41.68 60.69,42.31 63.21,44.83 64.29,44.83 66.04,46.59 72.05,46.59 73.54,48.08 74.83,48.08 78.97,52.22 80.41,52.22 81.29,53.11 81.29,55.49 82.53,56.73 82.53,61.53 v5(81.59,62.47)
  GND5 w0.104: v5(81.59,62.47) 81.59,62.55 81.34,62.8 v6(81.34,62.83)
  BOTTOM w0.122: v6(81.34,62.83) 81.34,62.85 81.38,62.89 UCPU1.AR3
DDR_B_D14: length 42.3
  TOP w0.076: UD10.E3 57.22,35.68 v10(57.22,35.7)
  IN4 w0.071: v10(57.22,35.7) 57.22,36.65 56.82,37.05 56.82,37.53 56.06,38.29 56.06,39.68 56.38,39.99 56.38,40.87 56.88,41.37 57.69,41.37 58.78,42.46 58.78,43.07 64.2,48.49 71.26,48.49 73.45,50.69 74.65,50.69 79.35,55.39 79.35,56.23 80.65,57.52 80.65,59.59 80.73,59.68 v5(80.73,60.18)
  GND5 w0.104: v6(81.08,60.46) 81,60.46 80.73,60.2 v5(80.73,60.18)
  BOTTOM w0.122: v6(81.08,60.46) 81.11,60.49 81.49,60.49 UCPU1.AY2
DDR_B_D15: length 43
  TOP w0.104: v10(56.47,38.9) 56.47,38.03 UD10.B3
  IN4 w0.071: v5(81.11,60.02) 80.96,59.86 80.96,59.6 80.88,59.52 80.88,57.42 79.64,56.18 79.64,55.35 79.33,55.03 79.33,54.93 74.5,50.1 74.3,50.1 74.2,50.2 74.2,50.33 74.1,50.43 73.87,50.43 73.77,50.33 73.77,49.86 73.64,49.73 73.45,49.73 73.36,49.82 73.36,50 73.29,50.08 73.18,50.08 71.36,48.25 65.37,48.25 65.01,47.89 64.83,47.89 64.47,48.25 64.29,48.25 64.12,48.08 64.12,47.96 64.51,47.57 64.51,47.4 64.39,47.27 64.21,47.27 63.82,47.66 63.7,47.66 63.53,47.49 63.53,47.37 63.72,47.18 63.72,47.06 63.54,46.88 63.42,46.88 63.23,47.07 63.11,47.07 59.01,42.97 59.01,42.36 57.79,41.14 56.98,41.14 56.61,40.77 56.61,40.38 56.7,40.3 56.8,40.3 56.88,40.22 56.88,39.84 56.8,39.76 56.48,39.76 56.3,39.58 56.3,39.07 v10(56.47,38.9)
  GND5 w0.104: v5(81.11,60.02) 81.31,59.82 v6(81.66,59.82)
  BOTTOM w0.122: v6(81.66,59.82) 81.38,60.11 UCPU1.BA3
DDR_B_D16: length 46.9
  IN4 w0.071: v5(77.54,58.43) 77.3,58.43 77.17,58.55 77.17,58.92 77.3,59.05 77.71,59.05 77.88,59.22 78.06,59.22 78.21,59.07 78.21,58.89 77.91,58.59 77.91,55.95 74.07,52.11 72.87,52.11 70.67,49.91 63.61,49.91 61.07,47.37 60.88,47.37 60.65,47.15 60.65,46.95 60.37,46.67 58.94,46.67 58.54,46.27 58.54,44.84 56.89,43.19 56.69,43.19 53.76,40.25 53.76,39.85 52.83,38.93 52.83,38.01 51.89,37.07 51.7,37.07 51.34,37.43 51.06,37.43 50.96,37.53 50.96,38.62 v10(51.06,38.72)
  GND5 w0.104: v5(77.54,58.43) 77.6,58.43 77.83,58.19 v6(77.92,58.19)
  BOTTOM w0.104: UD11.C2 49.78,36.88 50.19,37.29 50.7,37.29 50.94,37.53 50.94,38.61 v10(51.06,38.72)
  BOTTOM w0.122: v6(77.92,58.19) 78.03,58.19 78.33,57.89 UCPU1.BE9
DDR_B_D17: length 47.4
  IN4 w0.071: v10(44.58,35.67) 45.58,34.68 50.17,34.68 53.31,37.83 53.31,38.74 54.23,39.66 54.23,40.06 56.89,42.72 57.09,42.72 63.8,49.43 70.87,49.43 73.07,51.64 74.26,51.64 78.39,55.76 78.39,56.91 78.57,57.09 v5(78.57,57.8)
  GND5 w0.104: v6(78.62,58.23) 78.57,58.18 v5(78.57,57.8)
  BOTTOM w0.104: UD11.E8 44.98,35.28 v10(44.58,35.67)
  BOTTOM w0.122: v6(78.62,58.23) 78.54,58.23 UCPU1.BD9
DDR_B_D18: length 46
  IN4 w0.071: v10(45.37,37.28) 45.94,36.71 46.35,36.71 46.44,36.8 46.44,36.94 46.52,37.02 46.77,37.02 46.86,36.94 46.86,36.8 46.94,36.71 47.83,36.71 49,37.88 49,38.29 49.33,38.62 49.33,39.39 51.03,41.08 52.25,41.08 52.52,41.35 52.52,41.47 52.33,41.65 52.33,41.77 52.51,41.95 52.63,41.95 52.81,41.76 52.93,41.76 53.11,41.94 53.11,42.06 52.93,42.25 52.93,42.36 53.1,42.54 53.22,42.54 53.41,42.36 53.52,42.36 53.73,42.56 53.73,43.9 59.17,49.34 60.66,49.34 62.89,51.57 70,51.57 72.75,54.32 73.93,54.32 76.09,56.47 76.09,56.65 76.28,56.84 76.28,58.41 v5(76.21,58.48)
  GND5 w0.104: v5(76.21,58.48) 76.21,58.51 75.94,58.77 v6(75.94,58.86)
  BOTTOM w0.104: v10(45.37,37.28) 45.77,36.88 UD11.C7
  BOTTOM w0.122: UCPU1.BD13 76.26,58.54 v6(75.94,58.86)
DDR_B_D19: length 46.6
  IN4 w0.071: v10(51.37,38.19) 51.37,37.76 51.49,37.63 51.7,37.63 51.82,37.76 51.82,38.69 51.93,38.8 52.09,38.8 52.2,38.69 52.2,38.14 52.33,38.01 52.47,38.01 52.6,38.13 52.6,39.03 53.52,39.95 53.52,40.35 56.59,43.43 56.79,43.43 56.88,43.51 56.88,43.65 56.85,43.68 56.85,43.76 56.94,43.85 57.22,43.85 58.31,44.94 58.31,45.07 58.2,45.17 57.97,45.17 57.84,45.3 57.84,45.48 57.97,45.61 58.2,45.61 58.31,45.71 58.31,46.45 58.77,46.91 59.06,46.91 59.19,47.03 59.19,47.32 59.31,47.43 59.48,47.43 59.6,47.32 59.6,47.03 59.72,46.91 60.27,46.91 60.42,47.05 60.42,47.25 60.46,47.29 60.46,47.54 60.43,47.56 60.43,47.78 60.55,47.89 60.7,47.89 60.81,47.78 60.81,47.66 60.87,47.6 60.97,47.6 63.51,50.14 70.57,50.14 72.78,52.35 73.15,52.35 73.23,52.43 73.23,52.79 73.32,52.87 73.57,52.87 73.65,52.79 73.65,52.43 73.74,52.35 73.95,52.35 74.05,52.45 74.05,52.8 74.15,52.91 74.53,52.91 77.64,56.02 77.64,56.69 v5(77.47,56.86)
  GND5 w0.104: v6(76.91,57.11) 77,57.11 77.25,56.86 v5(77.47,56.86)
  BOTTOM w0.104: v10(51.37,38.19) 51.65,37.9 51.65,36.78 51.47,36.6 50.86,36.6 50.79,36.53 50.23,36.53 UD11.D2
  BOTTOM w0.122: UCPU1.BF12 v6(76.91,57.11)
DDR_B_D20: length 47
  IN4 w0.071: v5(78.75,56.73) 78.64,56.62 78.64,55.68 74.36,51.4 73.17,51.4 70.96,49.2 63.9,49.2 57.18,42.48 56.99,42.48 54.46,39.96 54.46,39.56 53.55,38.65 53.55,37.73 53.17,37.35 53.17,33.88 53.06,33.77 52.79,33.77 52.66,33.9 52.66,34.43 52.53,34.56 52.33,34.56 52.2,34.43 52.2,33.9 52.08,33.77 51.75,33.77 51.62,33.9 v10(51.62,35.12)
  GND5 w0.104: v5(78.75,56.73) 78.98,56.73 79.09,56.85 v6(79.19,56.85)
  BOTTOM w0.104: UD11.E3 48.98,35.47 49.21,35.7 51.04,35.7 v10(51.62,35.12)
  BOTTOM w0.122: v6(79.19,56.85) 78.89,57.15 UCPU1.BF8
DDR_B_D21: length 47.2
  IN4 w0.071: v5(78.24,58.48) 78.15,58.39 78.15,55.85 74.17,51.87 72.97,51.87 70.77,49.67 63.7,49.67 60.47,46.44 59.04,46.44 58.78,46.17 58.78,44.74 56.99,42.95 56.79,42.95 53.99,40.15 53.99,39.76 53.07,38.83 53.07,37.91 51.77,36.61 50.96,36.61 49.86,35.51 46.96,35.51 46.75,35.29 45.75,35.29 v10(45.37,35.67)
  GND5 w0.104: v6(77.91,58.79) 77.93,58.79 v5(78.24,58.48)
  BOTTOM w0.104: v10(45.37,35.67) 45.77,35.28 UD11.E7
  BOTTOM w0.122: v6(77.91,58.79) 77.66,58.54 UCPU1.BD10
DDR_B_D22: length 45.3
  IN4 w0.071: v5(75.6,58.53) 76.04,58.09 76.04,56.98 75.79,56.73 75.79,56.51 73.83,54.56 72.65,54.56 69.9,51.81 62.79,51.81 60.58,49.59 59.09,49.59 58.84,49.34 58.72,49.34 58.47,49.59 58.2,49.59 58.1,49.49 58.1,49.37 58.42,49.04 58.42,48.93 58.24,48.75 58.12,48.75 57.8,49.07 57.65,49.07 57.5,48.92 57.5,48.78 57.83,48.45 57.83,48.33 57.67,48.17 57.49,48.17 57.18,48.48 57.05,48.48 56.7,48.13 56.7,47.97 56.6,47.87 56.44,47.87 56.12,47.54 56.12,47.36 56.4,47.07 56.4,46.93 56.29,46.82 56.12,46.82 55.83,47.11 55.69,47.11 55.55,46.97 55.55,46.83 55.86,46.52 55.86,46.37 53.49,44 53.49,43.67 53.35,43.52 53.02,43.52 52.67,43.18 52.67,43.06 52.91,42.82 52.91,42.71 52.73,42.53 52.61,42.53 52.38,42.76 52.26,42.76 52.08,42.59 52.08,42.47 52.32,42.23 52.32,42.11 52.14,41.93 52.02,41.93 51.78,42.17 51.67,42.17 51.28,41.78 51.28,41.46 51.14,41.32 50.93,41.32 49.1,39.48 49.1,38.74 48.59,38.23 v10(48.59,38.07)
  GND5 w0.104: v6(75.8,58.17) 75.8,58.22 75.6,58.42 v5(75.6,58.53)
  BOTTOM w0.104: UD11.B3 v10(48.59,38.07)
  BOTTOM w0.122: UCPU1.BD14 75.6,58.37 v6(75.8,58.17)
DDR_B_D23: length 46.4
  IN4 w0.071: v10(45.37,36.46) 45.91,36.46 45.99,36.37 45.99,36.19 46.07,36.11 46.33,36.11 46.41,36.19 46.41,36.37 46.49,36.46 47.08,36.46 47.23,36.31 47.76,36.31 47.91,36.46 48.27,36.46 48.52,36.21 48.72,36.21 48.85,36.33 48.85,36.49 48.5,36.84 48.5,37.04 49.15,37.69 49.63,37.69 49.82,37.88 49.82,38.44 49.77,38.49 49.77,39.48 51.13,40.85 52.35,40.85 54.11,42.61 54.11,42.8 53.96,42.95 53.96,43.69 54.64,44.36 54.87,44.36 55.05,44.54 55.05,44.87 55.76,45.58 56.04,45.58 56.17,45.71 56.17,45.99 56.7,46.52 56.95,46.52 57.11,46.67 57.11,46.93 59.26,49.09 60.78,49.09 63.01,51.32 70.08,51.32 72.84,54.08 74.03,54.08 76.34,56.39 76.34,56.55 76.51,56.72 76.51,57.66 v5(76.67,57.82)
  GND5 w0.104: v6(76.67,58.23) v5(76.67,57.82)
  BOTTOM w0.104: v10(45.37,36.46) 45.37,36.49 44.98,36.88 UD11.C8
  BOTTOM w0.122: v6(76.67,58.23) 76.36,57.92 UCPU1.BE13
DDR_B_D24: length 45.3
  TOP w0.104: v10(47.55,38.62) 47.56,38.62 48.09,38.09 48.09,37.71 48.91,36.88 UD12.C7
  IN4 w0.071: v5(74.99,57.52) 74.93,57.46 74.93,56.66 73.54,55.27 71.8,55.27 69.83,53.3 69.83,52.74 69.6,52.51 61.48,52.51 61.37,52.41 61.37,52.16 61.27,52.06 61.04,52.06 60.94,52.16 60.94,52.41 60.84,52.51 60.61,52.51 60.51,52.41 60.51,52.16 60.41,52.06 60.18,52.06 59.98,52.26 59.77,52.26 59.65,52.13 59.65,51.75 59.8,51.6 60.03,51.6 60.11,51.52 60.11,51.25 60.2,51.17 60.45,51.17 60.53,51.25 60.53,51.52 60.62,51.6 61.09,51.6 61.2,51.5 61.2,51.21 60.29,50.3 57.87,50.3 54.83,47.26 54.83,46.69 47.55,39.41 v10(47.55,38.62)
  GND5 w0.104: v5(74.99,57.52) 74.99,57.14 v6(75.03,57.1)
  BOTTOM w0.122: UCPU1.BF16 74.94,57.19 v6(75.03,57.1)
DDR_B_D25: length 46.2
  TOP w0.076: v10(47.55,37.76) 47.68,37.62 47.68,37.6 48.66,36.62 48.66,35.85 48.83,35.67 49.03,35.67 49.42,35.28 49.78,35.28 UD12.E8
  IN4 w0.071: v10(47.55,37.76) 47.55,38.02 47.12,38.44 47.12,39.32 54.59,46.79 54.59,47.35 57.77,50.54 58.48,50.54 58.73,50.79 58.73,51.88 59.6,52.75 67.07,52.75 67.23,52.91 67.23,53.45 67.31,53.53 67.56,53.53 67.65,53.45 67.65,52.89 67.77,52.77 67.94,52.77 68.07,52.89 68.07,53.45 68.15,53.53 68.4,53.53 68.48,53.45 68.48,52.9 68.61,52.77 68.84,52.77 68.97,52.9 68.97,53.25 69.63,53.91 70.11,53.91 71.7,55.5 73.44,55.5 74.7,56.76 74.7,57.63 74.43,57.9 v5(74.38,57.9)
  GND5 w0.104: v5(74.38,57.9) 74.68,57.9 v6(74.8,58.02)
  BOTTOM w0.122: UCPU1.BE17 74.68,57.89 v6(74.8,58.02)
DDR_B_D26: length 43.6
  TOP w0.104: v10(43.52,38.54) 43.8,38.27 43.8,37.4 43.92,37.27 44.58,37.27 UD12.C2
  IN4 w0.071: v5(73.49,57.9) 73.08,58.31 72.85,58.31 72.73,58.18 72.73,57.06 72.61,56.94 71.09,56.94 69.48,55.33 64.63,55.33 64.24,54.94 58.92,54.94 55.33,51.35 55.33,51.02 55.04,50.74 55.04,49.82 52.79,47.57 52.79,46.99 45.2,39.41 44.38,39.41 v10(43.52,38.54)
  GND5 w0.104: v6(73.28,58.27) 73.49,58.06 v5(73.49,57.9)
  BOTTOM w0.122: v6(73.28,58.27) 73.52,58.03 UCPU1.BE18
DDR_B_D27: length 44.6
  TOP w0.076: UD12.E3 46.17,35.68 v10(46.17,35.7)
  IN4 w0.071: v5(71.64,57.56) 70.97,57.56 69.21,55.8 64.43,55.8 64.04,55.41 58.68,55.41 54.86,51.58 54.86,51.22 54.57,50.93 54.57,50.02 52.32,47.76 52.32,47.19 45.61,40.49 44.54,40.49 42.64,38.58 42.64,37.93 42.96,37.6 43.47,37.6 45.01,36.06 45.55,36.06 45.9,35.7 v10(46.17,35.7)
  GND5 w0.104: v6(72.08,57.57) 71.65,57.57 v5(71.64,57.56)
  BOTTOM w0.122: UCPU1.BE21 72.4,57.89 v6(72.08,57.57)
DDR_B_D28: length 45.3
  TOP w0.104: v10(48.49,38.74) 48.6,38.85 49.89,38.85 50.2,38.54 50.2,37.63 49.78,37.21 UD12.C8
  IN4 w0.071: v5(75.47,57.87) 75.8,57.54 75.8,57.05 75.52,56.76 75.52,56.57 73.74,54.79 72.55,54.79 69.8,52.04 62.7,52.04 60.48,49.83 58.07,49.83 55.3,47.06 55.3,46.75 55.51,46.54 55.51,46.35 55.42,46.26 55.19,46.26 55.07,46.14 55.07,45.91 54.98,45.82 54.86,45.82 54.81,45.86 54.69,45.86 54.52,45.68 54.52,45.56 54.56,45.52 54.56,45.4 54.38,45.22 54.26,45.22 54.22,45.27 54.1,45.27 53.92,45.09 53.92,44.97 53.97,44.93 53.97,44.81 53.79,44.63 53.67,44.63 53.63,44.68 53.51,44.68 53.33,44.5 53.33,44.38 53.38,44.33 53.38,44.22 53.2,44.04 53.08,44.04 53.03,44.08 52.92,44.08 52.74,43.9 52.74,43.79 52.78,43.74 52.78,43.62 52.6,43.44 52.49,43.44 52.44,43.49 52.32,43.49 52.15,43.31 52.15,43.19 52.19,43.15 52.19,43.03 52.01,42.85 51.89,42.85 51.85,42.9 51.73,42.9 51.55,42.72 51.55,42.6 51.6,42.56 51.6,42.44 51.42,42.26 51.3,42.26 51.26,42.3 51.14,42.3 50.96,42.13 50.96,42.01 51,41.96 51,41.84 50.83,41.67 50.71,41.67 50.66,41.71 50.54,41.71 50.37,41.53 50.37,41.41 50.41,41.37 50.41,41.25 50.23,41.07 50.11,41.07 50.07,41.12 49.95,41.12 49.77,40.94 49.77,40.82 49.82,40.78 49.82,40.66 49.64,40.48 49.52,40.48 49.48,40.53 49.36,40.53 49.18,40.35 49.18,40.23 49.23,40.18 49.23,40.07 49.05,39.89 48.93,39.89 48.88,39.93 48.77,39.93 48.59,39.75 48.59,39.64 48.86,39.36 48.86,39.26 48.76,39.15 48.6,39.15 48.52,39.23 48.42,39.23 48.32,39.13 48.32,38.9 48.48,38.74 v10(48.49,38.74)
  GND5 w0.104: v5(75.47,57.87) 75.52,57.87 75.8,57.59 v6(75.8,57.59)
  BOTTOM w0.122: UCPU1.BE14 v6(75.8,57.59)
DDR_B_D29: length 44.7
  TOP w0.076: v10(47.64,37.1) 47.86,37.1 48.47,36.49 48.47,35.79 UD12.E7
  IN4 w0.071: v10(47.64,37.1) 47.86,37.1 48.29,37.53 48.29,37.76 48.09,37.96 48.09,38.82 47.94,38.98 47.94,39.46 55.06,46.59 55.06,47.16 57.97,50.07 60.39,50.07 61.43,51.11 61.43,51.33 61.53,51.42 61.74,51.42 62.01,51.69 62.01,51.78 61.93,51.85 61.73,51.85 61.63,51.96 61.63,52.18 61.73,52.28 69.7,52.28 70.12,52.69 70.12,52.81 70.08,52.85 70.08,53.12 70.18,53.23 70.29,53.23 70.41,53.11 70.53,53.11 70.71,53.29 70.71,53.4 70.58,53.53 70.58,53.67 70.74,53.83 70.88,53.83 71.01,53.7 71.12,53.7 71.3,53.88 71.3,54 71.19,54.11 71.19,54.25 71.34,54.41 71.48,54.41 71.6,54.29 71.72,54.29 71.89,54.47 71.89,54.59 71.76,54.73 71.76,54.87 71.91,55.02 72.05,55.02 72.19,54.89 72.31,54.89 72.45,55.03 73.64,55.03 75.24,56.63 75.24,56.9 v5(75.49,57.16)
  GND5 w0.104: v6(75.49,56.72) v5(75.49,57.16)
  BOTTOM w0.122: UCPU1.BG14 v6(75.49,56.72)
DDR_B_D30: length 43.2
  TOP w0.104: v10(45.42,38.9) 45.42,38.03 UD12.B3
  IN4 w0.071: v10(45.42,38.9) 45.42,38.7 45.52,38.6 45.78,38.6 45.93,38.75 45.93,39.8 53.03,46.89 53.03,47.47 55.46,49.9 55.46,50.05 55.28,50.23 55.28,50.64 55.61,50.97 55.81,50.97 56.09,50.68 56.24,50.68 56.44,50.88 56.44,51.02 55.96,51.5 55.96,51.65 56.14,51.82 56.26,51.82 56.75,51.34 56.89,51.34 57.05,51.49 57.05,51.63 56.56,52.12 56.56,52.24 56.73,52.42 56.85,52.42 57.21,52.06 57.33,52.06 57.51,52.23 57.51,52.35 57.15,52.71 57.15,52.83 59.02,54.7 64.33,54.7 64.72,55.09 69.59,55.09 71.2,56.71 72.95,56.71 v5(72.96,56.71)
  GND5 w0.104: v6(73.36,56.78) 73.03,56.78 v5(72.96,56.71)
  BOTTOM w0.122: v6(73.36,56.78) 73.52,56.94 UCPU1.BG18
DDR_B_D31: length 43.2
  TOP w0.104: v10(43.06,38.08) 43.06,36.66 43.26,36.46 44.6,36.46 UD12.D2
  IN4 w0.071: v10(43.06,38.08) 43.06,38.67 44.64,40.25 45.71,40.25 52.55,47.09 52.55,47.67 54.81,49.92 54.81,50.83 55.09,51.12 55.09,51.47 58.8,55.17 64.14,55.17 64.53,55.56 69.32,55.56 70.97,57.21 72.35,57.21 v5(72.39,57.25)
  GND5 w0.104: v5(72.39,57.25) 72.43,57.21 72.75,57.21 v6(72.83,57.14)
  BOTTOM w0.122: UCPU1.BF19 72.96,57.27 v6(72.83,57.14)
DDR_B_D32: length 40.3
  IN4 w0.071: v5(57.77,58.59) 57.77,59.25 57.87,59.35 58.05,59.35 58.15,59.25 58.15,58.29 58.68,57.76 58.68,56.85 53.9,52.07 53.9,51.59 52.46,50.16 52.46,49.92 52.71,49.67 52.71,49.5 51.37,48.16 51.37,47.58 45.25,41.46 44.17,41.46 41.68,38.98 41.68,37.38 41.37,37.06 41.37,36.44 41.27,36.33 41.08,36.33 40.98,36.44 40.98,37.71 40.88,37.81 40.65,37.81 40.55,37.71 40.55,35.73 40.44,35.62 v10(40.22,35.62)
  GND5 w0.104: v6(58.07,58.2) 58.07,58.23 57.77,58.53 v5(57.77,58.59)
  BOTTOM w0.104: v10(40.22,35.62) 38.08,35.62 37.93,35.47 UD13.E3
  BOTTOM w0.122: UCPU1.BD50 58.07,58.28 v6(58.07,58.2)
DDR_B_D33: length 42
  IN4 w0.071: v10(34.32,37.28) 34.18,37.28 33.59,36.69 33.59,36.26 33.92,35.92 33.92,35.47 34.68,34.71 36.46,34.71 37.7,33.46 38.28,33.46 38.77,33.95 39.55,33.95 41.84,36.23 41.84,36.87 42.15,37.18 42.15,38.78 44.36,40.99 45.45,40.99 51.84,47.39 51.84,47.96 54.1,50.21 54.1,51.13 54.38,51.41 54.38,51.85 59.21,56.68 v5(59.24,56.68)
  GND5 w0.104: v5(59.24,56.68) v6(59.24,57.12)
  BOTTOM w0.104: v10(34.32,37.28) 34.72,36.88 UD13.C7
  BOTTOM w0.122: v6(59.24,57.12) 59.13,57.23 UCPU1.BF48
DDR_B_D34: length 38
  IN4 w0.071: v10(37.54,38.07) 37.78,38.07 37.89,38.18 37.89,38.3 37.78,38.41 37.78,38.53 37.96,38.7 38.08,38.7 38.19,38.59 38.31,38.59 38.41,38.7 38.41,39.26 38.55,39.39 38.55,39.51 38.49,39.57 38.49,39.69 38.67,39.87 38.79,39.87 38.84,39.81 38.96,39.81 39.14,39.99 39.14,40.1 39.08,40.16 39.08,40.28 39.26,40.46 39.38,40.46 39.44,40.4 39.56,40.4 39.73,40.58 39.73,40.7 39.68,40.76 39.68,40.87 39.85,41.05 39.97,41.05 40.03,40.99 40.15,40.99 40.33,41.17 40.33,41.29 40.27,41.35 40.27,41.47 40.45,41.65 40.56,41.65 40.62,41.59 40.74,41.59 40.92,41.76 40.92,41.88 40.86,41.94 40.86,42.06 41.04,42.24 41.16,42.24 41.22,42.18 41.33,42.18 41.51,42.36 41.51,42.48 41.45,42.53 41.45,42.65 41.63,42.83 41.75,42.83 41.81,42.77 41.93,42.77 42.02,42.86 42.02,43.12 42.11,43.2 42.36,43.2 43.01,43.85 43.3,43.85 43.42,43.98 43.42,44.27 51.92,52.77 51.92,52.87 51.84,52.96 51.84,53.25 51.91,53.33 52.03,53.33 52.2,53.15 52.3,53.15 52.43,53.28 52.43,53.43 52.26,53.6 52.26,53.69 52.44,53.87 52.56,53.87 52.73,53.69 52.85,53.69 53.03,53.87 53.03,53.99 52.85,54.16 52.85,54.28 53.03,54.46 53.15,54.46 53.32,54.29 53.44,54.29 53.62,54.46 53.62,54.58 53.45,54.76 53.45,54.87 53.62,55.05 53.74,55.05 53.92,54.88 54.03,54.88 54.21,55.06 54.21,55.18 54.04,55.35 54.04,55.47 54.22,55.65 54.34,55.65 54.51,55.47 54.63,55.47 54.81,55.65 54.81,55.77 54.63,55.94 54.63,56.06 54.81,56.24 54.93,56.24 55.1,56.06 55.22,56.06 55.8,56.65 55.8,58.13 55.7,58.23 55.15,58.23 55.05,58.33 55.05,58.81 55.15,58.92 55.84,58.92 55.91,58.84 55.91,58.74 v5(55.84,58.66)
  GND5 w0.104: v5(55.84,58.66) v6(56.13,58.96)
  BOTTOM w0.104: UD13.B3 v10(37.54,38.07)
  BOTTOM w0.122: UCPU1.BD53 56.5,58.59 v6(56.13,58.96)
DDR_B_D35: length 39.8
  IN4 w0.071: v5(57.41,56.38) 57.41,56.25 53.42,52.26 53.42,51.79 52.98,51.35 52.5,51.35 52.37,51.21 52.37,51.09 52.48,50.98 52.48,50.86 52.3,50.68 52.18,50.68 52.07,50.79 51.95,50.79 51.52,50.36 51.52,50.19 52.05,49.66 52.05,49.52 51.89,49.36 51.75,49.36 51.26,49.85 51,49.85 50.58,49.42 50.58,49.21 50.94,48.84 50.94,48.4 50.84,48.3 50.02,48.3 49.92,48.2 49.92,47.97 50.02,47.87 50.7,47.87 50.78,47.79 50.78,47.66 50.55,47.43 50.22,47.43 50.11,47.33 50.11,46.99 47.08,43.95 45.96,43.95 45.47,43.47 45.17,43.47 45.03,43.34 45.03,42.76 44.89,42.62 44.89,42.48 45.17,42.2 45.17,42.09 45.02,41.94 44.83,41.94 44.61,42.15 44.43,42.15 44.22,41.94 43.96,41.94 43.8,41.77 43.57,41.77 43.33,42.01 43.18,42.01 42.98,41.81 42.98,41.69 43.28,41.39 43.28,41.28 43.1,41.1 42.98,41.1 42.68,41.4 42.56,41.4 42.39,41.22 42.39,41.1 42.68,40.8 42.68,40.68 42.51,40.51 42.39,40.51 42.09,40.8 41.97,40.8 41.79,40.63 41.79,40.51 42.09,40.21 42.09,40.09 41.91,39.91 41.8,39.91 41.5,40.21 41.38,40.21 41.17,40 41.17,39.85 41.46,39.56 41.46,39.42 41.34,39.31 41.21,39.31 41.1,39.41 40.98,39.41 40.85,39.28 40.85,39.03 40.65,38.82 v10(40.27,38.82)
  GND5 w0.104: v5(57.41,56.38) 57.41,56.66 v6(57.55,56.79)
  BOTTOM w0.104: v10(40.27,38.82) 39.9,38.45 39.9,37.53 39.65,37.29 39.14,37.29 UD13.C2
  BOTTOM w0.122: v6(57.55,56.79) 57.15,57.19 UCPU1.BF52
DDR_B_D36: length 42.3
  IN4 w0.071: v10(34.32,35.7) 34.32,35.52 34.87,34.98 35.5,34.98 36.02,35.5 37.09,35.5 37.19,35.39 37.19,34.58 37.29,34.48 37.52,34.48 37.62,34.58 37.62,35.34 37.73,35.45 37.95,35.45 38.06,35.34 38.06,35.09 38.16,34.99 38.39,34.99 38.49,35.09 38.49,35.17 38.59,35.27 39.99,35.27 40,35.26 40.06,35.26 40.11,35.21 40.49,35.21 41.6,36.33 41.6,36.96 41.92,37.28 41.92,38.88 44.27,41.23 45.35,41.23 51.61,47.48 51.61,48.06 53.86,50.3 53.86,50.32 53.86,50.32 53.86,51.23 54.15,51.51 54.15,51.97 58.94,56.76 58.94,57.85 58.46,58.32 v5(58.46,58.52)
  GND5 w0.104: v5(58.46,58.52) 58.42,58.52 58.16,58.78 v6(58.14,58.78)
  BOTTOM w0.104: v10(34.32,35.7) 34.73,35.29 UD13.E7
  BOTTOM w0.122: v6(58.14,58.78) 58.14,58.77 58.37,58.54 UCPU1.BD49
DDR_B_D37: length 42.2
  IN4 w0.071: v10(33.54,35.67) 33.54,35.19 35.59,33.13 38.39,33.13 38.95,33.69 39.64,33.69 42.09,36.15 42.09,36.76 42.4,37.06 42.4,38.68 44.44,40.72 45.51,40.72 52.08,47.29 52.08,47.86 54.33,50.12 54.33,51.03 54.62,51.31 54.62,51.7 59.24,56.32 59.34,56.32 59.54,56.53 59.54,57.39 v5(59.39,57.54)
  GND5 w0.104: v6(59.21,57.95) 59.21,57.8 59.39,57.62 v5(59.39,57.54)
  BOTTOM w0.104: v10(33.54,35.67) 33.93,35.28 UD13.E8
  BOTTOM w0.122: v6(59.21,57.95) 58.63,57.95 UCPU1.BE49
DDR_B_D38: length 37.8
  IN4 w0.071: v10(34.32,36.46) 34.12,36.66 34.12,36.79 34.22,36.89 34.61,36.89 34.71,36.79 34.71,35.54 34.73,35.53 34.73,35.52 34.98,35.27 35.39,35.27 35.59,35.47 35.59,35.75 35.41,35.93 35.41,36.23 35.64,36.46 37.7,36.46 37.8,36.56 37.8,37.59 37.9,37.69 38.52,37.69 38.75,37.93 38.75,39.26 43.09,43.6 43.54,43.6 43.66,43.71 43.66,44.17 56.24,56.75 56.24,57.82 v5(56.24,57.82)
  GND5 w0.104: v5(56.24,57.82) 56.16,57.91 v6(56.16,58.27)
  BOTTOM w0.104: UD13.C8 33.93,36.88 34.32,36.49 v10(34.32,36.46)
  BOTTOM w0.122: v6(56.16,58.27) 55.85,58.58 UCPU1.BD54
DDR_B_D39: length 38.6
  IN4 w0.071: v10(40.32,38.19) 40.34,38.19 40.77,38.62 41.34,38.62 41.44,38.72 41.44,39.07 44.07,41.7 45.15,41.7 51.14,47.68 51.14,48.25 51.39,48.51 51.39,48.73 50.93,49.19 50.93,49.33 51.11,49.52 51.26,49.52 51.65,49.12 51.99,49.12 52.29,49.42 52.29,49.76 51.85,50.2 51.85,50.34 51.95,50.44 52.09,50.44 52.11,50.42 52.39,50.42 53.66,51.69 53.66,52.17 57.84,56.35 57.84,56.46 57.82,56.49 57.82,56.63 58.09,56.9 58.23,56.9 58.25,56.88 58.37,56.88 58.44,56.95 58.44,57.64 57.85,58.23 56.85,58.23 56.7,58.38 56.65,58.38 56.38,58.65 56.23,58.65 56.11,58.53 56.11,58.39 56.52,57.98 v5(56.67,57.98)
  GND5 w0.104: v6(57.06,58.18) 56.88,58.18 v5(56.67,57.98)
  BOTTOM w0.104: v10(40.32,38.19) 40.32,37.55 40.6,37.27 40.6,36.78 40.42,36.6 39.81,36.6 39.74,36.53 39.18,36.53 UD13.D2
  BOTTOM w0.122: v6(57.06,58.18) 56.87,58.18 UCPU1.BE53
DDR_B_D40: length 36
  TOP w0.076: UD14.E7 37.44,35.77 37.44,35.88 37.44,36.47 36.81,37.1 v10(36.59,37.1)
  IN4 w0.071: v10(36.59,37.1) 36.79,37.1 36.91,37.22 36.91,38.34 36.81,38.44 36.81,39.02 41.7,43.91 42.06,43.91 48.42,50.27 48.42,50.39 48.2,50.6 48.2,50.72 48.38,50.9 48.5,50.9 48.71,50.68 48.83,50.68 48.99,50.84 48.99,51.16 49.3,51.47 49.3,51.86 50.01,52.57 50.01,52.83 50.15,52.97 50.5,52.97 50.65,53.12 50.65,53.61 50.3,53.96 50.3,54.14 51.41,55.25 51.55,55.25 52.01,54.79 52.33,54.79 52.71,55.16 52.71,55.35 52.2,55.86 52.2,56.06 52.76,56.62 53.39,56.62 53.56,56.45 53.74,56.45 54.78,57.49 55.07,57.49 v5(55.2,57.62)
  GND5 w0.104: v5(55.2,57.62) 55.2,57.44 55.01,57.25 v6(55.01,57.2)
  BOTTOM w0.122: UCPU1.BF56 55.22,57.42 v6(55.01,57.2)
DDR_B_D41: length 37.5
  TOP w0.104: v10(36.4,38.6) 36.41,38.6 37.04,37.96 37.04,37.71 37.86,36.88 UD14.C7
  IN4 w0.071: v5(54.82,57.8) 54.75,57.8 53.81,56.85 52.66,56.85 51.85,56.04 51.85,55.88 52.38,55.35 52.38,55.17 52.24,55.02 52.11,55.02 51.57,55.56 51.37,55.56 49.77,53.96 49.77,52.67 48.93,51.82 48.93,51.7 48.99,51.63 48.99,51.52 48.82,51.34 48.7,51.34 48.63,51.41 48.51,51.41 47.89,50.78 47.89,50.58 48.08,50.39 48.08,50.26 47.91,50.09 47.79,50.09 47.65,50.23 47.53,50.23 47.35,50.05 47.35,49.93 47.49,49.79 47.49,49.67 47.31,49.5 47.19,49.5 47.06,49.64 46.94,49.64 46.76,49.46 46.76,49.34 46.9,49.2 46.9,49.08 46.72,48.9 46.6,48.9 46.46,49.04 46.34,49.04 46.17,48.86 46.17,48.75 46.3,48.61 46.3,48.49 46.13,48.31 46.01,48.31 45.87,48.45 45.75,48.45 45.57,48.27 45.57,48.15 45.71,48.01 45.71,47.9 45.53,47.72 45.42,47.72 45.28,47.86 45.16,47.86 44.98,47.68 44.98,47.56 45.12,47.42 45.12,47.3 44.94,47.13 44.82,47.13 44.68,47.26 44.57,47.26 44.39,47.09 44.39,46.97 44.53,46.83 44.53,46.71 44.35,46.53 44.23,46.53 44.09,46.67 43.97,46.67 43.8,46.49 43.8,46.37 43.93,46.24 43.93,46.12 43.76,45.94 43.64,45.94 43.5,46.08 43.38,46.08 43.2,45.9 43.2,45.78 43.34,45.64 43.34,45.52 41.96,44.15 41.6,44.15 36.4,38.94 v10(36.4,38.6)
  GND5 w0.104: v5(54.82,57.8) 54.82,57.84 55.06,58.08 v6(55.06,58.14)
  BOTTOM w0.122: v6(55.06,58.14) 54.94,58.02 UCPU1.BE57
DDR_B_D42: length 35.9
  TOP w0.104: UD14.B3 34.32,38.09 v10(34.32,38.11)
  IN4 w0.071: v10(34.32,38.11) 34.32,37.93 33.21,36.83 33.07,36.83 32.71,37.19 32.71,37.33 33.1,37.73 33.1,37.93 32.9,38.14 32.9,38.87 33.27,39.24 33.81,39.24 33.92,39.13 33.92,38.75 34.07,38.6 34.45,38.6 34.55,38.7 34.55,39.11 41.02,45.58 41.35,45.58 41.77,45.99 41.77,46.66 48.36,53.25 48.36,54.55 52.42,58.61 v5(52.56,58.61)
  GND5 w0.104: v6(52.91,58.91) 52.61,58.61 v5(52.56,58.61)
  BOTTOM w0.122: UCPU1.BC59 53.22,59.22 v6(52.91,58.91)
DDR_B_D43: length 35.7
  TOP w0.104: v10(32.01,38.08) 32.01,36.66 32.21,36.46 33.55,36.46 UD14.D2
  IN4 w0.071: v5(52.41,59.93) 52.53,59.8 52.53,59.68 51.99,59.13 51.99,58.87 47.87,54.75 47.87,53.45 34.12,39.71 33.07,39.71 31.83,38.47 31.83,38.26 v10(32.01,38.08)
  GND5 w0.104: v6(52.43,60.41) 52.41,60.39 v5(52.41,59.93)
  BOTTOM w0.122: UCPU1.AY60 52.56,60.54 v6(52.43,60.41)
DDR_B_D44: length 37.2
  TOP w0.104: UD14.C8 38.73,36.88 38.73,37.21 39.15,37.63 39.15,38.57 38.59,39.13 v10(37.98,39.13)
  IN4 w0.071: v10(37.98,39.13) 37.85,39.26 37.85,39.4 41.9,43.44 42.26,43.44 49.46,50.64 49.46,50.97 49.59,51.09 49.89,51.09 50,51.2 50,51.34 49.79,51.55 49.79,51.67 49.96,51.85 50.1,51.85 50.3,51.65 50.47,51.65 50.6,51.79 50.6,51.96 50.43,52.13 50.43,52.26 50.58,52.41 50.71,52.41 50.81,52.51 51.33,52.51 51.57,52.75 51.57,52.87 51.49,52.95 51.24,52.95 51.14,53.05 51.14,53.23 51.24,53.33 51.58,53.33 51.8,53.55 51.8,53.73 51.68,53.85 51.51,53.85 51.34,53.69 51.25,53.69 51.13,53.81 51.13,54.28 51.42,54.57 51.56,54.57 52.09,54.04 52.25,54.04 53.37,55.16 53.37,55.36 52.85,55.88 52.85,56.04 52.96,56.14 53.2,56.14 53.55,55.79 53.75,55.79 54.51,56.55 54.87,56.55 54.95,56.48 55.3,56.48 55.5,56.69 55.5,56.91 55.3,57.11 55.3,57.29 55.5,57.49 v5(55.5,57.9)
  GND5 w0.104: v5(55.5,57.9) 55.5,58.35 v6(55.5,58.36)
  BOTTOM w0.122: v6(55.5,58.36) 55.78,58.07 UCPU1.BE54
DDR_B_D45: length 36.2
  TOP w0.076: v10(35.1,35.7) 35.1,35.68 34.73,35.31 UD14.E3
  IN4 w0.071: v10(35.1,35.7) 35.06,35.7 34.96,35.8 34.96,36.61 35.06,36.71 37.45,36.71 37.55,36.81 37.55,37.05 37.45,37.15 37.25,37.15 37.15,37.25 37.15,38.43 37.07,38.52 37.07,38.94 41.8,43.68 42.16,43.68 49.22,50.74 49.22,51.06 49.54,51.38 49.54,51.76 50.25,52.47 50.25,52.62 50.37,52.74 50.6,52.74 50.89,53.03 50.89,54.4 51.37,54.88 51.59,54.88 52.07,54.39 52.28,54.39 53.09,55.2 53.09,55.31 52.61,55.79 52.61,56.13 52.86,56.38 53.3,56.38 53.55,56.12 53.74,56.12 54.41,56.79 v5(55.13,56.79)
  GND5 w0.104: v6(55.57,56.75) 55.53,56.79 v5(55.13,56.79)
  BOTTOM w0.122: UCPU1.BG54 55.73,56.91 v6(55.57,56.75)
DDR_B_D46: length 36.3
  TOP w0.076: v10(36.5,37.76) 36.63,37.62 36.63,37.6 37.62,36.62 37.62,36.21 37.62,36.21 37.62,35.95 37.62,35.94 37.88,35.67 37.98,35.67 38.37,35.28 38.73,35.28 UD14.E8
  IN4 w0.071: v10(36.5,37.76) 36.5,38.1 36.41,38.19 36.18,38.19 35.97,38.39 35.97,38.85 41.5,44.38 41.87,44.38 42.96,45.48 42.96,46.19 49.54,52.76 49.54,54.06 52.56,57.09 53.71,57.09 54.26,57.64 54.26,59.02 54.44,59.19 54.44,59.8 54.16,60.08 v5(53.83,60.08)
  GND5 w0.104: v5(53.83,60.08) 54.03,59.88 v6(54.3,59.88)
  BOTTOM w0.122: UCPU1.BA58 v6(54.3,59.88)
DDR_B_D47: length 35.1
  TOP w0.104: v10(32.47,38.52) 32.75,38.24 32.75,37.53 32.98,37.3 33.51,37.3 UD14.C2
  IN4 w0.071: v10(32.47,38.52) 32.47,38.77 33.17,39.47 34.22,39.47 48.1,53.35 48.1,54.66 52.22,58.78 52.22,59.01 52.84,59.63 53.02,59.63 53.52,60.13 53.52,60.21 53.8,60.49 v5(53.88,60.49)
  GND5 w0.104: v6(53.6,60.82) 53.88,60.54 v5(53.88,60.49)
  BOTTOM w0.122: v6(53.6,60.82) 53.32,61.1 UCPU1.AW59
DDR_B_D48: length 48.4
  IN4 w0.071: v10(22.49,35.67) 22.49,35.21 24.56,33.13 26.32,33.13 26.88,33.69 29.35,33.69 31.12,35.46 31.12,36.39 31.58,36.84 31.58,38.54 32.97,39.94 34.02,39.94 47.63,53.55 47.63,54.85 51.75,58.97 51.75,59.73 52.86,60.84 53.29,60.84 53.63,61.18 v5(53.83,61.18)
  GND5 w0.104: v5(53.83,61.18) 53.86,61.18 54.11,60.92 v6(54.16,60.92)
  BOTTOM w0.104: v10(22.49,35.67) 22.88,35.28 UD15.E8
  BOTTOM w0.122: v6(54.16,60.92) 54.13,60.92 53.91,61.15 53.9,61.15 UCPU1.AW58
DDR_B_D49: length 49.4
  IN4 w0.071: v5(53.86,61.86) 53.06,61.07 52.75,61.07 51.51,59.83 51.51,59.05 47.39,54.93 47.39,53.65 33.93,40.18 32.88,40.18 31.34,38.64 31.34,36.94 30.89,36.48 30.89,35.56 29.35,34.02 26.25,34.02 25.58,34.68 23.52,34.68 22.89,35.32 22.89,36.9 v10(23.27,37.28)
  GND5 w0.104: v6(54.3,61.86) v5(53.86,61.86)
  BOTTOM w0.104: v10(23.27,37.28) 23.67,36.88 UD15.C7
  BOTTOM w0.122: UCPU1.AU58 v6(54.3,61.86)
DDR_B_D50: length 48.3
  IN4 w0.071: v5(51.9,63.62) 51.9,63.62 51.29,63.62 51.13,63.47 51.13,63.35 51.26,63.22 51.26,63.1 51.08,62.92 50.96,62.92 50.84,63.05 50.72,63.05 50.6,62.93 50.6,62.44 48.8,60.63 48.8,59.71 45.01,55.92 44.84,55.92 44.59,56.17 44.27,56.17 44.13,56.02 43.97,56.02 43.83,56.17 43.64,56.17 43.5,56.03 43.5,55.91 44.17,55.24 44.17,55.08 43.66,54.57 43.52,54.57 43.33,54.75 43.33,54.9 43.54,55.11 43.54,55.28 43.21,55.62 43.09,55.62 42.91,55.44 42.91,55.32 42.97,55.26 42.97,55.14 42.79,54.96 42.67,54.96 42.61,55.02 42.5,55.02 41.03,53.56 41.03,53.33 40.94,53.24 40.71,53.24 40.64,53.16 40.64,52.96 40.72,52.88 41.5,52.88 41.98,53.36 42.11,53.36 42.21,53.26 42.21,53.12 41.55,52.46 40.72,52.46 40.64,52.38 40.64,52.18 40.74,52.08 40.88,52.08 40.98,51.99 40.98,51.89 40.85,51.76 40.74,51.76 40.64,51.65 40.64,50.29 34.48,44.13 32.52,44.13 26.37,37.99 v10(26.32,37.99)
  GND5 w0.104: v6(52.32,63.5) 52.18,63.5 52.06,63.62 v5(51.9,63.62)
  BOTTOM w0.104: v10(26.32,37.99) 26.57,37.99 UD15.B3
  BOTTOM w0.122: v6(52.32,63.5) 52.48,63.66 UCPU1.AN61
DDR_B_D51: length 46
  IN4 w0.071: v5(53.23,63.93) 53.07,63.77 52.46,63.77 51.95,63.26 51.76,63.26 49.08,60.57 49.08,59.65 40.87,51.45 40.87,50.19 34.56,43.88 32.6,43.88 27.16,38.44 27.15,38.44 26.8,38.09 26.8,37.81 25.61,36.61 24.8,36.61 24.39,36.21 24.39,35.91 24.44,35.86 24.44,35.54 24.19,35.29 23.91,35.29 23.67,35.54 23.67,36.06 v10(23.27,36.46)
  GND5 w0.104: v5(53.23,63.93) 53.2,63.93 52.9,63.62 v6(52.88,63.62)
  BOTTOM w0.104: v10(23.27,36.46) 23.27,36.49 22.88,36.88 UD15.C8
  BOTTOM w0.122: UCPU1.AN59 53.2,63.94 v6(52.88,63.62)
DDR_B_D52: length 46.8
  IN4 w0.071: v5(53.25,61.99) 53.25,61.96 51.28,60 51.28,59.13 47.14,55 47.14,54.61 45.81,53.28 45.81,52.44 33.79,40.42 32.78,40.42 31.1,38.74 31.1,37.04 30.65,36.58 30.65,35.66 29.32,34.33 27.03,34.33 25.86,35.5 24.98,35.5 24.52,35.04 23.81,35.04 23.27,35.57 v10(23.27,35.7)
  GND5 w0.104: v5(53.25,61.99) 53.27,61.96 v6(53.27,61.51)
  BOTTOM w0.104: UD15.E7 23.68,35.29 v10(23.27,35.7)
  BOTTOM w0.122: v6(53.27,61.51) 53.2,61.57 UCPU1.AU59
DDR_B_D53: length 48
  IN4 w0.071: v5(52.45,61.61) 51.04,60.2 51.04,59.21 46.91,55.08 46.91,54.71 45.42,53.22 45.42,52.79 45.57,52.64 45.57,52.54 45.42,52.38 45.3,52.38 45.04,52.65 44.92,52.65 44.74,52.47 44.74,52.35 45.01,52.09 45.01,51.97 44.83,51.79 44.71,51.79 44.45,52.06 44.33,52.06 44.15,51.88 44.15,51.76 44.41,51.49 44.41,51.38 44.24,51.2 44.12,51.2 43.85,51.46 43.74,51.46 43.56,51.28 43.56,51.17 43.82,50.9 43.82,50.78 43.64,50.61 43.52,50.61 43.26,50.87 43.14,50.87 42.96,50.69 42.96,50.57 43.23,50.31 43.23,50.19 34.17,41.14 33.92,41.14 33.71,41.34 33.37,41.34 33.21,41.19 32.95,41.19 32.85,41.08 32.85,40.82 31.11,39.08 30.92,39.08 30.77,39.23 30.58,39.23 30.33,38.99 30.33,38.82 30.85,38.3 30.85,37.15 30.26,36.55 29.52,36.55 29.42,36.45 29.42,36.19 29.52,36.09 30.3,36.09 30.39,36 30.39,35.75 30.3,35.67 29.42,35.67 29.32,35.56 29.32,35.22 29.42,35.12 v10(29.52,35.12)
  GND5 w0.104: v6(52.84,61.78) 52.84,61.78 52.67,61.61 v5(52.45,61.61)
  BOTTOM w0.104: UD15.E3 26.88,35.47 27.11,35.7 28.94,35.7 v10(29.52,35.12)
  BOTTOM w0.122: UCPU1.AU61 52.66,61.96 v6(52.84,61.78)
DDR_B_D54: length 50.1
  IN4 w0.071: v5(53.81,63.79) 53.81,63.65 53.52,63.36 53.1,63.36 52.94,63.51 52.64,63.51 52.14,63.02 51.86,63.02 49.31,60.48 49.31,60.26 49.39,60.19 49.54,60.19 49.63,60.1 49.63,59.87 49.56,59.8 49.41,59.8 49.31,59.71 49.31,59.56 41.53,51.78 41.53,51.57 41.45,51.49 41.26,51.49 41.18,51.4 41.18,51.15 41.26,51.07 41.45,51.07 41.53,50.98 41.53,50.76 41.43,50.66 41.19,50.66 41.11,50.58 41.11,50.09 34.36,43.35 34.22,43.35 33.94,43.62 32.68,43.62 32.49,43.44 32.49,43.29 32.6,43.19 33.79,43.19 33.9,43.09 33.9,42.88 33.78,42.77 32.41,42.77 32.19,42.99 32.04,42.99 27.62,38.56 27.62,38.32 27.72,38.21 27.72,37.71 27.79,37.63 27.9,37.63 28.2,37.93 28.2,38.11 28.28,38.19 v10(29.27,38.19)
  GND5 w0.104: v6(53.45,63.58) 53.55,63.58 53.76,63.79 v5(53.81,63.79)
  BOTTOM w0.104: UD15.D2 28.13,36.53 28.69,36.53 28.76,36.6 29.37,36.6 29.55,36.78 29.55,37.9 v10(29.27,38.19)
  BOTTOM w0.122: UCPU1.AN58 53.7,63.84 v6(53.45,63.58)
DDR_B_D55: length 48.3
  IN4 w0.071: v10(28.96,38.72) 28.73,38.49 28.38,38.49 28.24,38.63 28.24,38.76 30.97,41.49 31.33,41.49 31.43,41.59 31.43,41.95 32.01,42.53 33.88,42.53 41.77,50.42 41.77,51.68 42.1,52.01 42.22,52.01 42.3,51.93 42.42,51.93 42.6,52.11 42.6,52.22 42.52,52.31 42.52,52.43 42.7,52.6 42.81,52.6 42.9,52.52 43.02,52.52 43.19,52.7 43.19,52.82 43.11,52.9 43.11,53.02 43.29,53.2 43.41,53.2 43.49,53.11 43.61,53.11 43.79,53.29 43.79,53.41 43.7,53.49 43.7,53.61 43.88,53.79 44,53.79 44.08,53.71 44.2,53.71 44.38,53.88 44.38,54 44.3,54.09 44.3,54.2 44.47,54.38 44.59,54.38 44.68,54.3 44.79,54.3 44.97,54.48 44.97,54.6 44.89,54.68 44.89,54.8 45.07,54.97 45.19,54.97 45.27,54.89 45.39,54.89 45.56,55.07 45.56,55.19 45.48,55.27 45.48,55.39 49.86,59.77 49.86,60.69 51.94,62.76 52.29,62.76 52.65,63.12 53.18,63.12 54.01,62.29 54.16,62.29 54.29,62.42 54.54,62.42 55.21,63.09 55.21,63.23 55.04,63.39 54.9,63.39 54.31,62.8 54.08,62.8 53.8,63.08 53.8,63.21 v5(53.91,63.31)
  GND5 w0.104: v6(54.3,63.18) 54.17,63.31 v5(53.91,63.31)
  BOTTOM w0.104: v10(28.96,38.72) 28.85,38.61 28.85,37.53 28.6,37.29 28.09,37.29 27.68,36.88 UD15.C2
  BOTTOM w0.122: UCPU1.AR58 v6(54.3,63.18)
DDR_B_D56: length 51.8
  TOP w0.104: UD16.C7 26.82,36.88 25.86,37.83 25.86,38.21 25.46,38.62 v10(25.45,38.62)
  IN4 w0.071: v10(25.45,38.62) 26.03,39.2 26.59,39.2 29.78,42.39 29.78,42.53 29.62,42.69 29.62,43.21 30.34,43.93 30.45,43.93 30.81,43.58 30.93,43.58 31.04,43.7 31.04,43.82 30.78,44.08 30.78,44.22 30.88,44.32 31.02,44.32 31.28,44.06 31.44,44.06 32.26,44.88 34.22,44.88 39.48,50.14 39.48,50.3 39.29,50.49 39.29,50.65 39.38,50.74 39.78,50.74 39.91,50.86 39.91,51.06 39.81,51.17 39.4,51.17 39.29,51.28 39.29,54.13 42.04,56.88 44.96,56.88 47.23,59.15 47.23,59.5 47.32,59.58 47.66,59.58 47.76,59.68 47.76,59.82 47.66,59.92 47.32,59.92 47.23,60 47.23,60.17 47.32,60.25 47.55,60.25 47.63,60.34 47.63,60.5 47.55,60.59 47.32,60.59 47.23,60.67 47.23,61.81 47.43,62.01 48.67,62.01 51.16,64.49 52.7,64.49 53.03,64.83 53.43,64.83 53.56,64.96 53.56,65.24 53.86,65.53 v5(53.86,65.82)
  GND5 w0.104: v6(53.57,66.17) 53.57,66.11 v5(53.86,65.82)
  BOTTOM w0.122: v6(53.57,66.17) 53.85,65.89 UCPU1.AK58
DDR_B_D57: length 52.9
  TOP w0.104: v10(26.29,38.77) 26.36,38.85 27.79,38.85 28.1,38.54 28.1,37.63 27.68,37.21 UD16.C8
  IN4 w0.071: v5(53.86,65.11) 53.86,64.9 53.51,64.56 53.11,64.56 52.8,64.25 51.25,64.25 48.28,61.28 48.28,59.86 45.06,56.64 42.79,56.64 42.7,56.55 42.7,56.43 42.85,56.28 42.85,56.16 42.69,55.99 42.55,55.99 42.12,56.43 41.94,56.43 41.49,55.97 41.49,55.79 41.92,55.36 41.92,55.22 41.77,55.08 41.59,55.08 41.18,55.49 40.99,55.49 40.55,55.05 40.55,54.85 40.95,54.44 40.95,54.26 40.82,54.13 40.66,54.13 40.24,54.55 40.05,54.55 39.53,54.03 39.53,53.51 39.66,53.38 40.04,53.38 40.16,53.25 40.16,53.02 40.09,52.95 39.63,52.95 39.53,52.84 39.53,52.16 39.66,52.03 40.04,52.03 40.16,51.9 40.16,50.49 34.32,44.64 32.36,44.64 30.83,43.12 30.69,43.12 30.36,43.45 30.18,43.45 29.85,43.12 29.85,42.79 30.08,42.56 30.08,42.36 26.49,38.77 v10(26.29,38.77)
  GND5 w0.104: v6(54.16,65.42) v5(53.86,65.11)
  BOTTOM w0.122: v6(54.16,65.42) 53.89,65.15 UCPU1.AL58
DDR_B_D58: length 53.9
  TOP w0.076: UD16.E3 23.68,35.31 24.05,35.68 v10(24.05,35.7)
  IN4 w0.071: v5(53.91,67.69) 53.89,67.69 53.54,67.34 53.54,66.87 53.26,66.59 50.35,66.59 48.39,64.63 46.63,64.63 46.33,64.93 43.1,64.93 37.23,59.06 37.23,50.23 33.56,46.56 30.58,46.56 23.47,39.46 23.27,39.46 22.89,39.08 22.89,38.44 23.66,37.68 23.66,36.48 24.05,36.09 v10(24.05,35.7)
  GND5 w0.104: v5(53.91,67.69) 53.86,67.69 53.83,67.67 53.83,67.67 53.6,67.44 v6(53.54,67.44)
  BOTTOM w0.122: v6(53.54,67.44) 53.85,67.13 UCPU1.AG58
DDR_B_D59: length 53
  TOP w0.104: UD16.C2 22.5,37.26 21.91,37.26 21.7,37.48 21.7,38.39 v10(21.55,38.54)
  IN4 w0.071: v10(21.55,38.54) 21.42,38.54 22.62,39.75 23.43,39.75 30.48,46.8 33.45,46.8 37,50.35 37,59.17 43,65.17 47.83,65.17 47.92,65.08 47.92,64.97 48,64.88 48.17,64.88 48.25,64.97 48.25,65.08 48.34,65.17 48.59,65.17 50.39,66.97 51.8,66.97 52.18,67.35 52.79,67.35 53.1,67.03 v5(53.22,67.03)
  GND5 w0.104: v5(53.22,67.03) 53.26,67 53.26,66.62 v6(53.3,66.59)
  BOTTOM w0.122: UCPU1.AG59 53.2,66.68 v6(53.3,66.59)
DDR_B_D60: length 53.2
  TOP w0.076: UD16.E7 26.39,35.77 26.39,36.47 25.76,37.1 v10(25.54,37.1)
  IN4 w0.071: v10(25.54,37.1) 25.71,37.1 26.09,37.48 26.09,37.63 25.81,37.91 25.81,38.27 25.92,38.37 26.45,38.37 26.78,38.7 26.78,38.73 32.44,44.39 34.4,44.39 40.4,50.39 40.4,52.13 40.26,52.27 39.91,52.27 39.78,52.4 39.78,52.57 39.91,52.69 40.27,52.69 40.4,52.82 40.4,53.47 40.26,53.61 39.88,53.61 39.77,53.73 39.77,53.93 40.05,54.22 40.24,54.22 40.65,53.81 40.84,53.81 41.26,54.23 41.26,54.47 40.88,54.85 40.88,55.03 41,55.16 41.18,55.16 41.61,54.72 41.75,54.72 42.15,55.13 42.15,55.46 41.85,55.76 41.85,55.93 41.98,56.06 42.16,56.06 42.45,55.76 42.79,55.76 43.09,56.06 43.09,56.3 43.19,56.4 44.69,56.4 44.84,56.25 45,56.25 48.57,59.81 48.57,60.73 48.83,60.99 48.83,61.13 48.72,61.23 48.72,61.38 48.86,61.53 48.98,61.53 49.11,61.4 49.23,61.4 49.35,61.52 49.35,61.64 49.22,61.76 49.22,61.88 49.34,62 49.46,62 49.58,61.87 49.7,61.87 49.82,61.99 49.82,62.11 49.69,62.24 49.69,62.36 49.81,62.48 49.93,62.48 50.06,62.35 50.18,62.35 50.29,62.47 50.29,62.59 50.17,62.71 50.17,62.83 51.35,64.02 52.9,64.02 53.19,64.3 53.5,64.3 v5(53.58,64.22)
  GND5 w0.104: v6(53.27,64.49) 53.28,64.49 53.55,64.22 v5(53.58,64.22)
  BOTTOM w0.122: UCPU1.AM60 v6(53.27,64.49)
DDR_B_D61: length 53.6
  TOP w0.076: UD16.E8 27.68,35.28 27.32,35.28 26.93,35.67 26.84,35.67 26.57,35.95 26.57,36.62 25.58,37.6 25.58,37.62 v10(25.45,37.76)
  IN4 w0.071: v10(25.45,37.76) 25.45,38.02 25,38.47 25,38.98 25.83,39.81 25.97,39.81 26.34,39.44 26.49,39.44 26.65,39.6 26.65,39.72 26.5,39.86 26.5,40 26.6,40.1 26.74,40.1 26.88,39.95 27,39.95 27.12,40.07 27.12,40.19 27.1,40.22 27.1,40.33 27.21,40.45 27.33,40.45 27.36,40.43 27.48,40.43 27.6,40.55 27.6,40.66 27.55,40.71 27.55,40.85 27.64,40.95 27.78,40.95 27.83,40.9 27.95,40.9 28.07,41.02 28.07,41.14 27.99,41.22 27.99,41.36 28.09,41.46 28.23,41.46 28.31,41.38 28.43,41.38 28.54,41.49 28.54,41.61 28.52,41.64 28.52,41.76 28.64,41.88 28.76,41.88 28.78,41.85 28.9,41.85 29.22,42.17 29.22,42.33 29.09,42.46 29.09,42.58 29.38,42.87 29.38,43.36 30.66,44.64 31.02,44.64 31.15,44.77 31.15,45.08 31.22,45.15 31.45,45.15 31.53,45.06 31.53,44.83 31.62,44.74 31.78,44.74 31.87,44.83 31.87,45.06 31.95,45.15 34.16,45.15 39.06,50.05 39.06,54.23 39.3,54.47 39.3,54.59 39.2,54.68 39.2,54.8 39.32,54.92 39.44,54.92 39.53,54.82 39.65,54.82 39.77,54.94 39.77,55.06 39.67,55.16 39.67,55.28 39.79,55.39 39.91,55.39 40.01,55.3 40.13,55.3 41.94,57.11 44.86,57.11 47,59.25 47,61.91 47.33,62.24 48.57,62.24 51.06,64.73 52.59,64.73 52.99,65.13 v5(53.25,65.13)
  GND5 w0.104: v6(53.5,65.54) 53.5,65.37 v5(53.25,65.13)
  BOTTOM w0.122: v6(53.5,65.54) 53.5,65.34 53.21,65.05 UCPU1.AL59
DDR_B_D62: length 52.8
  TOP w0.104: v10(21.09,38.09) 20.96,37.96 20.96,36.66 21.17,36.46 22.5,36.46 UD16.D2
  IN4 w0.071: v10(21.09,38.09) 21.09,38.67 22.4,39.98 23.33,39.98 30.38,47.04 33.35,47.04 36.76,50.45 36.76,59.26 42.9,65.4 48.5,65.4 50.57,67.48 v5(51.72,67.48)
  GND5 w0.104: v6(52.04,67.78) 52.04,67.78 51.73,67.48 v5(51.72,67.48)
  BOTTOM w0.122: UCPU1.AF61 v6(52.04,67.78)
DDR_B_D63: length 53.7
  TOP w0.104: v10(23.32,38.9) 23.35,38.87 23.32,38.85 23.32,38.03 UD16.B3
  IN4 w0.071: v5(52.05,66.23) 51.95,66.33 50.47,66.33 47.96,63.82 46.44,63.82 46.34,63.92 46.34,64.59 46.24,64.7 46.01,64.7 45.9,64.59 45.9,63.92 45.8,63.82 45.57,63.82 45.47,63.92 45.47,64.59 45.37,64.7 45.14,64.7 45.04,64.59 45.04,63.92 44.94,63.82 44.74,63.82 44.61,63.95 44.61,64.58 44.49,64.7 44.28,64.7 44.18,64.59 44.18,63.92 44.08,63.82 43.85,63.82 43.75,63.92 43.75,64.59 43.64,64.7 43.42,64.7 43.31,64.59 43.31,63.92 43.21,63.82 42.32,63.82 37.45,58.95 37.45,50.12 33.66,46.33 30.68,46.33 23.32,38.98 v10(23.32,38.9)
  GND5 w0.104: v5(52.05,66.23) 52.08,66.23 52.32,66.47 v6(52.42,66.47)
  BOTTOM w0.122: UCPU1.AH60 v6(52.42,66.47)
DDR_B_DQS0: length 60
  IN4 w0.071: v5(81.73,64.53) 81.87,64.67 83.21,64.67 84.59,63.29 84.59,51.77 81.66,48.84 80.4,48.84 76.25,44.7 76.07,44.7 75.82,44.95 75.82,45.13 78.7,48 78.7,48.34 78.33,48.71 77.99,48.71 74.9,45.61 74.82,45.54 74.82,45.15 74.36,44.69 73.63,44.69 73.41,44.48 66.3,44.48 64.98,43.16 63.9,43.16 62.77,42.02 62.77,40.3 63.02,40.05 63.02,38.22 62.53,37.72 61.75,37.72 60.93,36.89 60.31,36.89 60.21,37 60.21,37.09 v10(60.41,37.3)
  GND5 w0.076: v5(81.73,64.53) 81.54,64.72 81.38,64.72 81.25,64.59 v6(81.25,64.51)
  BOTTOM w0.114: v6(81.25,64.51) 81.25,64.51 81.41,64.67 UCPU1.AM2
  BOTTOM w0.127: v10(60.41,37.3) 60.03,36.91 UD9.C3
DDR_B_DQS1: length 42.5
  TOP w0.076: v10(57.21,38.09) 57.59,37.71 57.59,37.03 57.13,36.56 56.97,36.56 56.82,36.71 UD10.C3
  IN4 w0.071: v10(57.21,38.09) 57.22,38.09 57.4,38.27 57.4,40.24 57.76,40.6 57.99,40.6 59.53,42.14 59.53,42.76 62.81,46.04 63.89,46.04 65.57,47.72 71.58,47.72 73.07,49.21 74.35,49.21 79.31,54.18 79.9,54.18 80.16,54.44 80.16,55.96 81.4,57.2 81.4,59.4 81.44,59.44 81.44,60.15 81.14,60.45 81.14,60.78 81.37,61.01 81.51,61.01 v5(81.66,61.16)
  GND5 w0.076: v5(81.66,61.16) 81.94,60.87 v6(82.22,60.87)
  BOTTOM w0.114: UCPU1.AV1 82.1,60.99 v6(82.22,60.87)
DDR_B_DQS2: length 45.8
  IN4 w0.071: v10(49.36,37.27) 49.62,37.01 50.12,37.01 50.26,37.15 50.26,39.18 50.5,39.41 50.97,39.41 51.12,39.56 51.12,40.11 51.36,40.35 51.88,40.35 52.12,40.11 52.12,39.88 52.2,39.79 52.38,39.79 52.83,40.23 52.83,40.63 54.84,42.64 54.84,42.77 54.46,43.15 54.46,43.48 54.83,43.86 55.17,43.86 55.52,43.51 55.7,43.51 55.94,43.76 55.94,43.94 55.55,44.33 55.55,44.67 55.92,45.04 56.26,45.04 56.76,44.54 56.93,44.54 57.18,44.79 57.18,44.97 56.67,45.48 56.67,45.78 56.9,46.01 57.39,46.01 57.6,46.23 57.6,46.71 59.47,48.58 60.97,48.58 63.22,50.83 70.29,50.83 73.05,53.59 74.25,53.59 76.96,56.3 76.96,57.41 77.13,57.59 77.36,57.59 v5(77.48,57.71)
  GND5 w0.076: v5(77.48,57.71) 77.49,57.71 77.62,57.58 77.77,57.58 v6(77.9,57.71)
  BOTTOM w0.114: v6(77.9,57.71) 77.86,57.67 77.69,57.67 UCPU1.BE11
  BOTTOM w0.127: UD11.C3 48.98,36.89 v10(49.36,37.27)
DDR_B_DQS3: length 44.9
  TOP w0.076: v10(46.16,38.09) 46.54,37.71 46.54,37.03 46.08,36.56 45.93,36.56 45.78,36.71 UD12.C3
  IN4 w0.071: v5(73.73,58.38) 73.83,58.28 73.83,56.86 73.16,56.19 71.41,56.19 69.82,54.6 64.93,54.6 64.54,54.2 64.42,54.2 64.21,53.99 64.21,53.63 64.1,53.53 63.7,53.53 63.6,53.63 63.6,53.99 63.38,54.2 62.82,54.2 62.61,53.99 62.61,53.63 62.5,53.53 62.08,53.53 61.98,53.63 61.98,53.99 61.77,54.2 61.19,54.2 60.98,53.99 60.98,53.84 60.88,53.73 60.46,53.73 60.36,53.84 60.36,53.96 60.12,54.2 59.23,54.2 58.25,53.23 58.25,52.7 58.01,52.46 58.01,51.74 53.91,47.64 53.91,47.07 46.43,39.59 46.43,38.28 46.24,38.09 v10(46.16,38.09)
  GND5 w0.076: v5(73.73,58.38) 73.84,58.5 73.84,58.84 v6(73.73,58.96)
  BOTTOM w0.114: UCPU1.BD18 73.63,58.54 73.76,58.68 73.76,58.92 v6(73.73,58.96)
DDR_B_DQS4: length 39.9
  IN4 w0.071: v10(38.31,37.27) 38.31,37.11 38.44,36.98 38.8,36.98 38.98,36.79 38.98,36.42 39.1,36.31 39.31,36.31 39.57,36.56 39.57,37.08 39.25,37.4 39.25,37.77 39.52,38.04 39.52,38.35 39.25,38.62 39.25,39.05 42.9,42.7 44,42.7 44.35,43.05 44.35,43.43 44.15,43.62 44.15,43.95 44.54,44.34 44.85,44.34 45.03,44.16 45.17,44.16 45.46,44.45 45.46,44.6 45.3,44.76 45.3,45.07 45.7,45.47 46,45.47 46.73,44.75 46.87,44.75 47.17,45.04 47.17,45.18 46.43,45.92 46.43,46.22 46.83,46.63 47.14,46.63 47.87,45.89 48.02,45.89 48.3,46.17 48.3,46.32 48.06,46.56 48.06,46.86 48.46,47.26 48.76,47.26 49,47.02 49.15,47.02 49.43,47.3 49.43,47.44 48.89,47.98 48.89,48.7 56.73,56.54 56.73,56.84 57.44,57.54 57.6,57.54 v5(57.72,57.66)
  GND5 w0.076: v5(57.72,57.66) 57.83,57.54 57.98,57.54 58.12,57.69 v6(58.14,57.69)
  BOTTOM w0.114: v6(58.14,57.69) 58.13,57.68 57.92,57.68 UCPU1.BE51
  BOTTOM w0.127: v10(38.31,37.27) 37.93,36.89 UD13.C3
DDR_B_DQS5: length 34
  TOP w0.076: UD14.C3 34.73,36.71 34.88,36.56 35.03,36.56 35.49,37.03 35.49,37.71 v10(35.11,38.09)
  IN4 w0.071: v5(52.98,59.32) 53.1,59.2 53.1,58.87 53.29,58.67 53.46,58.67 53.59,58.54 53.59,57.9 53.43,57.75 53.12,57.75 52.95,57.92 52.47,57.92 48.88,54.33 48.88,53.04 42.29,46.45 42.29,45.78 41.57,45.06 41.24,45.06 35.07,38.89 35.07,38.63 35.31,38.39 35.31,38.28 35.12,38.09 v10(35.11,38.09)
  GND5 w0.076: v5(52.98,59.32) 52.98,59.32 53.12,59.46 53.12,59.55 52.9,59.77 v6(52.86,59.77)
  BOTTOM w0.114: UCPU1.BA61 52.64,59.99 v6(52.86,59.77)
DDR_B_DQS6: length 48.3
  IN4 w0.071: v10(27.26,37.27) 27.49,37.05 27.7,37.05 27.91,36.83 27.91,35.94 27.67,35.7 27.19,35.7 27.03,35.55 27.03,35.34 27.36,35.01 28.18,35.01 28.62,35.46 28.62,35.7 28.43,35.89 28.43,37.44 28.68,37.69 29.32,37.69 29.78,37.24 29.98,37.24 30.17,37.43 30.17,38.02 29.52,38.67 29.52,39.32 29.76,39.56 29.94,39.56 30.09,39.72 30.09,39.89 31.2,41 31.48,41 31.69,40.79 31.82,40.79 32.15,41.11 32.15,41.24 31.94,41.45 31.94,41.74 32.24,42.04 32.6,42.04 32.75,41.88 32.92,41.88 33.06,42.02 34.09,42.02 42.27,50.2 42.27,51.04 46.22,54.99 46.22,55.3 50.36,59.44 50.36,60.49 52.14,62.27 52.22,62.27 52.73,62.78 v5(53.1,62.78)
  GND5 w0.076: v5(53.1,62.78) 53.11,62.77 v6(53.51,62.77)
  BOTTOM w0.114: v6(53.51,62.77) 53.51,62.77 UCPU1.AR59
  BOTTOM w0.127: v10(27.26,37.27) 26.88,36.89 UD15.C3
DDR_B_DQS7: length 52.5
  TOP w0.076: UD16.C3 23.68,36.71 23.83,36.56 23.98,36.56 24.44,37.03 24.44,37.71 v10(24.06,38.09)
  IN4 w0.071: v10(24.06,38.09) 24.16,38.09 24.3,38.23 24.3,39.25 25.99,40.94 26.28,40.94 26.43,40.78 26.56,40.78 26.89,41.11 26.89,41.23 26.73,41.39 26.73,41.68 27.37,42.32 27.66,42.32 27.82,42.17 27.95,42.17 28.27,42.49 28.27,42.62 28.11,42.78 28.11,43.06 30.88,45.83 33.88,45.83 38.37,50.33 38.37,57.71 38.58,57.91 39.2,57.91 39.33,58.04 39.33,58.42 39.2,58.55 38.58,58.55 38.37,58.75 38.37,59.17 42.53,63.33 48.17,63.33 50.44,65.6 51.01,65.6 51.05,65.56 52.66,65.56 52.75,65.65 52.75,65.79 v5(52.64,65.9)
  GND5 w0.076: v6(52.65,65.48) 52.65,65.5 52.75,65.6 52.75,65.79 v5(52.64,65.9)
  BOTTOM w0.114: UCPU1.AK61 52.65,65.74 v6(52.65,65.48)
DDR_B_DQS#0: length 60
  IN4 w0.071: v7(60.42,36.47) 60.68,36.73 60.99,36.73 61.82,37.55 62.6,37.55 63.19,38.15 63.19,40.11 62.94,40.37 62.94,41.96 63.97,42.99 65.05,42.99 66.37,44.31 73.48,44.31 73.69,44.53 74.43,44.53 74.99,45.08 74.99,45.47 75.01,45.5 78.06,48.54 78.26,48.54 78.53,48.27 78.53,48.07 75.66,45.2 75.66,44.88 76.01,44.53 76.32,44.53 80.46,48.67 81.73,48.67 84.76,51.7 84.76,63.35 83.28,64.83 81.86,64.83 v5(81.73,64.96)
  GND5 w0.076: v5(81.73,64.96) 81.65,64.88 81.1,64.88 v6(81.07,64.91)
  BOTTOM w0.114: UCPU1.AL3 81.38,65.05 81.24,64.91 v6(81.07,64.91)
  BOTTOM w0.127: v7(60.42,36.47) 60.03,36.08 UD9.D3
DDR_B_DQS#1: length 42.4
  TOP w0.076: UD10.D3 56.82,36.18 57.04,36.4 57.2,36.4 57.75,36.96 57.75,38.02 v10(57.82,38.09)
  IN4 w0.071: v5(81.65,60.63) 81.72,60.7 81.72,60.77 81.64,60.85 81.44,60.85 81.31,60.71 81.31,60.52 81.6,60.22 81.6,59.37 81.57,59.33 81.57,57.13 80.33,55.89 80.33,54.37 79.97,54.01 79.38,54.01 74.42,49.05 73.14,49.05 71.65,47.56 65.64,47.56 63.96,45.87 62.88,45.87 59.7,42.69 59.7,42.08 58.06,40.44 57.83,40.44 57.56,40.17 57.56,38.27 57.74,38.09 v10(57.82,38.09)
  GND5 w0.076: v5(81.65,60.63) 81.39,60.89 v6(81.25,60.89)
  BOTTOM w0.114: v6(81.25,60.89) 81.38,61.02 UCPU1.AV3
DDR_B_DQS#2: length 45.8
  IN4 w0.071: v5(77.48,57.3) 77.36,57.42 77.2,57.42 77.12,57.34 77.12,56.23 74.31,53.43 73.12,53.43 70.36,50.66 63.28,50.66 61.04,48.41 59.54,48.41 57.77,46.64 57.77,46.16 57.45,45.85 56.97,45.85 56.84,45.71 56.84,45.55 57.35,45.04 57.35,44.72 57,44.38 56.69,44.38 56.19,44.88 55.99,44.88 55.71,44.6 55.71,44.4 56.11,44.01 56.11,43.69 55.76,43.34 55.45,43.34 55.1,43.69 54.9,43.69 54.63,43.42 54.63,43.22 55.01,42.84 55.01,42.57 52.99,40.56 52.99,40.17 52.45,39.62 52.14,39.62 51.95,39.81 51.95,40.04 51.81,40.18 51.43,40.18 51.29,40.04 51.29,39.49 51.04,39.25 50.56,39.25 50.43,39.11 50.43,37.08 50.19,36.85 49.74,36.85 v7(49.37,36.47)
  GND5 w0.076: v5(77.48,57.3) 77.59,57.42 77.78,57.42 v6(77.9,57.3)
  BOTTOM w0.114: v6(77.9,57.3) 77.61,57.3 UCPU1.BG11
  BOTTOM w0.127: UD11.D3 48.98,36.08 v7(49.37,36.47)
DDR_B_DQS#3: length 45
  TOP w0.076: v10(46.77,38.09) 46.71,38.02 46.71,36.96 46.15,36.4 45.99,36.4 45.78,36.18 UD12.D3
  IN4 w0.071: v10(46.77,38.09) 46.59,38.26 46.59,39.52 54.07,47 54.07,47.57 58.17,51.67 58.17,52.39 58.41,52.63 58.41,53.16 59.3,54.04 60.05,54.04 60.19,53.89 60.19,53.77 60.39,53.57 60.95,53.57 61.14,53.77 61.14,53.92 61.26,54.04 61.7,54.04 61.82,53.92 61.82,53.56 62.02,53.37 62.57,53.37 62.77,53.56 62.77,53.92 62.89,54.04 63.31,54.04 63.43,53.92 63.43,53.56 63.63,53.37 64.17,53.37 64.37,53.56 64.37,53.92 64.49,54.04 64.6,54.04 65,54.43 69.88,54.43 71.47,56.02 73.23,56.02 74,56.79 74,58.24 v5(74.14,58.38)
  GND5 w0.076: v5(74.14,58.38) 74.01,58.51 74.01,58.79 74.14,58.92 v6(74.14,58.96)
  BOTTOM w0.114: UCPU1.BD17 74.27,58.54 74.1,58.71 74.1,58.92 v6(74.14,58.96)
DDR_B_DQS#4: length 40
  IN4 w0.071: v5(57.72,57.25) 57.72,57.26 57.6,57.38 57.51,57.38 56.89,56.77 56.89,56.47 49.05,48.63 49.05,48.05 49.59,47.51 49.59,47.23 49.21,46.85 48.93,46.85 48.69,47.1 48.53,47.1 48.22,46.79 48.22,46.63 48.47,46.39 48.47,46.11 48.08,45.72 47.8,45.72 47.07,46.46 46.9,46.46 46.59,46.15 46.59,45.99 47.33,45.25 47.33,44.97 46.94,44.58 46.66,44.58 45.94,45.31 45.77,45.31 45.46,45 45.46,44.83 45.63,44.67 45.63,44.39 45.24,44 44.96,44 44.78,44.18 44.61,44.18 44.32,43.89 44.32,43.69 44.51,43.5 44.51,42.98 44.07,42.53 42.96,42.53 39.42,38.98 39.42,38.69 39.68,38.42 39.68,37.97 39.42,37.7 39.42,37.47 39.73,37.15 39.73,36.49 39.38,36.14 39.03,36.14 38.82,36.36 38.82,36.73 38.73,36.82 38.39,36.82 38.32,36.75 v7(38.32,36.47)
  GND5 w0.076: v5(57.72,57.25) 57.84,57.38 58.03,57.38 58.12,57.28 v6(58.14,57.28)
  BOTTOM w0.114: v6(58.14,57.28) 58.09,57.33 57.88,57.33 UCPU1.BG51
  BOTTOM w0.127: v7(38.32,36.47) 37.93,36.08 UD13.D3
DDR_B_DQS#5: length 33.9
  TOP w0.076: UD14.D3 34.73,36.18 34.95,36.4 35.1,36.4 35.66,36.96 35.66,38.02 v10(35.72,38.09)
  IN4 w0.071: v10(35.72,38.09) 35.62,38.09 35.48,38.23 35.48,38.46 35.24,38.7 35.24,38.82 41.31,44.89 41.64,44.89 42.45,45.71 42.45,46.38 49.04,52.97 49.04,54.26 52.54,57.76 52.88,57.76 53.06,57.58 53.5,57.58 53.76,57.84 53.76,58.61 53.52,58.84 53.36,58.84 53.26,58.94 53.26,59.15 v5(53.38,59.27)
  GND5 w0.076: v6(53.49,59.69) 53.28,59.49 53.28,59.37 v5(53.38,59.27)
  BOTTOM w0.114: UCPU1.BA59 53.2,59.98 v6(53.49,59.69)
