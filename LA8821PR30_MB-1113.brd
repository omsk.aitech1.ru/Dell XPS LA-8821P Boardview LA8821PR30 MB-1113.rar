# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CKE0: length 187.8
  TOP w0.076: UD8.G9 76.73,28.99 76.16,28.99 75.92,29.23 75.92,29.46 75.56,29.82 75.46,29.82 75.39,29.89 74.86,30.42 74.61,30.42 74.6,30.42 74.24,30.42 73.84,30.02 73.78,30.02 73.78,30.02 v10(73.78,30.02) ; v10(106.92,30.02) 106.92,30.02 106.98,30.02 107.38,30.42 107.75,30.42 107.75,30.42 108.01,30.42 108.35,30.07 108.54,29.89 108.54,29.89 108.6,29.82 108.7,29.82 109.06,29.46 109.06,29.23 109.3,28.99 109.87,28.99 UD2.G9 ; UD4.G9 98.82,28.99 98.25,28.99 98.02,29.23 98.02,29.46 97.65,29.82 97.56,29.82 97.49,29.89 96.96,30.42 96.7,30.42 96.7,30.42 96.34,30.42 95.93,30.02 95.87,30.02 95.87,30.02 v10(95.88,30.02) ; UD6.G9 87.77,28.99 87.21,28.99 86.97,29.23 86.97,29.46 86.61,29.82 86.51,29.82 86.44,29.89 86.44,29.89 86.26,30.07 85.91,30.42 85.66,30.42 85.65,30.42 85.29,30.42 84.89,30.02 84.83,30.02 v10(84.83,30.02)
  TOP w0.188: R1068.1 v2(117.66,35.14)
  GND1 w0.102: v2(117.66,35.14) 117.56,35.14 v3(117.28,34.86)
  IN1 w0.147: v4(116.9,34.38) 116.9,34.48 v3(117.28,34.86)
  IN3 w0.14: v4(69.98,32.45) 69.98,32.64 70.2,32.85 70.49,32.85 70.67,32.67 70.67,31.18 70.8,31.05 71.25,31.05 71.38,31.18 71.38,32.42 71.57,32.61 72.08,32.61 72.24,32.78 72.24,33.25 72.5,33.51 72.5,33.83 72.63,33.95 73.44,33.95 73.57,33.83 73.57,33.41 73.85,33.13 74.48,33.13 74.61,33.25 74.61,34.02 74.73,34.15 75.32,34.15 75.45,34.02 75.45,33.59 75.57,33.46 77.04,33.46 77.17,33.59 77.17,33.82 77.4,34.06 77.4,34.36 77.73,34.68 77.73,35.19 78.14,35.6 78.14,35.7 78.28,35.84 78.56,35.84 78.7,35.98 78.7,36.25 78.56,36.39 78.28,36.39 78.14,36.53 78.14,36.83 78.28,36.97 78.88,36.97 79.03,37.12 79.03,38.56 78.9,38.69 78.65,38.69 78.21,39.13 78.21,41.09 77.8,41.49 77.8,42.66 77.8,42.67 77.8,43.11 78.12,43.43 78.64,43.43 79.15,42.92 80.15,42.92 80.29,42.78 80.29,42.48 80.15,42.33 79.71,42.33 79.56,42.18 79.56,40.6 79.71,40.45 80,40.45 80.14,40.59 80.14,41.67 80.29,41.82 80.53,41.82 80.73,41.61 81.17,41.61 81.31,41.47 81.31,41.2 81.17,41.06 80.85,41.06 80.7,40.91 80.7,40.59 80.84,40.45 81.8,40.45 81.94,40.31 81.94,40.18 82.08,40.04 82.36,40.04 82.5,40.18 82.5,40.31 82.64,40.45 83.55,40.45 83.65,40.55 83.65,42.94 83.52,43.07 83.24,43.07 83.11,43.19 83.11,43.47 83.24,43.6 83.52,43.6 83.65,43.73 83.65,46.01 83.55,46.11 83.3,46.11 83.17,46.24 83.17,47.3 81.03,49.44 81.03,49.49 80.73,49.8 80.19,49.8 79.2,50.79 79.2,51.42 79.41,51.63 79.41,51.99 73.49,57.9 72.68,57.9 71.33,59.25 71.33,59.65 71.02,59.96 70.2,59.96 70.19,59.97 69.22,59.97 69.1,60.1 69.1,60.72 69.22,60.85 v4(69.49,60.85)
  IN4 w0.104: v4(69.98,32.45) 69.71,32.45 69.55,32.29 69.55,31.29 69.45,31.19 69.27,31.19 69.14,31.06 69.14,30.31 68.99,30.16 68.68,30.16 68.54,30.31 68.54,30.93 68.39,31.08 68.05,31.08 67.9,30.93 67.9,29.75 68.05,29.6 69.12,29.6 69.43,29.3 70.58,29.3 70.89,29.6 72.31,29.6 72.51,29.8 73.56,29.8 v10(73.78,30.02) 73.78,29.99 74.26,29.51 74.53,29.51 74.75,29.73 75.17,29.73 75.97,28.93 78.5,28.93 79.13,29.56 79.13,31.64 79.26,31.76 79.59,31.76 79.71,31.64 79.71,30.23 79.91,30.03 80.24,30.03 81.09,29.19 81.55,29.19 82.17,29.81 84.61,29.81 v10(84.83,30.02) 84.83,29.99 85.35,29.46 86.04,29.46 86.31,29.73 86.89,29.73 87.24,30.08 87.45,30.08 88.25,30.88 88.25,32.35 88.45,32.55 89.24,32.55 89.44,32.75 89.44,33.82 88.78,34.48 88.78,34.68 88.96,34.86 90.99,34.86 91.22,34.63 91.22,32.55 91.57,32.19 91.57,31.64 91.86,31.35 91.86,29.45 92.12,29.19 92.6,29.19 93.19,29.78 94.36,29.78 94.36,29.78 95.64,29.78 v10(95.88,30.02) 95.88,29.98 96.35,29.5 97.39,29.5 97.96,28.93 98.26,28.93 98.4,29.08 98.4,29.35 98.53,29.48 98.87,29.48 98.99,29.35 98.99,29.08 99.14,28.93 100.6,28.93 101.23,29.56 101.23,30.87 101.35,31 101.75,31 101.88,30.87 101.88,30.16 102,30.03 102.46,30.03 103.31,29.19 103.64,29.19 104.14,29.68 105.49,29.68 105.63,29.83 106.73,29.83 v10(106.92,30.02) 106.92,29.98 107.37,29.53 107.82,29.53 108.01,29.72 108.75,29.72 110.29,31.25 110.29,31.56 111.13,32.4 114.36,32.4 116.34,34.38 v4(116.9,34.38) ; v5(70.31,60.95) 70.31,60.93 70.24,60.85 v4(69.49,60.85)
  GND5 w0.102: v6(69.97,60.69) 70.06,60.69 v5(70.31,60.95)
  BOTTOM w0.076: v10(73.78,30.02) 73.56,29.8 72.12,29.8 71.86,29.54 71.86,28.38 71.6,28.12 71.29,28.12 71.14,28.27 71.14,28.53 71.07,28.6 UD7.G9 ; UCPU1.AY26 v6(69.97,60.69) ; UD1.G9 103.87,28.6 104.22,28.6 104.29,28.53 104.29,28.27 104.44,28.12 104.75,28.12 105.01,28.38 105.01,29.54 105.26,29.8 106.7,29.8 v10(106.92,30.02) ; v10(95.88,30.02) 95.65,29.8 94.22,29.8 93.96,29.54 93.96,28.38 93.7,28.12 93.39,28.12 93.24,28.27 93.24,28.53 93.17,28.6 UD3.G9 ; v10(84.83,30.02) 84.61,29.8 83.17,29.8 82.91,29.54 82.91,28.38 82.65,28.12 82.34,28.12 82.19,28.27 82.19,28.53 82.12,28.6 81.77,28.6 UD5.G9
DDR_A_CS0#: length 179.5
  TOP w0.076: v10(96.48,29.98) 96.1,29.6 95.79,29.6 95.18,28.99 95.15,28.99 94.91,28.75 94.91,28.4 94.89,28.39 94.9,28.38 94.63,28.11 94.15,28.11 93.83,27.8 93.62,27.8 UD4.H2 ; v10(74.38,29.98) 74,29.6 73.69,29.6 73.08,28.99 73.05,28.99 72.81,28.75 72.81,28.4 72.8,28.39 72.8,28.38 72.53,28.11 72.05,28.11 71.74,27.8 71.52,27.8 UD8.H2 ; UD6.H2 82.57,27.8 82.79,27.8 83.1,28.11 83.58,28.11 83.85,28.38 83.84,28.39 83.86,28.4 83.86,28.75 84.1,28.99 84.13,28.99 84.74,29.6 85.05,29.6 v10(85.43,29.98) ; UD2.H2 104.67,27.8 104.88,27.8 105.19,28.11 105.68,28.11 105.95,28.38 105.94,28.39 105.95,28.4 105.95,28.75 106.2,28.99 106.23,28.99 106.84,29.6 107.14,29.6 v10(107.53,29.98)
  TOP w0.188: R1072.1 v2(115.88,35.04)
  GND1 w0.102: v2(115.88,35.04) 115.5,35.04 v3(115.48,35.06)
  IN1 w0.147: v3(115.48,35.06) 115.07,35.06 v4(114.97,35.17)
  IN3 w0.14: v8(70.94,37.15) 71.06,37.15 71.46,37.55 71.46,38.09 70.94,38.6 70.94,39.12 71.46,39.64 71.46,40.02 71.2,40.28 71.2,40.89 71.2,41.62 71,41.82 71,42.78 71.24,43.02 71.24,43.3 71.1,43.44 70.56,43.44 70.42,43.58 70.42,43.86 70.56,44 71.1,44 71.24,44.14 71.24,44.43 71.1,44.57 69.9,44.57 69.81,44.66 69.76,44.72 69.76,44.98 69.9,45.13 71.1,45.13 71.24,45.27 71.24,45.56 71.09,45.71 69.27,45.71 69.13,45.57 69.13,44.79 69,44.66 68.7,44.66 68.57,44.79 68.57,45.57 68.43,45.71 68.07,45.71 67.93,45.85 67.93,46.11 68.07,46.25 71.11,46.25 71.24,46.39 71.24,50.93 70.82,51.35 68.07,51.35 68.07,51.35 67.79,51.35 67.79,51.35 65.77,51.35 65.76,51.35 65.51,51.35 65.5,51.35 63.37,51.35 63.25,51.47 63.25,52.83 63.25,54.2 63.25,54.21 63.25,54.65 63.25,55.36 63.35,55.46 63.96,55.46 64.49,55.98 64.49,58.79 64.34,58.94 63.25,58.94 63.1,59.09 63.1,59.24 63.71,59.85 v4(63.71,60.01)
  IN4 w0.104: v4(63.71,60.01) 63.22,59.52 v5(63.18,59.52) ; v4(114.97,35.17) 114.66,34.86 110.06,34.86 109.56,34.35 109.56,31.25 108.64,30.34 107.88,30.34 v10(107.53,29.98) 107.53,30.09 107.2,30.41 107.07,30.41 107.05,30.44 107,30.44 106.33,30.44 106.02,30.13 104.11,30.13 103.74,30.49 103.74,31 103.41,31.33 103,31.33 102.7,31.64 101.38,31.64 100.8,31.06 100.8,29.66 100.47,29.32 99.45,29.32 98.91,29.86 98.91,30.14 98.79,30.26 98.48,30.26 98.36,30.14 98.36,29.73 98.23,29.6 97.89,29.6 97.77,29.73 97.77,30.12 97.62,30.26 97.01,30.26 96.73,29.98 v10(96.48,29.98) 96.48,30.06 96.18,30.36 96.13,30.36 96.07,30.42 96.01,30.42 96,30.44 95.28,30.44 94.94,30.09 93.07,30.09 92.77,30.39 92.77,34.43 91.73,35.47 88.3,35.47 87.71,34.89 87.71,33.63 87.95,33.39 87.95,31.02 87.31,30.38 87.12,30.38 86.94,30.2 86.24,30.2 86.02,29.98 v10(85.43,29.98) 85.43,30.06 85.13,30.36 85.08,30.36 85.02,30.42 84.96,30.42 84.95,30.44 84.24,30.44 83.91,30.11 81.95,30.11 81.64,30.42 81.64,31.03 81.35,31.33 80.91,31.33 80.12,32.12 80.12,32.78 79.92,32.98 79.31,32.98 78.72,32.4 78.72,29.6 78.43,29.31 76.08,29.31 75.28,30.12 74.52,30.12 v10(74.38,29.98) 74.38,30.06 74.08,30.36 74.03,30.36 73.97,30.42 73.91,30.42 73.9,30.44 73.25,30.44 72.98,30.16 70.91,30.16 70.62,30.45 70.62,31.03 70.77,31.18 71.28,31.18 71.43,31.33 71.43,31.62 71.28,31.77 70.77,31.77 70.64,31.9 70.64,32.25 70.77,32.37 71.41,32.37 72.65,33.62 73.59,33.62 73.72,33.74 73.72,34.1 73.57,34.25 72.09,34.25 71.94,34.4 71.94,34.69 72.09,34.84 74.25,34.84 74.4,34.69 74.4,34.3 74.54,34.15 74.84,34.15 74.99,34.3 74.99,34.69 75.13,34.84 75.48,34.84 75.62,34.69 75.62,34.35 75.77,34.2 76.16,34.2 76.28,34.33 76.28,35.33 76.18,35.44 73.09,35.44 72.95,35.58 72.95,35.85 72.28,36.52 71.73,36.52 71.58,36.37 71.58,36.15 71.44,36 70.97,36 69.63,34.66 69.24,34.66 68.42,33.84 68.21,33.84 67.88,34.17 67.88,34.4 68.57,35.09 69.22,35.09 70.94,36.81 v8(70.94,37.15)
  GND5 w0.102: v6(63.62,59.52) 63.46,59.52 63.46,59.52 v5(63.18,59.52)
  BOTTOM w0.076: v10(107.53,29.98) 107.64,29.87 107.64,29.12 108.15,28.6 108.15,28.27 108.27,28.16 108.42,28.16 108.46,28.11 108.54,28.11 108.54,28.11 108.8,28.11 109.16,28.11 UD1.H2 ; UD3.H2 98.11,28.11 97.75,28.11 97.41,28.11 97.37,28.16 97.22,28.16 97.1,28.27 97.1,28.6 96.59,29.12 96.59,29.87 v10(96.48,29.98) ; UD5.H2 87.06,28.11 86.7,28.11 86.44,28.11 86.44,28.11 86.37,28.11 86.32,28.16 86.17,28.16 86.05,28.27 86.05,28.6 85.54,29.12 85.54,29.87 v10(85.43,29.98) ; UD7.H2 76.01,28.11 75.65,28.11 75.32,28.11 75.27,28.16 75.12,28.16 75,28.27 75,28.6 74.49,29.12 74.49,29.87 v10(74.38,29.98)
  BOTTOM w0.188: UCPU1.BB40 v6(63.62,59.52)
DDR_A_D0: length 67.1
  IN1 w0.071: v4(79.8,67.39) 79.9,67.3 80.75,67.3 86.21,61.84 86.21,58.67 90.36,54.52 90.77,54.52 93.3,52 94.35,52 98.96,47.39 99.25,47.39 99.74,46.9 101.76,46.9 107.78,40.88 107.78,40.69 112.35,36.12 112.35,30.24 111.21,29.1 110.09,29.1 108.21,27.22 106.22,27.22 105.96,27.47 105.96,27.94 104.56,29.34 104.44,29.46 104.05,29.86 104.05,30.37 v10(104.27,30.59)
  IN4 w0.084: v5(79.76,66.87) 79.8,66.91 v4(79.8,67.39)
  GND5 w0.104: v6(80.16,67.01) 79.9,67.01 v5(79.76,66.87)
  BOTTOM w0.104: UD1.E8 104.67,30.2 v10(104.27,30.59)
  BOTTOM w0.122: UCPU1.AG6 79.83,67.33 v6(80.16,67.01)
DDR_A_D1: length 67.3
  IN1 w0.071: v10(105.06,32.2) 105.14,32.28 105.14,33.06 105.04,33.16 104.76,33.16 104.66,33.06 104.66,32.63 104.53,32.5 104.2,32.5 104.09,32.39 104.09,31.18 104.19,31.08 104.5,31.08 104.63,31.21 104.63,31.66 104.73,31.76 105.24,31.76 105.47,31.53 105.47,30.37 105.6,30.24 106.02,30.24 106.03,30.24 106.08,30.24 106.28,30.44 107.86,30.44 107.96,30.34 107.96,29.96 108.06,29.86 109.9,29.86 110.78,30.73 110.98,30.73 111.63,31.38 111.63,35.83 107.07,40.4 107.07,40.59 101.47,46.19 99.45,46.19 98.96,46.68 98.67,46.68 94.06,51.29 93,51.29 90.48,53.82 90.12,53.82 85.51,58.43 85.51,61.54 80.65,66.4 v4(79.88,66.4)
  IN4 w0.084: v4(79.88,66.4) 79.88,66.01 v5(80.02,65.87)
  GND5 w0.104: v5(80.02,65.87) 79.93,65.87 79.84,65.97 v6(79.58,65.97)
  BOTTOM w0.104: UD1.C7 105.46,31.8 v10(105.06,32.2)
  BOTTOM w0.122: UCPU1.AJ6 79.83,66.22 v6(79.58,65.97)
DDR_A_D2: length 70
  IN1 w0.071: v10(108.28,32.99) 108.04,32.99 107.91,32.85 107.91,32.45 107.72,32.26 107.72,31.86 107.47,31.62 107.47,31.46 107.57,31.36 107.93,31.36 108.19,31.11 108.19,30.19 108.29,30.09 109.71,30.09 109.81,30.19 109.81,30.57 109.71,30.67 108.76,30.67 108.66,30.77 108.66,31.29 108.21,31.74 108.21,32.19 108.69,32.68 108.69,33.14 108.92,33.36 108.92,33.98 108.81,34.09 108.81,34.24 108.92,34.35 108.92,34.46 108.72,34.67 108.6,34.67 108.49,34.56 108.34,34.56 108.12,34.78 108.12,34.9 108.25,35.02 108.25,35.14 107.98,35.41 107.86,35.41 107.81,35.36 107.69,35.36 107.51,35.53 107.51,35.65 107.57,35.71 107.57,35.82 107.38,36.01 107.27,36.01 107.22,35.95 107.1,35.95 106.92,36.13 106.92,36.24 106.97,36.3 106.97,36.41 106.79,36.59 106.67,36.59 106.61,36.54 106.5,36.54 106.33,36.71 106.33,36.82 106.38,36.88 106.38,36.99 106.21,37.17 106.09,37.17 106.04,37.12 105.92,37.12 105.74,37.3 105.74,37.42 105.79,37.47 105.79,37.59 105.61,37.76 105.49,37.76 105.44,37.71 105.32,37.71 105.15,37.89 105.15,38.01 105.21,38.07 105.21,38.18 105.02,38.37 104.91,38.37 104.87,38.37 104.81,38.31 104.73,38.31 104.58,38.31 104.48,38.41 104.48,38.52 104.38,38.62 103.38,38.62 103.26,38.75 103.03,38.75 102.91,38.62 102.7,38.62 102.37,38.96 102.37,39.23 102.18,39.42 101.91,39.42 101.71,39.62 101.71,40.03 101.27,40.48 101.27,40.77 101.06,40.97 100.77,40.97 100.11,41.64 100.11,41.92 99.94,42.09 99.66,42.09 98.95,42.79 98.95,43.08 98.76,43.27 98.48,43.27 97.68,44.06 97.68,44.35 97.53,44.5 97.24,44.5 96.54,45.2 96.54,45.49 96.39,45.65 96.1,45.65 94.95,46.79 94.95,46.95 95.05,47.05 95.05,47.19 94.91,47.32 94.77,47.32 94.48,47.03 94.35,47.03 94.16,47.22 94.16,47.31 94.28,47.43 94.28,47.57 94.13,47.72 93.99,47.72 93.89,47.61 93.77,47.61 93.6,47.78 93.6,47.92 93.68,48 93.68,48.2 93.56,48.33 93.42,48.33 93.36,48.27 93.29,48.21 93.18,48.21 93,48.38 93,48.5 93.27,48.77 93.27,48.92 93.11,49.07 92.97,49.07 92.7,48.8 92.58,48.8 83.04,58.34 83.04,59.08 83.22,59.26 83.22,59.51 83.04,59.69 83.04,60.88 82.74,61.18 82.74,61.3 82.85,61.41 82.85,61.53 82.68,61.7 82.55,61.7 82.45,61.6 82.33,61.6 82.15,61.77 82.15,61.89 82.24,61.98 82.24,62.13 82.09,62.28 81.94,62.28 81.85,62.19 81.73,62.19 81.56,62.37 81.56,62.49 81.67,62.6 81.67,62.74 81.52,62.89 81.37,62.89 81.26,62.78 81.14,62.78 80.98,62.94 80.98,63.05 81.11,63.18 81.11,63.41 80.14,64.38 79.7,64.38 79.59,64.27 79.48,64.27 79.37,64.38 79.09,64.38 78.98,64.27 78.76,64.27 78.66,64.38 78.17,64.38 78.09,64.3 78.09,63.89 77.99,63.79 77.76,63.79 77.65,63.89 77.65,64.58 77.55,64.68 76.96,64.68 76.86,64.58 76.86,63.99 76.96,63.88 v4(77.2,63.88)
  IN4 w0.084: v5(77.6,63.61) 77.33,63.88 v4(77.2,63.88)
  GND5 w0.104: v5(77.6,63.61) 77.6,63.8 77.2,64.21 v6(77.2,64.39)
  BOTTOM w0.104: UD1.B3 v10(108.28,32.99)
  BOTTOM w0.122: v6(77.2,64.39) UCPU1.AP11
DDR_A_D3: length 67.4
  IN1 w0.071: v10(111.21,31.84) 111.26,31.84 111.36,31.94 111.36,32.65 111.26,32.75 110.8,32.75 110.29,33.26 110.29,33.79 110.14,33.95 110.14,34.91 109.99,35.06 109.99,35.23 110.55,35.78 110.55,35.89 110.36,36.08 110.25,36.08 109.67,35.5 109.55,35.5 108.68,36.37 108.68,36.49 109.24,37.04 109.24,37.18 109.08,37.34 108.94,37.34 108.38,36.78 108.27,36.78 107.4,37.66 107.4,37.78 107.94,38.32 107.94,38.46 107.79,38.61 107.64,38.61 107.11,38.08 106.97,38.08 106.11,38.94 106.11,39.09 106.64,39.62 106.64,39.76 106.49,39.91 106.34,39.91 105.83,39.4 105.66,39.4 105.25,39.8 104.84,39.8 104.63,40.02 104.63,40.43 104.36,40.69 104.21,40.85 104.21,40.97 104.86,41.62 104.86,41.74 104.68,41.92 104.57,41.92 103.91,41.26 103.79,41.26 102.92,42.13 102.92,42.25 103.57,42.89 103.57,43.04 103.41,43.19 103.27,43.19 102.63,42.55 102.51,42.55 102.33,42.73 102.33,42.84 103,43.51 103,43.62 102.81,43.81 102.7,43.81 102.03,43.14 101.91,43.14 100.08,44.98 99.37,44.98 99.21,45.14 99.21,45.43 98.66,45.97 98.37,45.97 93.76,50.58 92.71,50.58 90.18,53.11 90.14,53.11 89.88,53.11 84.8,58.19 84.8,61.25 80.64,65.41 v4(79.8,65.41)
  IN4 w0.084: v4(79.8,65.41) 79.71,65.32 v5(79.71,64.53)
  GND5 w0.104: v5(79.71,64.53) 79.71,64.83 v6(79.8,64.93)
  BOTTOM w0.104: UD1.E3 109.06,30.59 110.83,30.59 110.96,30.73 110.97,30.73 111.2,30.96 111.2,30.96 111.21,30.98 v10(111.21,31.84)
  BOTTOM w0.122: v6(79.8,64.93) 79.88,65.01 UCPU1.AL6
DDR_A_D4: length 68.5
  IN1 w0.071: v10(105.06,31.38) 104.68,30.99 104.68,29.73 106.35,28.05 108.26,28.05 109.58,29.38 110.8,29.38 112.1,30.68 112.1,36.03 107.54,40.59 107.54,40.78 101.66,46.66 99.64,46.66 99.15,47.15 98.86,47.15 94.25,51.76 93.2,51.76 90.67,54.29 90.28,54.29 85.98,58.59 85.98,61.74 80.76,66.96 78.82,66.96 78.65,67.14 78.34,67.14 78.12,66.92 78.12,66.6 78.58,66.14 v4(78.58,65.96)
  IN4 w0.084: v5(78.14,65.6) 78.22,65.6 v4(78.58,65.96)
  GND5 w0.104: v5(78.14,65.6) 78.14,65.95 v6(78.2,66.02)
  BOTTOM w0.104: v10(105.06,31.38) 104.67,31.77 UD1.C8
  BOTTOM w0.122: v6(78.2,66.02) 77.88,66.34 UCPU1.AJ10
DDR_A_D5: length 68.2
  IN1 w0.071: v4(78.49,66.76) 78.5,66.77 80.61,66.77 85.74,61.64 85.74,58.51 90.2,54.05 90.58,54.05 93.1,51.53 94.16,51.53 98.77,46.92 99.06,46.92 99.55,46.43 101.57,46.43 107.31,40.69 107.31,40.49 111.87,35.93 111.87,31.28 111.08,30.49 110.8,30.49 109.91,29.6 108.84,29.6 108.75,29.51 108.75,28.99 108.65,28.89 108.43,28.89 108.33,28.99 108.33,29.5 108.23,29.6 108.02,29.6 107.91,29.5 107.91,28.94 107.81,28.84 107.6,28.84 107.49,28.94 107.49,29.51 107.41,29.6 106.76,29.6 106.67,29.51 106.67,29.08 106.59,28.99 106.34,28.99 106.25,29.08 106.25,29.88 106.15,29.98 105.93,29.98 105.82,29.88 105.82,29.2 105.72,29.1 105.57,29.1 105.37,29.3 105.37,29.53 105.26,29.63 105.16,29.63 105.06,29.73 v10(105.06,30.59)
  IN4 w0.084: v5(78.16,67.14) 78.16,67.09 v4(78.49,66.76)
  GND5 w0.104: v6(78.16,66.71) v5(78.16,67.14)
  BOTTOM w0.104: v10(105.06,30.59) 105.46,30.2 UD1.E7
  BOTTOM w0.122: UCPU1.AJ8 v6(78.16,66.71)
DDR_A_D6: length 68
  IN1 w0.071: v4(78.65,65.39) 79.24,65.99 80.73,65.99 85.27,61.44 85.27,58.35 90.04,53.58 90.38,53.58 92.9,51.06 93.96,51.06 98.57,46.44 98.86,46.44 99.39,45.91 99.66,45.91 99.74,45.83 99.74,45.56 99.83,45.48 100.08,45.48 100.16,45.56 100.16,45.83 100.24,45.91 100.56,45.91 100.64,45.83 100.64,45.77 100.73,45.68 100.98,45.68 101.06,45.77 101.06,45.83 101.15,45.91 101.41,45.91 102.34,44.98 102.34,44.77 101.75,44.18 101.75,44.06 101.95,43.85 102.08,43.85 102.68,44.45 102.84,44.45 104.25,43.04 104.25,42.89 103.61,42.25 103.61,42.12 103.78,41.94 103.92,41.94 104.54,42.56 104.73,42.56 106.15,41.14 106.15,41.01 105.55,40.41 105.55,40.26 105.71,40.1 105.86,40.1 106.43,40.68 106.61,40.68 106.81,40.47 106.81,40.3 107.37,39.74 107.37,39.6 106.82,39.06 106.82,38.91 106.98,38.76 107.12,38.76 107.67,39.31 107.81,39.31 108.66,38.47 108.66,38.32 108.11,37.77 108.11,37.63 108.26,37.48 108.4,37.48 108.92,38 109.09,38 109.91,37.17 109.91,37.03 109.37,36.49 109.37,36.35 109.53,36.19 109.67,36.19 110.02,36.55 110.02,36.55 110.22,36.75 110.37,36.75 111.21,35.9 111.21,35.76 110.69,35.23 110.69,35.09 110.79,34.99 111.03,34.99 111.21,35.17 111.34,35.17 111.4,35.11 111.4,33.34 111.28,33.22 v10(111.02,33.22)
  IN4 w0.084: v5(78.71,64.45) 78.71,65.33 v4(78.65,65.39)
  GND5 w0.104: v5(78.71,64.45) 78.71,64.73 v6(78.58,64.85)
  BOTTOM w0.104: v10(111.02,33.22) 110.8,33 110.8,32.07 110.62,31.89 110.62,31.69 110.39,31.45 110.24,31.45 109.79,31 UD1.D2
  BOTTOM w0.122: UCPU1.AL8 v6(78.58,64.85)
DDR_A_D7: length 67.9
  IN1 w0.071: v4(79.23,65.38) 79.64,65.79 80.59,65.79 80.74,65.64 85.03,61.35 85.03,58.27 89.96,53.34 90.28,53.34 92.81,50.82 93.86,50.82 98.47,46.21 98.76,46.21 99.44,45.53 99.44,45.36 99.59,45.21 100.26,45.21 100.33,45.15 100.45,45.15 100.73,45.43 100.85,45.43 101.02,45.25 101.02,45.13 100.74,44.85 100.74,44.73 100.93,44.55 101.04,44.55 101.67,45.17 101.79,45.17 101.97,44.99 101.97,44.88 101.34,44.25 101.34,44.13 101.96,43.51 102.07,43.51 102.7,44.14 102.81,44.14 103.93,43.02 103.93,42.91 103.27,42.25 103.27,42.11 103.78,41.61 103.92,41.61 104.55,42.24 104.69,42.24 105.21,41.73 105.21,41.58 104.61,40.98 104.61,40.87 104.79,40.69 104.9,40.69 105.52,41.3 105.63,41.3 105.81,41.12 105.81,41 105.2,40.39 105.2,40.27 105.52,39.95 105.52,39.87 105.68,39.71 105.81,39.71 106.35,40.25 106.5,40.25 107.01,39.74 107.01,39.6 106.47,39.06 106.47,38.92 106.97,38.42 107.11,38.42 107.65,38.96 107.8,38.96 108.3,38.45 108.3,38.31 107.74,37.74 107.74,37.65 108.27,37.12 108.38,37.12 108.5,37.24 108.72,37.46 108.95,37.69 109.06,37.69 109.59,37.16 109.59,37.05 109.04,36.49 109.04,36.35 109.14,36.25 109.5,35.89 109.53,35.86 109.67,35.86 110.12,36.31 110.12,36.31 110.23,36.42 110.36,36.42 110.88,35.9 110.88,35.76 110.46,35.33 110.46,35.33 110.45,35.32 110.45,34.81 110.52,34.74 110.82,34.74 111.03,34.53 111.03,34.1 v10(110.73,33.79)
  IN4 w0.084: v5(79.23,64.48) v4(79.23,65.38)
  GND5 w0.104: v6(79.23,64.9) v5(79.23,64.48)
  BOTTOM w0.104: v10(110.73,33.79) 110.62,33.69 110.62,33.39 110.59,33.36 110.59,33.27 110.45,33.12 110.45,32.88 110.59,32.74 110.59,32.47 110.45,32.32 110.45,32.27 110.39,32.21 109.88,32.21 109.47,31.8 UD1.C2
  BOTTOM w0.122: UCPU1.AL7 v6(79.23,64.9)
DDR_A_D8: length 52.6
  TOP w0.076: UD2.E8 109.47,30.2 109.11,30.2 108.72,30.59 108.63,30.59 108.54,30.69 108.54,30.69 108.35,30.88 108.35,31.54 107.37,32.52 107.37,32.54 v10(107.24,32.68)
  IN1 w0.071: v4(77.21,63.12) 77.63,63.54 78.86,63.54 79.03,63.37 80.01,63.37 80.3,63.08 80.3,62.62 82.33,60.59 82.33,58.05 94.14,46.24 94.5,46.24 98.77,41.97 98.77,41.79 99.36,41.2 99.36,41.19 99.88,40.68 99.88,40.32 99.96,40.25 100.31,40.25 100.75,39.81 100.76,39.81 100.99,39.57 100.99,39.57 101,39.55 101,39.25 101.01,39.25 101.92,38.34 101.92,37.95 102.01,37.87 102.94,37.87 103.02,37.78 103.28,37.78 103.41,37.92 103.89,37.92 104.21,37.6 104.44,37.6 105.56,36.47 105.56,36.34 105.89,36.01 106.02,36.01 107.23,34.81 107.23,34.4 107.63,34 107.63,33.34 107.45,33.16 107.24,33.16 107.12,33.03 107.12,32.8 v10(107.24,32.68)
  IN4 w0.084: v4(77.21,63.12) 77.31,63.12 77.61,62.82 v5(77.61,62.84)
  GND5 w0.104: v6(77.21,62.61) 77.33,62.61 77.55,62.84 v5(77.61,62.84)
  BOTTOM w0.122: UCPU1.AR11 v6(77.21,62.61)
DDR_A_D9: length 50
  TOP w0.076: v10(107.33,32.02) 107.55,32.02 108.17,31.4 108.17,30.7 UD2.E7
  IN1 w0.071: v4(79.8,63.96) 79.92,63.84 80.2,63.84 80.75,63.3 80.75,62.84 82.8,60.78 82.8,58.24 94.33,46.71 94.7,46.71 101.48,39.93 101.48,39.49 102.58,38.39 104.09,38.39 104.4,38.07 104.63,38.07 107.7,35 107.7,34.86 108.6,33.97 108.6,33.61 108.37,33.38 108.11,33.38 107.68,32.96 107.68,32.55 107.33,32.2 v10(107.33,32.02)
  IN4 w0.084: v5(80.02,63.49) 80.02,63.75 v4(79.8,63.96)
  GND5 w0.104: v5(80.02,63.49) 79.98,63.53 v6(79.58,63.53)
  BOTTOM w0.122: v6(79.58,63.53) 79.8,63.76 UCPU1.AP6
DDR_A_D10: length 49.6
  TOP w0.104: UD2.B3 105.11,32.95 v10(105.11,33.82)
  IN1 w0.071: v10(105.11,33.82) 105.11,34.52 105.04,34.6 104.73,34.6 104.38,34.6 104.27,34.7 104.27,35.06 104.14,35.19 102.75,35.19 102.21,35.73 102.21,36.18 101.94,36.45 101.22,36.45 97.21,40.46 97.21,40.55 97.35,40.69 97.36,40.73 97.36,41.04 97.29,41.1 97.2,41.1 96.95,40.85 96.82,40.85 96.66,41.01 96.66,41.13 97.06,41.53 97.06,41.64 96.88,41.82 96.76,41.82 96.37,41.43 96.25,41.43 96.07,41.6 96.07,41.72 96.47,42.12 96.47,42.24 96.29,42.42 96.17,42.42 95.77,42.02 95.65,42.02 95.48,42.2 95.48,42.31 95.87,42.71 95.87,42.83 95.7,43.01 95.58,43.01 95.18,42.61 95.06,42.61 94.88,42.79 94.88,42.91 95.28,43.3 95.28,43.42 95.1,43.6 94.98,43.6 94.59,43.2 94.47,43.2 94.27,43.41 94.27,43.52 94.5,43.75 94.57,43.82 94.57,44.17 93.97,44.78 93.59,44.78 81.16,57.21 81.16,57.22 80.92,57.46 80.92,60.56 79.84,61.63 v4(79.38,61.63)
  IN4 w0.084: v4(79.38,61.63) 79.74,61.99 v5(79.86,61.99)
  GND5 w0.104: v6(79.86,61.51) v5(79.86,61.99)
  BOTTOM w0.122: UCPU1.AU6 v6(79.86,61.51)
DDR_A_D11: length 50.8
  TOP w0.076: UD2.E3 105.86,30.6 v10(105.86,30.62)
  IN1 w0.071: v10(105.86,30.62) 106.08,30.62 106.18,30.72 106.18,31.54 106.08,31.64 105.63,31.64 105.46,31.8 105.46,32.85 105.46,33.16 105.21,33.41 103.94,33.41 103.84,33.52 103.84,34.12 103.74,34.23 103.44,34.23 103.33,34.12 103.33,33.97 103.23,33.87 102.98,33.87 102.88,33.97 102.88,34.8 102.8,34.89 102.55,34.89 102.46,34.8 102.46,33.98 102.38,33.9 102.14,33.9 102.04,34 102.04,35.3 101.78,35.55 101.78,35.73 101.97,35.91 101.97,36.08 101.84,36.21 101.59,36.21 101.43,36.06 101.28,36.06 93.96,43.38 93.96,43.55 94.33,43.92 94.33,44.07 93.87,44.54 93.5,44.54 80.68,57.35 80.68,60.46 79.89,61.25 78.89,61.25 v4(78.71,61.43)
  IN4 w0.084: v5(78.47,61.89) 78.71,61.64 v4(78.71,61.43)
  GND5 w0.104: v6(78.05,61.41) 78.05,61.46 78.47,61.87 v5(78.47,61.89)
  BOTTOM w0.104: UCPU1.AV9 v6(78.05,61.41)
DDR_A_D12: length 49.7
  TOP w0.104: UD2.C7 108.6,31.8 107.73,32.68 107.73,33.06 107.25,33.54 v10(107.24,33.54)
  IN1 w0.071: v10(107.24,33.54) 107.31,33.54 107.39,33.62 107.39,33.9 106.99,34.3 106.99,34.71 105.93,35.77 105.47,35.77 105.33,35.92 105.33,36.37 104.34,37.36 103.97,37.36 103.87,37.46 103.87,37.6 103.79,37.68 103.51,37.68 103.44,37.6 103.44,37.43 103.37,37.36 103.11,37.36 102.84,37.63 101.71,37.63 101.51,37.83 101.51,37.95 101.68,38.12 101.68,38.24 101.5,38.42 101.39,38.42 101.21,38.24 101.09,38.24 100.92,38.42 100.92,38.54 101.09,38.71 101.09,38.83 100.91,39.01 100.79,39.01 100.62,38.84 100.5,38.84 99.32,40.02 99.32,40.13 99.62,40.43 99.62,40.55 99.45,40.73 99.33,40.73 99.03,40.43 98.91,40.43 98.53,40.81 98.53,41.19 98.69,41.34 98.69,41.54 98.53,41.69 98.53,41.87 94.45,45.95 94.09,45.95 82.1,57.95 82.1,60.52 80.33,62.28 80.33,62.28 80.28,62.33 80.03,62.58 79.85,62.58 79.76,62.67 79.76,62.9 v4(79.85,63)
  IN4 w0.084: v4(79.85,63) 79.85,62.56 v5(79.94,62.47)
  GND5 w0.104: v6(79.5,62.64) 79.62,62.64 79.79,62.47 v5(79.94,62.47)
  BOTTOM w0.122: v6(79.5,62.64) 79.81,62.95 UCPU1.AR6
DDR_A_D13: length 50.2
  TOP w0.104: v10(108.21,33.77) 109.68,33.77 109.89,33.57 109.89,32.55 109.47,32.13 UD2.C8
  IN1 w0.071: v4(78.5,64.01) 78.5,63.83 78.59,63.74 78.96,63.74 79.11,63.59 80.12,63.59 80.51,63.2 80.51,62.75 82.57,60.69 82.57,58.14 94.24,46.48 94.4,46.48 94.4,46.48 94.6,46.48 99.01,42.07 99.01,41.89 101.24,39.65 101.24,39.35 102.15,38.44 102.15,38.24 102.24,38.15 103.99,38.15 104.31,37.83 104.53,37.83 105.8,36.57 105.8,36.44 105.99,36.25 106.12,36.25 107.46,34.91 107.46,34.49 107.86,34.1 107.86,33.79 107.96,33.69 108.13,33.69 v10(108.21,33.77)
  IN4 w0.084: v5(78.11,63.64) 78.13,63.64 v4(78.5,64.01)
  GND5 w0.104: v5(78.11,63.64) 78.29,63.64 78.45,63.48 v6(78.5,63.48)
  BOTTOM w0.122: UCPU1.AP8 v6(78.5,63.48)
DDR_A_D14: length 49.7
  TOP w0.104: v10(103.21,33.46) 103.49,33.19 103.49,32.45 103.73,32.21 104.26,32.21 UD2.C2
  IN1 w0.071: v10(103.21,33.46) 103.16,33.52 102.34,33.52 102.24,33.41 102.24,32.42 102.34,32.32 102.72,32.32 102.83,32.22 102.83,31.94 102.72,31.84 101.9,31.84 101.8,31.94 101.8,35.2 93.09,43.91 93.09,44.61 80.39,57.31 80.39,60.39 79.76,61.02 78.57,61.02 77.5,62.09 77.22,62.09 77.17,62.14 v4(77.17,62.55)
  IN4 w0.084: v4(77.17,62.55) 77.11,62.55 v5(76.78,62.88)
  GND5 w0.104: v6(76.78,62.45) v5(76.78,62.88)
  BOTTOM w0.122: UCPU1.AT13 v6(76.78,62.45)
DDR_A_D15: length 52
  TOP w0.104: UD2.D2 104.29,31.38 102.95,31.38 102.75,31.58 v10(102.75,33)
  IN1 w0.071: v10(102.75,33) 102.75,32.7 102.85,32.6 102.97,32.6 103.05,32.52 103.05,32.3 103.14,32.22 103.39,32.22 103.47,32.3 103.47,32.6 103.57,32.7 103.79,32.7 103.89,32.6 103.89,32.05 103.81,31.96 103.67,31.96 103.59,31.88 103.59,31.63 103.72,31.5 103.72,31.26 103.61,31.16 102.9,31.16 102.47,31.58 101.67,31.58 101.56,31.69 101.56,35.11 92.86,43.81 92.86,44.51 80.16,57.21 80.16,57.4 80.16,60.3 79.63,60.82 78.49,60.82 78.49,60.84 78.49,60.84 77.7,61.63 v4(77.4,61.63)
  IN4 w0.084: v5(77.1,62.05) 77.3,61.85 77.3,61.73 v4(77.4,61.63)
  GND5 w0.104: v6(76.67,62.05) 76.68,62.05 v5(77.1,62.05)
  BOTTOM w0.122: v6(76.67,62.05) 76.67,62.05 76.58,62.05 UCPU1.AU13
DDR_A_D16: length 48.6
  IN1 w0.071: v4(79.52,59.11) 79.69,58.95 79.69,57.01 92.38,44.31 92.38,43.62 101.09,34.92 101.09,32.03 99.47,30.42 95.61,30.42 95.23,30.04 94.01,30.04 93.63,30.42 93.63,30.95 93.44,31.14 93.44,31.69 v10(93.96,32.21)
  IN4 w0.084: v5(79.26,58.71) 79.52,58.98 v4(79.52,59.11)
  GND5 w0.104: v6(79.02,59.11) 79.02,59.05 79.26,58.81 v5(79.26,58.71)
  BOTTOM w0.104: UD3.C7 94.37,31.8 v10(93.96,32.21)
  BOTTOM w0.122: UCPU1.BC7 v6(79.02,59.11)
DDR_A_D17: length 48.3
  IN1 w0.071: v4(79.45,59.76) 79.45,59.92 79.13,60.24 78.92,60.24 78.83,60.14 78.83,59.72 78.98,59.57 79.1,59.57 79.2,59.47 79.2,59.31 79.08,59.19 78.92,59.19 78.85,59.12 78.85,58.94 79.03,58.76 79.4,58.76 79.48,58.68 79.48,58.2 79.38,58.1 79,58.1 78.85,57.95 78.85,57.47 79,57.32 79.36,57.32 79.46,57.21 79.46,56.91 92.15,44.22 92.15,43.52 98.59,37.08 98.59,36.95 98.37,36.73 98.37,36.15 98.54,35.98 98.71,35.98 98.81,36.08 98.81,36.54 98.91,36.64 99.03,36.64 99.32,36.35 99.32,36.2 99.24,36.13 99.24,35.9 99.32,35.83 99.5,35.83 99.61,35.93 99.74,35.93 99.85,35.81 99.85,35.62 100.01,35.47 100.19,35.47 100.4,35.27 100.4,35.08 100.6,34.88 100.79,34.88 100.85,34.82 100.85,32.63 100.72,32.5 100.72,32.34 100.82,32.25 100.82,32.1 100.69,31.97 100.53,31.97 100.43,32.07 100.31,32.07 100.16,31.92 v10(100.16,31.84)
  IN4 w0.084: v5(79.95,60.18) 79.54,59.76 v4(79.45,59.76)
  GND5 w0.104: v5(79.95,60.18) 79.95,59.79 v6(79.93,59.76)
  BOTTOM w0.104: UD3.E3 98.01,30.59 99.68,30.59 100.16,31.08 v10(100.16,31.84)
  BOTTOM w0.122: UCPU1.BB7 v6(79.93,59.76)
DDR_A_D18: length 50.5
  IN1 w0.071: v10(97.23,32.99) 97.12,32.99 96.96,32.83 96.96,31.84 97.34,31.46 97.52,31.46 97.67,31.61 97.67,31.74 97.37,32.04 97.37,32.32 97.49,32.45 97.7,32.45 97.82,32.58 98.33,32.58 98.51,32.75 98.51,33.11 98.23,33.38 97.68,33.38 97.54,33.52 97.54,33.83 97.3,34.07 97.07,34.07 96.74,34.4 96.56,34.4 96.51,34.45 96.51,34.63 96.19,34.95 96.02,34.95 95.87,35.09 95.87,35.26 95.55,35.58 95.38,35.58 95.26,35.7 95.26,35.85 94.86,36.25 94.71,36.25 94.61,36.35 94.61,36.51 93.53,37.59 93.53,37.9 93.43,38 93.13,38 92.21,38.93 92.21,39.04 92.42,39.26 92.42,39.4 92.27,39.55 92.12,39.55 91.91,39.34 91.79,39.34 91.62,39.52 91.62,39.64 91.8,39.82 91.8,39.97 91.65,40.12 91.51,40.12 91.32,39.93 91.2,39.93 91.12,40.02 91.12,40.47 90.94,40.65 90.94,40.77 91.04,40.87 91.04,41.01 90.89,41.16 90.75,41.16 90.65,41.06 90.53,41.06 88.62,42.97 88.62,43.02 88.62,43.03 88.62,43.22 88.52,43.32 88.52,43.39 88.72,43.59 88.72,43.71 88.54,43.88 88.4,43.88 88.24,43.72 88.12,43.72 87.94,43.9 87.94,44.03 88.12,44.21 88.12,44.31 86.37,46.06 86.37,46.97 86.2,47.14 85.83,47.14 85.68,47.29 85.68,47.38 85.72,47.43 85.72,47.57 85.57,47.72 85.43,47.72 85.41,47.71 85.25,47.71 85.11,47.85 85.11,48.22 84.96,48.37 84.84,48.37 84.8,48.33 84.73,48.33 84.64,48.33 84.52,48.44 84.52,48.49 84.52,48.49 84.52,48.69 84.52,48.81 84.39,48.95 84.01,48.95 83.92,49.03 83.92,49.41 83.79,49.54 83.44,49.54 83.34,49.64 83.34,49.99 83.18,50.16 82.99,50.16 82.95,50.12 82.89,50.12 82.62,50.12 80.54,52.2 80.54,52.37 80.54,52.57 80.41,52.7 80.13,52.7 79.99,52.57 79.98,52.57 79.78,52.57 76.21,56.13 76.21,56.81 76.32,56.91 76.38,56.91 76.49,57.01 76.49,57.23 76.38,57.33 76.08,57.33 75.98,57.43 75.98,57.65 76.08,57.75 76.33,57.75 76.44,57.85 76.44,58.07 76.33,58.17 76.08,58.17 75.98,58.27 75.98,58.49 76.08,58.59 76.13,58.59 76.21,58.67 76.21,58.92 76.13,59.01 76.04,59.01 75.95,59.09 75.95,59.34 76.04,59.43 76.04,60.02 v4(76.16,60.14)
  IN4 w0.084: v4(76.16,60.14) 76.17,60.13 v5(76.17,59.62)
  GND5 w0.104: v6(76.73,59.62) v5(76.17,59.62)
  BOTTOM w0.104: UD3.B3 v10(97.23,32.99)
  BOTTOM w0.122: UCPU1.BA13 76.5,59.85 v6(76.73,59.62)
DDR_A_D19: length 49.1
  IN1 w0.071: v4(77.57,59.5) 77.57,59.6 77.68,59.71 77.73,59.71 77.77,59.75 77.91,59.75 77.99,59.68 77.99,59.09 78.16,58.91 78.16,58.76 78.06,58.65 77.97,58.65 77.89,58.57 77.89,58.32 77.97,58.23 78.06,58.23 78.16,58.13 78.16,57.92 78.06,57.82 77.94,57.82 77.71,57.59 77.71,57.39 77.86,57.24 78.1,57.24 78.89,56.44 78.89,56.25 79.01,56.14 79.19,56.14 79.4,55.94 79.4,55.8 79.63,55.57 79.74,55.57 79.76,55.57 82.04,53.29 82.04,53.16 82.16,53.04 82.3,53.04 87.78,47.55 87.78,47.31 87.89,47.2 88,47.2 88.02,47.22 88.13,47.22 88.31,47.04 88.31,46.92 88.3,46.91 88.3,46.79 88.48,46.61 88.71,46.61 89.06,46.26 89.06,46.16 88.96,46.06 88.96,46.01 88.78,45.84 88.78,45.65 89.19,45.23 89.25,45.23 89.25,45.23 89.48,45 89.48,44.94 89.79,44.64 89.84,44.64 89.84,44.64 90.08,44.41 90.08,44.35 90.38,44.05 90.43,44.05 90.44,44.05 90.69,43.8 90.69,43.7 90.61,43.63 90.61,43.62 90.61,43.55 90.83,43.33 91.1,43.33 91.2,43.23 91.32,43.23 91.39,43.23 91.59,43.02 91.59,42.84 91.8,42.63 91.98,42.63 92.19,42.43 92.19,42.24 92.38,42.05 92.56,42.05 92.82,41.8 92.82,41.62 93.07,41.36 93.29,41.36 93.45,41.2 93.45,40.97 93.67,40.75 93.9,40.75 95.11,39.55 95.11,39.18 95.21,39.08 95.58,39.08 95.74,38.92 95.74,38.77 95.11,38.14 95.11,38.01 95.23,37.88 95.46,37.88 96.04,38.47 96.19,38.47 96.37,38.28 96.37,38.14 95.89,37.66 95.89,37.23 96.04,37.08 96.22,37.08 96.32,37.18 96.32,37.45 96.7,37.83 96.82,37.83 97.06,37.6 97.06,37.48 96.88,37.3 96.83,37.3 96.75,37.22 96.75,36.81 96.82,36.74 97.14,36.74 97.24,36.84 97.24,37.05 97.34,37.15 97.51,37.15 97.66,36.99 97.66,36.56 97.57,36.47 97.47,36.47 97.31,36.3 97.31,35.85 97.6,35.55 97.96,35.55 98.4,35.11 98.76,35.11 98.86,35.01 98.86,34.65 99.03,34.48 99.24,34.48 99.36,34.37 99.36,34.26 99.59,34.03 99.59,34.03 99.68,33.95 v10(99.68,33.79)
  IN4 w0.084: v5(77.12,59.75) 77.31,59.75 v4(77.57,59.5)
  GND5 w0.104: v5(77.12,59.75) 77.12,59.35 v6(77.04,59.26)
  BOTTOM w0.104: UD3.C2 98.83,32.21 99.34,32.21 99.4,32.27 99.4,32.32 99.54,32.47 99.54,32.74 99.4,32.88 99.4,33.12 99.54,33.27 99.54,33.36 99.58,33.39 99.58,33.69 v10(99.68,33.79)
  BOTTOM w0.122: UCPU1.BB11 77.22,59.44 v6(77.04,59.26)
DDR_A_D20: length 49.6
  IN1 w0.071: v10(93.23,30.59) 93.23,29.88 93.5,29.6 96.31,29.6 96.32,29.6 96.7,29.6 97.31,30.21 99.6,30.21 101.33,31.94 101.33,35.01 92.62,43.71 92.62,44.41 79.92,57.11 79.92,59.97 v4(79.51,60.38)
  IN4 w0.084: v4(79.51,60.38) 79.79,60.65 v5(79.79,60.82)
  GND5 w0.104: v6(79.16,60.73) 79.24,60.82 v5(79.79,60.82)
  BOTTOM w0.104: UD3.E8 93.62,30.2 v10(93.23,30.59)
  BOTTOM w0.122: UCPU1.BA7 v6(79.16,60.73)
DDR_A_D21: length 49.2
  IN1 w0.071: v4(78.56,59.45) 78.56,58.73 78.64,58.65 78.72,58.65 78.82,58.55 78.82,58.33 78.72,58.23 78.64,58.23 78.56,58.14 78.56,57.47 91.91,44.12 91.91,43.41 98.13,37.19 98.13,36.05 98.59,35.59 99.54,35.59 100.61,34.52 100.61,32.72 100.18,32.3 100.01,32.3 99.37,31.66 99.37,30.9 99.19,30.72 97.21,30.72 97.11,30.82 97.11,30.82 97.11,31.13 96.88,31.36 96.56,31.36 96.42,31.22 95.83,31.22 95.65,31.39 95.27,31.39 95.08,31.2 95.08,30.89 95.18,30.79 95.18,30.77 95.23,30.72 95.23,30.42 95.05,30.24 94.37,30.24 v10(94.01,30.59)
  IN4 w0.084: v4(78.56,59.45) 78.85,59.74 78.85,60.47 v5(78.81,60.51)
  GND5 w0.104: v5(78.81,60.51) 78.81,60.23 v6(78.94,60.1)
  BOTTOM w0.104: UD3.E7 94.41,30.2 v10(94.01,30.59)
  BOTTOM w0.122: UCPU1.BA9 v6(78.94,60.1)
DDR_A_D22: length 48.2
  IN1 w0.071: v4(78.46,60.05) 78.46,59.88 78.19,59.61 78.19,59.3 78.35,59.14 78.35,57.35 89.34,46.36 89.34,46.09 89.22,45.97 89.22,45.6 91.32,43.5 91.49,43.5 97.9,37.09 97.9,36.31 97.82,36.23 97.64,36.23 97.54,36.13 97.54,35.95 97.7,35.79 98.06,35.79 98.49,35.35 99.44,35.35 100.38,34.42 100.38,32.85 100.05,32.53 99.91,32.53 99.13,31.76 99.13,31.56 99.16,31.53 98.57,30.94 97.39,30.94 97.3,31.03 97.3,31.09 97.29,31.1 97.29,31.21 96.96,31.55 96.81,31.55 96.49,31.55 96.34,31.4 95.9,31.4 95.72,31.58 95.6,31.58 95.52,31.66 95.52,31.81 95.44,31.89 95.18,31.89 95.1,31.81 95.1,31.66 95.02,31.58 94.11,31.58 94.01,31.48 v10(94.01,31.38)
  IN4 w0.084: v5(78.01,59.87) 78.27,59.87 v4(78.46,60.05)
  GND5 w0.104: v5(78.01,59.87) 78.05,59.83 v6(78.05,59.45)
  BOTTOM w0.104: v10(94.01,31.38) 94.01,31.41 93.62,31.8 UD3.C8
  BOTTOM w0.122: UCPU1.BB9 v6(78.05,59.45)
DDR_A_D23: length 49
  IN1 w0.071: v10(99.97,33.22) 100.14,33.04 100.14,32.95 99.96,32.77 99.81,32.77 99.69,32.65 99.55,32.65 99.45,32.75 99.45,33.29 99.24,33.49 99.24,33.94 98.62,34.56 98.62,34.75 98.49,34.88 98.3,34.88 97.86,35.32 97.51,35.32 97.07,35.75 97.07,36.38 96.94,36.5 96.73,36.5 96.39,36.84 95.94,36.84 95.66,37.13 95.66,37.48 95.49,37.65 95.38,37.65 95.31,37.58 95.21,37.58 95.14,37.65 95.14,37.65 94.87,37.91 94.87,38.24 95.23,38.6 95.23,38.72 95.11,38.84 95.11,38.84 95.04,38.91 94.94,38.91 94.78,38.76 94.65,38.76 94.54,38.87 94.54,39 94.87,39.33 94.87,39.45 94.69,39.63 94.58,39.63 94.24,39.29 94.12,39.29 94.06,39.35 94.06,39.66 94.24,39.84 94.24,39.99 94.14,40.09 94,40.09 93.89,40.21 93.89,40.44 93.8,40.52 93.58,40.52 93.17,40.92 92.82,41.27 92.68,41.27 92.55,41.4 92.55,41.55 92.34,41.76 91.1,42.99 91,43.09 90.93,43.09 90.61,43.09 90.38,43.32 90.38,43.72 88.53,45.57 88.53,45.66 88.42,45.77 88.33,45.77 87.97,46.12 87.97,46.25 88.2,46.47 88.2,46.56 88.04,46.71 88.04,46.85 87.95,46.94 87.65,46.94 87.55,47.04 87.55,47.45 82.2,52.8 82.07,52.8 82.06,52.8 81.97,52.8 81.8,52.96 81.8,53.06 81.8,53.2 81.62,53.38 81.57,53.38 81.31,53.64 81.31,53.69 81.14,53.87 80.89,53.87 80.78,53.97 80.68,54.08 80.68,54.32 80.5,54.5 80.25,54.5 80.11,54.64 80.11,54.89 79.66,55.34 79.53,55.34 79.09,55.78 78.86,55.78 78.66,55.98 78.66,56.34 77.99,57.01 77.6,57.01 77.35,57.26 77.35,57.49 77.83,57.98 77.83,58.11 77.65,58.29 77.65,58.61 77.83,58.79 77.83,58.92 77.62,59.12 77.51,59.12 77.39,59 77.25,59 76.86,59.39 76.86,59.55 76.97,59.65 77.2,59.65 77.27,59.73 77.27,60.03 77.34,60.1 77.57,60.1 v4(77.58,60.08)
  IN4 w0.084: v4(77.58,60.08) 77.38,60.28 v5(77.11,60.28)
  GND5 w0.104: v6(76.67,60.24) 76.72,60.28 v5(77.11,60.28)
  BOTTOM w0.104: UD3.D2 98.74,31 99.19,31.45 99.34,31.45 99.58,31.69 99.58,31.89 99.75,32.07 99.75,33 v10(99.97,33.22)
  BOTTOM w0.122: UCPU1.AY13 76.33,60.29 76.44,60.18 76.61,60.18 v6(76.67,60.24)
DDR_A_D24: length 45.5
  TOP w0.104: v10(97.13,33.66) 97.24,33.77 98.56,33.77 98.79,33.54 98.79,32.17 UD4.C8
  IN1 w0.071: v10(97.13,33.66) 96.94,33.66 96.83,33.77 96.83,33.97 96.64,34.16 96.46,34.16 96.27,34.35 96.27,34.53 96.09,34.71 95.92,34.71 95.64,34.99 95.64,35.16 95.46,35.34 95.28,35.34 95.03,35.6 95.03,35.75 94.76,36.02 94.61,36.02 94.38,36.25 94.38,36.41 92.98,37.81 92.74,37.81 92.66,37.89 92.66,38.12 91.37,39.41 91.37,39.56 91.23,39.7 91.1,39.7 90.88,39.92 90.88,40.38 88.38,42.87 88.38,43.12 87.61,43.9 87.61,44.48 86.1,46 86.1,46.31 86.04,46.36 86.04,46.48 86.1,46.53 86.1,46.71 85.91,46.9 85.73,46.9 85.68,46.85 85.55,46.85 85.41,46.99 85.41,47.14 85.44,47.17 85.44,47.35 85.31,47.47 85.13,47.47 85.1,47.44 84.96,47.44 84.79,47.61 84.79,47.73 84.85,47.79 84.85,47.97 84.73,48.09 84.55,48.09 84.49,48.03 84.37,48.03 84.2,48.21 84.2,48.33 84.29,48.42 84.29,48.59 84.16,48.71 83.99,48.71 83.9,48.62 83.78,48.62 83.6,48.8 83.6,48.92 83.69,49 83.69,49.18 83.57,49.3 83.39,49.3 83.31,49.21 83.19,49.21 83.01,49.39 83.01,49.51 83.11,49.61 83.11,49.77 82.99,49.88 82.83,49.88 82.76,49.81 82.59,49.81 80.07,52.33 79.68,52.33 75.98,56.03 75.98,56.89 75.76,57.11 75.76,60.27 75.9,60.41 75.9,60.57 75.76,60.71 75.76,60.89 75.9,61.03 75.9,61.36 v4(75.79,61.47)
  IN4 w0.084: v5(74.9,61.47) v4(75.79,61.47)
  GND5 w0.104: v6(75.31,61.47) v5(74.9,61.47)
  BOTTOM w0.122: UCPU1.AV14 v6(75.31,61.47)
DDR_A_D25: length 44.8
  TOP w0.104: v10(96.19,33.54) 96.19,33.53 96.68,33.03 96.68,32.74 UD4.C7
  IN1 w0.071: v10(96.19,33.54) 96.03,33.7 96.03,33.93 94.11,35.85 93.44,35.85 92.36,36.93 92.36,36.94 92.35,36.96 92.35,37.24 92.15,37.44 91.86,37.44 91.61,37.68 91.61,38.02 91.73,38.14 91.73,38.35 90.41,39.67 90.41,40.18 87.91,42.68 87.91,42.93 87.14,43.7 87.14,44.29 85.62,45.8 85.62,46.11 85.58,46.16 85.52,46.21 83.31,48.42 82.97,48.77 79.88,51.86 79.49,51.86 75.5,55.84 75.5,56.78 75.32,56.96 75.32,60.47 75.37,60.51 75.37,60.92 75.27,61.02 74.99,61.02 74.89,61.13 74.89,61.87 74.97,61.95 75.23,61.95 75.32,62.04 75.32,62.29 75.23,62.37 74.99,62.37 74.89,62.48 74.89,62.7 74.99,62.8 75.37,62.8 75.47,62.9 v4(75.47,63.46)
  IN4 w0.084: v4(75.47,63.46) 75.83,63.82 v5(75.85,63.82)
  GND5 w0.104: v6(76.2,63.55) 76.18,63.55 75.92,63.82 v5(75.85,63.82)
  BOTTOM w0.122: v6(76.2,63.55) 76.08,63.44 75.78,63.44 UCPU1.AR14
DDR_A_D26: length 44.7
  TOP w0.104: v10(94.79,30.63) 94.79,30.59 94.42,30.21 UD4.E3
  IN1 w0.071: v10(94.79,30.63) 94.45,30.98 93.86,30.98 93.63,31.22 93.63,31.53 93.85,31.76 94.06,31.76 94.37,32.07 94.37,32.45 93.41,33.41 93.06,33.41 92.67,33.79 92.67,34.29 89.95,37.01 89.95,37.79 89.59,38.15 89.25,38.15 89.02,37.92 88.69,37.92 88.46,38.15 88.46,38.37 88.18,38.65 88.18,39.38 88.1,39.47 87.82,39.47 87.74,39.55 87.74,39.8 87.92,39.98 87.92,40.34 86.26,41.99 86.26,42.24 83.97,44.53 83.97,45.42 80.78,48.61 80.13,48.61 78.17,50.57 78.17,50.84 72.91,56.1 72.91,56.12 72.9,56.13 72.9,58.81 73.03,58.95 73.03,59.31 73.14,59.42 73.73,59.42 73.83,59.52 73.83,59.76 74,59.92 74,60.26 73.9,60.36 v4(73.79,60.36)
  IN4 w0.084: v5(73.97,60.82) 73.79,60.64 v4(73.79,60.36)
  GND5 w0.104: v6(73.48,60.74) 73.55,60.82 v5(73.97,60.82)
  BOTTOM w0.122: UCPU1.AY17 v6(73.48,60.74)
DDR_A_D27: length 44.7
  TOP w0.104: UD4.D2 93.24,31.38 91.93,31.38 91.65,31.66 91.65,32.95 v10(91.7,33)
  IN1 w0.071: v10(91.7,33) 91.68,33 90.08,34.61 90.08,35.28 90.08,35.28 90.08,35.86 87.69,38.25 87.59,38.36 87.59,39 86.44,40.14 86.44,41.14 85.79,41.8 85.79,42.05 83.5,44.33 83.5,45.22 80.59,48.13 79.93,48.13 79,49.07 79,49.07 77.7,50.37 77.7,50.64 72.36,55.97 72.36,58.72 72.09,58.99 72.09,60.85 72.68,61.43 72.68,63.15 v4(72.87,63.35)
  IN4 w0.084: v5(73.72,63.64) 73.42,63.35 v4(72.87,63.35)
  GND5 w0.104: v5(73.72,63.64) 73.42,63.35 v6(73.38,63.35)
  BOTTOM w0.122: UCPU1.AR19 v6(73.38,63.35)
DDR_A_D28: length 43.9
  TOP w0.076: UD4.E8 98.42,30.2 98.06,30.2 97.67,30.59 97.57,30.59 97.31,30.86 97.31,31.56 v10(96.19,32.68)
  IN1 w0.071: v10(96.19,32.68) 96.22,32.65 96.42,32.65 96.52,32.75 96.52,33.06 96.43,33.16 95.87,33.16 95.74,33.29 95.74,33.83 93.96,35.61 93.34,35.61 91.38,37.58 91.38,38.37 90.17,39.57 90.17,40.08 87.67,42.58 87.67,42.83 86.9,43.6 86.9,44.19 86.69,44.4 86.5,44.4 86.41,44.5 86.41,44.61 86.16,44.86 86.05,44.86 85.95,44.96 85.95,45.14 85.39,45.7 85.39,46 83.14,48.25 83.14,48.26 82.8,48.6 79.78,51.62 79.39,51.62 75.27,55.74 75.27,56.71 75.04,56.93 75.04,60.08 74.96,60.16 74.81,60.16 74.68,60.29 74.68,60.57 74.76,60.64 74.91,60.64 v4(74.96,60.59)
  IN4 w0.084: v5(74.89,60.08) 74.89,60.52 v4(74.96,60.59)
  GND5 w0.104: v5(74.89,60.08) 75.22,60.08 v6(75.31,60.17)
  BOTTOM w0.122: UCPU1.BA14 v6(75.31,60.17)
DDR_A_D29: length 44.5
  TOP w0.076: UD4.E7 97.13,30.69 97.13,31.39 96.5,32.02 v10(96.28,32.02)
  IN1 w0.071: v10(96.28,32.02) 96.41,31.89 96.55,31.89 96.7,32.04 96.7,33.59 94.14,36.15 94.14,36.31 92.92,37.53 92.56,37.53 92.42,37.67 92.42,38.02 92.13,38.32 92.1,38.32 90.64,39.77 90.64,40.28 88.15,42.78 88.15,43.02 87.37,43.8 87.37,44.39 85.86,45.9 85.86,46.21 83.42,48.64 83.2,48.87 79.98,52.09 79.58,52.09 75.74,55.94 75.74,56.83 75.51,57.06 75.51,60.39 75.55,60.44 75.55,60.45 75.57,60.47 75.57,61.05 75.29,61.33 75.29,61.61 75.79,62.11 v4(75.79,62.12)
  IN4 w0.084: v5(74.89,62.12) v4(75.79,62.12)
  GND5 w0.104: v6(75.31,62.12) v5(74.89,62.12)
  BOTTOM w0.122: UCPU1.AU14 v6(75.31,62.12)
DDR_A_D30: length 44.3
  TOP w0.104: v10(94.06,33.82) 94.06,32.95 UD4.B3
  IN1 w0.071: v4(74.2,59.6) 74.2,59.2 74.1,59.09 73.46,59.09 73.36,58.99 73.36,58.78 73.46,58.68 73.95,58.68 74.03,58.59 74.03,58.34 73.95,58.26 73.26,58.26 73.16,58.15 73.16,57.94 73.26,57.84 73.95,57.84 74.03,57.75 74.03,57.5 73.95,57.42 73.26,57.42 73.16,57.32 73.16,57.1 73.26,57 73.95,57 74.03,56.92 74.03,56.65 73.95,56.56 73.22,56.56 73.13,56.48 73.13,56.23 73.22,56.15 73.95,56.15 74.03,56.06 74.03,55.31 78.42,50.92 78.42,50.65 80.23,48.84 80.88,48.84 84.21,45.52 84.21,44.63 86.5,42.34 86.5,42.09 88.42,40.17 88.42,39.89 88.52,39.79 88.8,39.79 88.98,39.6 88.98,38.74 89.01,38.71 89.02,38.71 89.1,38.64 89.44,38.64 89.44,38.63 90.2,37.88 90.2,37.09 92.86,34.44 93.47,34.44 93.6,34.31 93.6,33.88 93.66,33.82 v10(94.06,33.82)
  IN4 w0.084: v5(74.87,59.52) 74.78,59.6 v4(74.2,59.6)
  GND5 w0.104: v6(75.31,59.52) v5(74.87,59.52)
  BOTTOM w0.122: UCPU1.BB14 v6(75.31,59.52)
DDR_A_D31: length 45.1
  TOP w0.104: UD4.C2 93.27,32.14 92.62,32.14 92.34,32.42 92.34,33.29 v10(92.16,33.46)
  IN1 w0.071: v4(73.39,59.93) 73.11,59.93 72.87,59.69 72.87,59.42 72.83,59.38 72.83,59 72.6,58.78 72.6,56.07 77.93,50.74 77.93,50.47 80.03,48.37 80.69,48.37 83.74,45.32 83.74,44.43 86.02,42.14 86.02,41.9 86.69,41.23 86.69,40.86 86.8,40.75 86.98,40.75 87.01,40.72 87.01,40.72 87.25,40.49 87.25,40.16 87.13,40.04 87.13,39.79 87.82,39.1 87.82,38.46 87.93,38.34 88.15,38.34 88.22,38.27 88.22,38.05 89,37.27 89.14,37.27 89.24,37.38 89.24,37.78 89.36,37.91 89.5,37.91 89.71,37.69 89.71,37.11 89.71,37.11 89.71,36.88 90.51,36.08 90.51,35.91 90.32,35.73 90.32,35.52 90.41,35.43 90.62,35.43 90.85,35.66 90.96,35.66 91.32,35.3 91.32,35.12 91.22,35.01 90.41,35.01 90.31,34.91 90.31,34.7 90.46,34.56 91.07,34.56 91.17,34.46 91.17,34.29 91.27,34.19 91.57,34.19 91.68,34.29 91.68,34.63 91.78,34.73 91.89,34.73 92.16,34.47 v10(92.16,33.46)
  IN4 w0.084: v4(73.39,59.93) 73.36,59.91 73.36,59.75 v5(73.06,59.44)
  GND5 w0.104: v6(73.48,59.44) v5(73.06,59.44)
  BOTTOM w0.122: UCPU1.BB17 v6(73.48,59.44)
DDR_A_D32: length 65.4
  IN1 w0.071: v10(88.96,33.11) 89.13,33.28 89.13,33.74 88.98,33.89 88.98,34.05 89.13,34.2 89.13,34.51 88.98,34.66 88.98,34.83 89.13,34.98 89.13,35.47 88.93,35.68 88.7,35.68 88.53,35.84 88.53,35.95 88.29,36.19 88.19,36.19 88.09,36.29 88.09,36.37 87.29,37.17 87.21,37.17 87.02,37.36 87.02,37.39 87.02,37.58 86.74,37.86 86.64,37.96 86.64,38.61 85.5,39.75 85.5,40.75 84.84,41.41 84.84,41.65 82.55,43.94 82.55,44.83 80.25,47.14 79.59,47.14 76.7,50.02 76.7,50.16 75.06,51.8 74.71,51.8 74.63,51.89 74.63,52.33 71.4,55.55 71.4,56.29 71.24,56.46 71.03,56.46 70.82,56.25 70.68,56.25 70.57,56.35 70.57,57.12 70.3,57.39 70.16,57.39 70.09,57.32 70.09,57.11 69.98,57.01 69.76,57.01 69.65,57.11 69.65,57.37 69.91,57.62 69.91,57.75 69.81,57.85 69.32,57.85 69.22,57.75 69.22,57.34 69.12,57.24 68.43,57.24 68.33,57.14 68.33,56.71 68.43,56.6 68.69,56.6 68.89,56.81 69.35,56.81 69.53,56.62 69.53,55.79 69.43,55.69 69.2,55.69 69.1,55.79 69.1,55.83 69.01,55.92 68.76,55.92 68.68,55.83 68.68,55.71 68.58,55.61 68.36,55.61 68.26,55.71 68.26,55.82 68.16,55.92 67.94,55.92 67.84,55.82 67.84,55.77 67.75,55.68 67.41,55.68 67.31,55.78 67.31,56.3 67.39,56.38 67.58,56.38 67.67,56.48 67.67,56.69 67.56,56.8 67.39,56.8 67.34,56.85 67.34,57.01 67.24,57.11 67.09,57.11 66.94,57.26 66.8,57.26 66.71,57.17 66.71,56.72 66.77,56.65 66.83,56.65 66.89,56.6 66.89,56.03 66.81,55.94 66.24,55.94 66.13,56.04 66.13,56.67 65.89,56.91 65.89,57.24 65.82,57.32 65.14,57.32 65.06,57.4 65.06,57.65 65.14,57.73 65.87,57.73 66.39,58.25 66.39,58.39 66.1,58.69 65.97,58.69 65.89,58.6 65.89,58.37 65.67,58.15 65.23,58.15 65.13,58.25 65.13,58.55 64.83,58.85 64.83,59.17 64.75,59.25 64.62,59.25 64.4,59.02 63.76,59.02 63.33,59.45 62.29,59.45 62.14,59.3 61.98,59.3 61.91,59.37 61.91,59.51 61.78,59.64 61.66,59.64 61.58,59.72 61.58,59.96 61.44,60.09 61.25,60.09 61.24,60.1 60.77,60.1 60.69,60.19 60.69,60.33 v4(60.74,60.39)
  IN4 w0.084: v5(60.26,60.59) 60.46,60.39 v4(60.74,60.39)
  GND5 w0.104: v5(60.26,60.59) 60.32,60.53 v6(60.32,60.15)
  BOTTOM w0.104: v10(88.96,33.11) 89.24,32.82 89.24,31.7 89.06,31.52 88.45,31.52 88.38,31.45 87.89,31.45 87.66,31.23 87.6,31.23 UD5.D2
  BOTTOM w0.122: v6(60.32,60.15) 60.63,59.85 UCPU1.BA45
DDR_A_D33: length 62.8
  IN1 w0.071: v4(61.59,63.1) 61.59,63.09 62.31,62.37 62.31,62.36 62.69,61.98 62.69,60.84 62.91,60.63 63.22,60.63 63.69,61.1 65.35,61.1 65.35,61.1 65.97,61.1 66.59,60.48 66.59,60.47 66.81,60.26 67.59,60.26 68.15,59.7 69.17,59.7 69.53,59.35 69.53,59.17 72.11,56.59 72.11,55.89 77.44,50.57 77.44,50.3 78.76,48.97 78.76,48.97 79.83,47.9 80.49,47.9 83.26,45.12 83.26,44.24 85.55,41.95 85.55,41.7 86.21,41.04 86.21,40.05 87.35,38.9 87.35,38.26 87.46,38.15 89.84,35.77 89.84,35.37 89.84,30.08 89.15,29.39 88.39,29.39 87.06,28.06 84.2,28.06 82.05,30.21 82.02,30.21 81.79,30.43 81.79,31.02 82.96,32.19 v10(82.96,32.2)
  IN4 w0.084: v5(61.81,63.54) 61.59,63.32 v4(61.59,63.1)
  GND5 w0.104: v5(61.81,63.54) 61.81,63.46 62.07,63.19 v6(62.07,63.17)
  BOTTOM w0.104: UD5.C7 83.36,31.8 v10(82.96,32.2)
  BOTTOM w0.122: UCPU1.AR43 v6(62.07,63.17)
DDR_A_D34: length 64.9
  IN1 w0.071: v4(58.75,61.15) 58.66,61.24 58.66,61.38 58.76,61.48 58.99,61.48 59.38,61.09 59.38,60.15 59.49,60.03 59.49,59.09 59.27,58.86 59.27,58.51 59.75,58.03 59.75,57.38 59.96,57.16 60.88,57.16 61.06,56.98 61.06,56.35 61.8,55.6 61.87,55.6 62.17,55.29 62.17,54.95 62.19,54.94 63.25,53.87 64.24,53.87 64.37,53.75 64.37,52.97 64.48,52.86 67.09,52.86 67.19,52.96 67.19,53.4 67.29,53.5 70.51,53.5 71.38,52.63 71.6,52.63 71.78,52.45 71.78,52.06 72.47,51.36 72.74,51.36 73.71,50.39 74.47,50.39 75.29,49.57 75.29,49.44 79,45.72 79.12,45.72 79.49,45.35 79.89,45.35 79.89,45.35 80.03,45.35 80.9,44.48 80.9,44.48 81.14,44.24 81.14,43.72 81.02,43.6 80.96,43.6 80.85,43.49 80.85,42.47 81.11,42.21 81.66,42.21 82.24,41.63 82.24,41.34 82.48,41.09 83.15,41.09 83.63,40.62 83.63,40.32 83.18,39.87 83.18,39.36 83.18,38.95 83.76,38.37 84.88,38.37 85.11,38.14 85.11,37.49 85.48,37.12 85.48,36.19 85.64,36.03 86.09,35.58 86.38,35.58 86.53,35.43 86.53,35.14 87.23,34.44 87.23,33.54 87.87,32.91 87.87,32.35 87.76,32.25 87.48,32.25 87.38,32.35 87.38,32.49 87.28,32.59 86.65,32.59 86.54,32.49 86.54,30.72 86.65,30.62 87.89,30.62 87.99,30.52 87.99,30.16 87.74,29.91 86.04,29.91 85.88,30.06 85.88,30.26 85.73,30.42 84.67,30.42 84.44,30.19 84.44,29.89 84.36,29.81 83.4,29.81 82.96,30.24 v10(82.96,30.59)
  IN4 w0.084: v4(58.75,61.15) 58.8,61.15 v5(59.23,60.72)
  GND5 w0.104: v6(59.23,61.15) v5(59.23,60.72)
  BOTTOM w0.104: UD5.E7 83.36,30.2 v10(82.96,30.59)
  BOTTOM w0.122: UCPU1.AW48 v6(59.23,61.15)
DDR_A_D35: length 64
  IN1 w0.071: v10(86.14,32.99) 86.35,32.99 86.41,33.05 86.41,33.36 86.62,33.57 86.62,33.69 86.49,33.83 86.49,33.83 86.31,34 86.31,34.12 86.42,34.23 86.49,34.23 86.57,34.3 86.57,34.43 86.38,34.62 86.13,34.62 86.04,34.72 86.04,34.97 85.96,35.04 85.83,35.04 85.63,34.84 85.48,34.84 85.4,34.91 85.4,35.17 85.53,35.29 85.53,35.4 84.88,36.06 84.66,36.06 84.35,35.75 84.19,35.75 83.9,36.04 83.9,36.13 84.11,36.33 84.11,36.49 83.98,36.61 83.86,36.61 83.76,36.72 83.76,36.98 83.93,37.15 84.18,37.15 84.56,36.77 84.56,36.51 84.67,36.41 84.93,36.41 85.01,36.49 85.01,36.93 84.97,36.97 84.64,37.3 84.64,37.43 84.54,37.53 84.34,37.53 84.25,37.61 84.25,37.8 84.17,37.88 83.92,37.88 83.83,37.8 83.83,37.61 83.75,37.53 83.47,37.53 83.37,37.63 83.37,37.88 83.27,37.99 82.96,37.99 82.75,38.2 82.75,38.48 82.65,38.58 82.35,38.58 82.22,38.71 82.22,38.9 82.3,38.98 82.61,38.98 82.71,39.08 82.71,39.3 82.61,39.4 82.3,39.4 82.22,39.48 82.22,39.79 82.32,39.89 82.61,39.89 82.71,39.99 82.71,40.4 82.61,40.5 82.47,40.5 82.32,40.35 82.17,40.35 82.02,40.5 82.02,40.6 82.1,40.68 82.1,40.81 81.94,40.96 81.83,40.96 81.75,40.89 81.64,40.89 81.48,41.04 81.48,41.29 81.64,41.46 81.64,41.56 81.5,41.7 81.37,41.7 81.22,41.55 81.09,41.55 80.38,42.27 80.38,43.93 80.22,44.08 80.02,44.08 79.84,44.27 79.84,44.39 80.02,44.57 80.02,44.69 79.84,44.87 79.72,44.87 79.54,44.68 79.42,44.68 79.16,44.94 78.94,44.94 78.57,45.32 78.57,45.48 78.41,45.63 78.25,45.63 78.1,45.79 78.1,45.95 77.94,46.11 77.78,46.11 77.62,46.26 77.62,46.43 77.47,46.58 77.3,46.58 77.15,46.74 77.15,46.9 76.99,47.06 76.83,47.06 76.67,47.21 76.67,47.37 76.52,47.53 76.36,47.53 76.15,47.74 76,47.74 75.8,47.54 75.61,47.54 75.13,48.02 75.13,48.23 75.24,48.34 75.31,48.41 75.31,48.42 75.39,48.49 75.39,48.63 75.23,48.78 75.09,48.78 74.78,48.47 74.68,48.47 74.48,48.67 74.48,48.79 74.81,49.12 74.81,49.26 74.66,49.42 74.51,49.42 74.18,49.09 74.06,49.09 73.73,49.42 73.73,49.75 73.56,49.92 73.23,49.92 72.8,50.35 72.8,50.61 72.52,50.89 72.27,50.89 71.3,51.86 71.3,52.03 71.16,52.18 70.7,52.18 70.59,52.28 70.59,52.74 70.31,53.02 70.19,53.02 70.06,52.9 70.06,52.59 70.14,52.51 70.14,52.28 70.03,52.18 69.89,52.18 69.78,52.29 69.53,52.29 69.42,52.18 69.21,52.18 69.1,52.29 68.74,52.29 68.63,52.18 68.38,52.18 68.29,52.26 68.29,52.47 68.46,52.65 68.46,52.79 68.26,52.99 67.97,52.99 67.87,52.9 67.87,52.26 67.79,52.18 67.54,52.18 67.45,52.26 67.45,52.28 67.37,52.36 67.12,52.36 67.03,52.28 67.03,52.26 66.95,52.18 66.7,52.18 66.62,52.26 66.62,52.28 66.53,52.36 66.28,52.36 66.2,52.28 66.2,52.26 66.11,52.18 65.86,52.18 65.78,52.26 65.78,52.28 65.69,52.36 65.44,52.36 65.36,52.28 65.36,52.26 65.27,52.18 65.02,52.18 64.94,52.26 64.94,52.28 64.85,52.36 64.6,52.36 64.52,52.28 64.52,52.26 64.44,52.18 64.28,52.18 63.71,52.75 63.71,52.93 63.88,53.1 63.88,53.28 63.76,53.4 63.43,53.4 63.3,53.28 63.18,53.28 61.52,54.94 61.52,55.06 61.54,55.07 61.54,55.19 61.36,55.37 61.24,55.37 61.22,55.35 61.11,55.35 60.93,55.53 60.93,55.65 60.95,55.67 60.95,55.79 60.77,55.96 60.65,55.96 60.63,55.95 60.51,55.95 60.34,56.12 60.34,56.25 60.54,56.45 60.54,56.59 60.47,56.65 60.16,56.65 60.04,56.53 59.92,56.53 59.09,57.37 59.09,57.49 59.19,57.59 59.19,57.82 59.06,57.95 58.83,57.95 58.71,58.08 58.71,59.32 58.76,59.37 v4(58.88,59.37)
  IN4 w0.084: v4(58.88,59.37) 58.88,59.02 v5(58.71,58.84)
  GND5 w0.104: v5(58.71,58.84) 58.63,58.84 v6(58.35,59.13)
  BOTTOM w0.104: v10(86.14,32.99) 86.18,32.99 86.57,32.6 UD5.B3
  BOTTOM w0.122: UCPU1.BC48 58.42,59.2 v6(58.35,59.13)
