# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS#6: length 48.3
  IN4 w0.071: v7(27.27,36.47) 27.27,36.75 27.4,36.88 27.63,36.88 27.74,36.76 27.74,36.01 27.6,35.86 27.12,35.86 26.87,35.62 26.87,35.28 27.29,34.85 28.24,34.85 28.79,35.39 28.79,35.77 28.59,35.96 28.59,37.37 28.75,37.53 29.25,37.53 29.71,37.07 30.04,37.07 30.33,37.36 30.33,38.09 29.69,38.74 29.69,39.25 29.83,39.4 30.01,39.4 30.26,39.65 30.26,39.82 31.27,40.83 31.41,40.83 31.63,40.62 31.89,40.62 32.31,41.04 32.31,41.31 32.1,41.52 32.1,41.67 32.31,41.87 32.53,41.87 32.68,41.72 32.99,41.72 33.13,41.86 34.16,41.86 42.44,50.13 42.44,50.97 46.39,54.92 46.39,55.23 50.52,59.37 50.52,60.42 52.2,62.1 52.29,62.1 52.6,62.41 v5(52.9,62.41)
  GND5 w0.076: v6(53.31,62.41) v5(52.9,62.41)
  BOTTOM w0.114: UCPU1.AT60 53.2,62.52 v6(53.31,62.41)
  BOTTOM w0.127: v7(27.27,36.47) 26.88,36.08 UD15.D3
DDR_B_DQS#7: length 52.6
  TOP w0.076: UD16.D3 23.68,36.18 23.9,36.4 24.05,36.4 24.61,36.96 24.61,38.02 v10(24.67,38.09)
  IN4 w0.071: v10(24.67,38.09) 24.47,38.29 24.47,39.19 26.06,40.78 26.21,40.78 26.37,40.62 26.63,40.62 27.05,41.04 27.05,41.3 26.89,41.46 26.89,41.61 27.44,42.16 27.59,42.16 27.75,42 28.01,42 28.44,42.42 28.44,42.69 28.28,42.85 28.28,43 30.95,45.67 33.94,45.67 38.54,50.26 38.54,57.64 38.64,57.75 39.27,57.75 39.49,57.97 39.49,58.49 39.27,58.72 38.64,58.72 38.54,58.82 38.54,59.1 42.6,63.16 48.24,63.16 50.5,65.43 50.94,65.43 50.98,65.39 52.73,65.39 52.77,65.44 52.92,65.58 52.92,65.79 53.03,65.9 v5(53.04,65.9)
  GND5 w0.076: v5(53.04,65.9) 52.92,65.77 52.92,65.64 53.06,65.5 v6(53.06,65.48)
  BOTTOM w0.114: UCPU1.AK59 53.18,65.91 52.99,65.73 52.99,65.55 v6(53.06,65.48)
DDR_B_MA0: length 167.3
  TOP w0.076: v10(58.87,31.53) 58.87,31.18 58.82,31.12 57.19,31.12 57.03,31.28 56.83,31.28 UD10.K3 ; v10(25.73,31.53) 25.32,31.12 24.04,31.12 23.88,31.28 23.68,31.28 UD16.K3 ; v10(47.83,31.53) 47.42,31.12 46.14,31.12 45.98,31.28 45.78,31.28 UD12.K3 ; UD14.K3 34.73,31.28 34.93,31.28 35.09,31.12 36.37,31.12 v10(36.78,31.53)
  TOP w0.16: R1041.1 18.14,31.38 v8(18.9,31.38)
  IN1 w0.091: v8(18.9,31.38) 18.92,31.39 18.92,31.91 19.34,32.33 19.35,32.33 19.38,32.36 20.36,32.36 21.47,31.25 23.55,31.25 24.27,31.97 25.28,31.97 25.3,31.96 25.55,31.71 25.55,31.7 v10(25.73,31.53) 25.98,31.78 26.64,31.78 26.77,31.65 26.77,31 26.9,30.87 27.24,30.87 27.36,31 27.36,31.17 27.49,31.29 27.74,31.29 27.87,31.17 27.87,30.94 28,30.81 28.32,30.81 28.44,30.94 28.44,31.17 28.57,31.3 29.71,31.3 29.99,31.02 29.99,30.18 30.12,30.05 30.53,30.05 30.65,30.18 30.65,30.79 30.78,30.92 31.06,30.92 31.19,30.79 31.19,30.56 31.32,30.43 31.57,30.43 31.7,30.56 31.7,30.79 31.82,30.92 34.26,30.92 35.32,31.97 36.33,31.97 36.34,31.96 36.35,31.96 36.6,31.71 36.6,31.7 v10(36.78,31.53) 37.03,31.78 37.69,31.78 37.82,31.65 37.82,30.86 37.94,30.74 39.37,30.74 39.49,30.86 39.49,31.17 39.62,31.3 40.76,31.3 41.04,31.02 41.04,30.81 40.48,30.25 40.48,29.72 40.41,29.65 40.13,29.65 40,29.52 40,29.04 40.13,28.91 40.79,28.91 40.94,28.76 40.94,28.17 41.07,28.04 41.35,28.04 41.42,28.12 41.42,29.9 41.7,30.18 41.7,30.79 41.83,30.92 42.11,30.92 42.24,30.79 42.24,30.56 42.36,30.43 42.62,30.43 42.75,30.56 42.75,30.79 42.87,30.92 45.31,30.92 46.36,31.97 47.38,31.97 47.39,31.96 47.65,31.71 47.65,31.7 v10(47.83,31.53) 48.08,31.78 48.74,31.78 48.87,31.65 48.87,31 48.99,30.87 49.33,30.87 49.46,31 49.46,31.17 49.59,31.29 49.84,31.29 49.97,31.17 49.97,30.94 50.1,30.81 50.42,30.81 50.54,30.94 50.54,31.17 50.67,31.3 51.81,31.3 52.09,31.02 52.09,30.18 52.22,30.05 52.63,30.05 52.75,30.18 52.75,30.79 52.88,30.92 53.16,30.92 53.29,30.79 53.29,30.56 53.41,30.43 53.67,30.43 53.79,30.56 53.79,30.79 53.92,30.92 56.36,30.92 57.41,31.97 58.43,31.97 58.44,31.96 58.44,31.96 58.7,31.71 58.7,31.7 v10(58.87,31.53) 58.88,31.53 59.87,32.52 62.49,32.52 63.3,31.7 65.75,31.7 65.81,31.76 66.12,31.76 66.25,31.89 66.25,32.25 66.38,32.38 66.45,32.38 66.58,32.51 66.58,32.76 66.45,32.89 66.38,32.89 66.26,33.01 66.26,33.27 66.38,33.4 66.45,33.4 66.58,33.52 66.58,33.78 66.45,33.9 66.38,33.9 66.26,34.03 66.26,34.28 66.38,34.41 66.45,34.41 66.58,34.54 66.58,35.06 65.91,35.72 65.91,36.23 65.67,36.47 65.67,36.47 65.56,36.58 65.56,37.86 65.68,37.99 66.25,37.99 66.38,38.12 66.38,38.37 66.25,38.5 65.68,38.5 65.56,38.63 65.56,39.97 65.95,40.36 65.95,41.6 66.02,41.68 66.3,41.68 66.43,41.55 66.43,41.29 66.56,41.16 66.83,41.16 66.96,41.29 66.96,41.54 67.09,41.67 67.27,41.67 67.39,41.54 v4(67.39,41.49)
  IN2 w0.122: v4(67.39,41.49) 67.55,41.65 67.55,42.19 67.28,42.46 67.28,42.67 64.17,45.78 60.41,45.78 60.28,45.91 60.28,46.39 60.15,46.52 58.88,46.52 58.76,46.39 58.76,45.91 58.63,45.78 55.3,45.78 55.18,45.91 55.18,46.24 55.3,46.37 57.13,46.37 57.41,46.65 57.61,46.65 57.89,46.37 58.1,46.37 58.22,46.49 58.22,46.98 58.35,47.1 59.44,47.1 59.57,47.23 59.57,47.56 59.44,47.69 57.54,47.69 56.8,46.95 56.5,46.95 56.1,47.34 56.1,47.52 57.18,48.6 57.18,49.16 57.3,49.28 58.15,49.28 58.27,49.41 58.27,49.75 58.15,49.87 57.28,49.87 57.16,50 57.16,50.84 57.03,50.97 56.34,50.97 56.22,51.09 56.22,52.03 56.04,52.21 55.53,52.21 55.4,52.34 55.4,52.67 55.53,52.79 56.88,52.79 57.01,52.67 57.01,52.33 57.2,52.14 58.4,52.14 58.52,52.26 58.52,52.69 58.65,52.81 63.81,52.81 64.63,51.99 64.96,51.99 65.18,52.21 65.45,52.21 65.67,51.99 65.94,51.99 66.16,52.21 66.43,52.21 66.64,51.99 66.86,51.99 67.77,52.91 68.39,52.91 69.08,52.21 69.71,52.21 70.16,52.67 70.16,54.32 69.48,55.01 66.54,55.01 66.39,55.16 66.39,55.55 66.56,55.71 67.24,55.71 67.37,55.84 67.37,56.27 67.24,56.4 66.99,56.4 66.86,56.53 66.86,56.86 66.99,56.99 v4(67.96,56.99)
  IN4 w0.091: v5(67.47,57.1) 67.84,57.1 v4(67.96,56.99)
  GND5 w0.102: v6(67.05,57.1) v5(67.47,57.1)
  BOTTOM w0.076: v10(25.73,31.53) 25.93,31.73 27.12,31.73 27.25,31.6 27.25,31.41 27.12,31.28 26.88,31.28 UD15.K3 ; v10(47.83,31.53) 48.03,31.73 49.22,31.73 49.35,31.6 49.35,31.41 49.22,31.28 48.98,31.28 UD11.K3 ; v10(58.87,31.53) 59.08,31.73 60.27,31.73 60.4,31.6 60.4,31.41 60.27,31.28 UD9.K3 ; v10(36.78,31.53) 36.98,31.73 38.17,31.73 38.3,31.6 38.3,31.41 38.17,31.28 UD13.K3
  BOTTOM w0.16: UCPU1.BF32 67.03,57.12 v6(67.05,57.1)
DDR_B_MA1: length 167
  TOP w0.076: UD10.L7 59.99,30.48 59.21,29.7 59.1,29.59 58.54,29.59 v10(58.14,29.19) ; v10(47.09,29.19) 47.5,29.59 48.06,29.59 48.16,29.7 48.94,30.48 UD12.L7 ; UD14.L7 37.89,30.48 37.11,29.7 37.01,29.59 36.45,29.59 v10(36.04,29.19) ; v10(24.99,29.19) 25.4,29.59 25.96,29.59 26.06,29.7 26.84,30.48 UD16.L7
  IN1 w0.091: v8(18.88,27.39) 19.79,28.31 23.17,28.31 24.05,29.19 v10(24.99,29.19) 24.99,29.14 24.99,29.14 24.99,28.91 25.14,28.76 26.25,28.76 26.51,28.5 26.51,27.39 26.87,27.03 27.15,27.03 27.28,27.16 27.28,27.41 27.4,27.54 27.66,27.54 27.78,27.41 27.78,27.16 27.91,27.03 28.17,27.03 28.29,27.16 28.29,27.41 28.42,27.54 28.67,27.54 28.8,27.41 28.8,27.16 28.93,27.03 29.18,27.03 29.31,27.16 29.31,27.37 29.44,27.5 29.69,27.5 29.82,27.37 29.82,27.16 29.94,27.03 33.73,27.03 33.84,27.14 33.84,27.45 35.58,29.19 v10(36.04,29.19) 36.04,29.14 36.04,28.91 36.19,28.76 37.29,28.76 37.54,28.5 37.54,28.5 37.56,28.48 37.56,27.39 38.55,26.39 38.55,24.68 38.68,24.55 39.04,24.55 39.16,24.68 39.16,26.28 39.29,26.4 39.62,26.4 39.75,26.28 39.75,25.17 39.87,25.05 44.93,25.05 45.09,25.21 45.09,27.65 46.63,29.19 v10(47.09,29.19) 47.09,29.14 47.09,29.14 47.09,28.91 47.24,28.76 48.35,28.76 48.61,28.5 48.61,27.39 48.97,27.03 49.25,27.03 49.37,27.16 49.37,27.41 49.5,27.54 49.76,27.54 49.88,27.41 49.88,27.16 50.01,27.03 50.26,27.03 50.39,27.16 50.39,27.41 50.52,27.54 50.77,27.54 50.9,27.41 50.9,27.16 51.03,27.03 51.28,27.03 51.41,27.16 51.41,27.37 51.53,27.5 51.79,27.5 51.91,27.37 51.91,27.16 52.04,27.03 55.52,27.03 57.68,29.19 v10(58.14,29.19) 58.14,29.14 58.14,28.91 58.29,28.76 59.13,28.76 59.2,28.83 60.82,28.83 61.14,28.51 61.14,27.2 62.47,25.87 64.93,25.87 65.13,26.07 65.13,26.65 65.42,26.94 66.09,26.94 67.15,25.87 67.6,25.87 68.13,26.4 68.13,27.51 68.38,27.76 68.38,29.56 67.98,29.97 67.98,34.86 68.36,35.24 68.36,38.07 68.36,38.07 68.36,38.53 68.21,38.68 68.21,39.52 68.32,39.64 68.32,40.39 68.12,40.59 67.53,40.59 67.27,40.86 v4(67.14,40.86)
  IN2 w0.122: v4(66.38,57.71) 66.36,57.71 65.91,57.26 65.91,56.93 66.12,56.72 66.12,55.05 66.43,54.73 69.36,54.73 69.88,54.21 69.88,52.78 69.59,52.49 69.2,52.49 68.51,53.18 67.66,53.18 67.02,52.54 64.46,52.54 63.92,53.08 58.36,53.08 58.25,52.97 58.25,52.59 58.07,52.41 57.44,52.41 57.28,52.57 57.28,52.87 57.07,53.08 54.36,53.08 54.24,52.96 54.24,52.62 54.36,52.49 55,52.49 55.13,52.36 55.13,52.06 55.25,51.93 55.82,51.93 55.94,51.8 55.94,51.5 55.82,51.37 55.02,51.37 54.9,51.24 54.9,50.99 55.02,50.86 55.89,50.86 56.07,50.69 56.76,50.69 56.88,50.56 56.88,49.87 56.76,49.75 55.96,49.75 55.84,49.62 55.84,49.29 55.96,49.16 56.7,49.16 56.9,48.96 56.9,48.71 55.83,47.64 55.83,47.23 56.06,47 56.06,46.79 55.91,46.64 55.19,46.64 54.89,46.34 54.89,45.8 55.18,45.51 64.05,45.51 66.96,42.6 66.96,41.03 v4(67.14,40.86)
  IN4 w0.091: v5(66.58,58.16) 66.58,57.91 v4(66.38,57.71)
  GND5 w0.102: v5(66.58,58.16) 66.28,58.16 66.22,58.09 v6(66.06,58.09)
  BOTTOM w0.076: UD15.L7 23.58,30.48 23.47,30.36 23.47,30.2 23.58,30.08 23.74,30.08 24.71,29.11 24.91,29.11 v10(24.99,29.19) ; v10(47.09,29.19) 47.01,29.11 46.81,29.11 45.84,30.08 45.68,30.08 45.56,30.2 45.56,30.36 45.68,30.48 UD11.L7 ; UD13.L7 34.73,30.48 34.63,30.48 34.52,30.36 34.52,30.2 34.63,30.08 34.79,30.08 35.76,29.11 35.96,29.11 v10(36.04,29.19) ; v10(58.14,29.19) 58.06,29.11 57.86,29.11 56.89,30.08 56.73,30.08 56.61,30.2 56.61,30.36 56.73,30.48 56.82,30.48 UD9.L7
  BOTTOM w0.16: v8(18.88,27.39) 18.19,27.39 R1055.1 ; UCPU1.BE33 66.26,57.89 v6(66.06,58.09)
DDR_B_MA2: length 172.3
  TOP w0.076: v10(35.51,30.41) 35.51,30.18 35.66,30.03 35.9,30.03 36.09,29.84 36.09,29.65 36.01,29.57 35.67,29.57 35.07,30.17 35.07,30.35 34.95,30.48 34.73,30.48 UD14.L3 ; v10(57.6,30.41) 57.6,30.18 57.76,30.03 58,30.03 58.19,29.84 58.19,29.65 58.11,29.57 57.77,29.57 57.17,30.17 57.17,30.35 57.05,30.48 56.83,30.48 UD10.L3 ; v10(46.56,30.41) 46.56,30.18 46.71,30.03 46.95,30.03 47.14,29.84 47.14,29.65 47.06,29.57 46.72,29.57 46.12,30.17 46.12,30.35 46,30.48 45.78,30.48 UD12.L3 ; UD16.L3 23.68,30.48 23.9,30.48 24.03,30.35 24.03,30.17 24.62,29.57 24.97,29.57 25.04,29.65 25.04,29.84 24.85,30.03 24.61,30.03 24.46,30.18 v10(24.46,30.41)
  TOP w0.16: R1051.1 v2(17.8,28.84)
  GND1 w0.102: v2(17.8,28.84) 17.8,28.46 17.88,28.38 v3(17.91,28.38)
  IN1 w0.091: v3(17.91,28.38) 18.19,28.11 18.94,28.11 19.71,28.87 22.56,28.87 24.1,30.41 v10(24.46,30.41) 24.46,30.03 24.56,29.92 25.57,29.92 26.1,29.39 26.44,29.39 26.57,29.52 26.57,29.65 26.69,29.77 27.05,29.77 27.17,29.65 27.17,28.43 27.3,28.3 28.34,28.3 28.44,28.4 28.44,28.76 28.62,28.93 29.79,28.93 30.02,28.71 30.02,28.38 30.07,28.32 33.83,28.32 34.29,28.78 34.29,29.44 34.44,29.59 34.93,29.59 35.06,29.72 35.06,30.28 35.19,30.41 v10(35.51,30.41) 35.51,30.03 35.61,29.92 36.62,29.92 37.02,29.52 37.03,29.52 37.16,29.39 37.49,29.39 37.61,29.52 37.61,29.65 37.74,29.77 38.1,29.77 38.22,29.65 38.22,27.64 38.68,27.18 40.01,27.18 40.73,26.47 42.16,26.47 42.29,26.6 42.29,27.44 42.41,27.56 42.67,27.56 42.8,27.44 42.8,26.6 42.92,26.47 43.18,26.47 43.3,26.6 43.3,27.32 43.43,27.44 43.68,27.44 43.81,27.32 43.81,26.6 43.94,26.47 44.19,26.47 44.32,26.6 44.32,27.77 45.34,28.78 45.34,29.42 45.51,29.59 45.74,29.59 v10(46.56,30.41) 46.56,30.03 46.66,29.92 47.67,29.92 48.07,29.52 48.08,29.52 48.21,29.39 48.54,29.39 48.66,29.52 48.66,29.65 48.79,29.77 49.15,29.77 49.27,29.65 49.27,28.43 49.4,28.3 50.44,28.3 50.54,28.4 50.54,28.76 50.72,28.93 51.89,28.93 52.12,28.71 52.12,28.38 52.17,28.32 55.93,28.32 56.38,28.78 56.38,29.44 56.54,29.59 57.03,29.59 57.16,29.72 57.16,30.28 57.28,30.41 v10(57.6,30.41) 57.6,30.33 58,29.93 58.66,29.93 58.7,29.9 59.25,29.9 59.59,29.57 61.26,29.57 61.45,29.38 62.74,29.38 63.1,29.01 63.1,28.16 62.9,27.95 61.98,27.95 61.84,27.81 61.84,27.3 62.71,26.43 64.4,26.43 64.57,26.61 64.57,26.88 65.19,27.5 66.3,27.5 66.63,27.83 66.63,29.8 67.42,30.58 67.42,35.1 67.8,35.48 67.8,38.24 67.55,38.49 67.27,38.49 66.98,38.79 66.15,38.79 65.9,39.03 65.9,39.69 66.35,40.14 66.63,40.14 66.64,40.14 66.64,40.15 v4(66.68,40.15)
  IN2 w0.122: v4(67.08,58.98) 66.72,58.98 65.63,57.89 65.63,56.72 65.84,56.51 65.84,54.94 66.32,54.46 69.25,54.46 69.55,54.16 69.55,53.68 69.32,53.45 67.55,53.45 66.91,52.82 64.57,52.82 64.04,53.36 54.19,53.36 53.95,53.12 53.95,52.51 54.25,52.21 54.72,52.21 54.85,52.09 54.85,51.78 54.72,51.65 54.36,51.65 54.26,51.55 54.26,51.36 54.61,51.01 54.61,50.77 54.79,50.59 55.13,50.59 55.25,50.46 55.25,50.23 55.56,49.92 55.56,49.01 55.68,48.89 56.01,48.89 56.17,48.73 56.17,48.37 55.89,48.09 53.86,48.09 53.73,47.97 53.73,47.64 53.86,47.51 55.38,47.51 55.51,47.38 55.51,47.05 55.38,46.93 54.74,46.93 54.61,46.8 54.61,45.46 54.84,45.23 63.94,45.23 66.68,42.49 v4(66.68,40.15)
  IN4 w0.091: v5(66.42,58.54) 66.86,58.98 v4(67.08,58.98)
  GND5 w0.102: v6(66.38,58.98) 66.38,58.59 v5(66.42,58.54)
  BOTTOM w0.076: v10(24.46,30.41) 24.46,30.15 24.73,29.87 26.27,29.87 UD15.L3 ; UD9.L3 59.42,29.87 57.88,29.87 57.6,30.15 v10(57.6,30.41) ; v10(35.51,30.41) 35.51,30.15 35.78,29.87 37.32,29.87 UD13.L3 ; v10(46.56,30.41) 46.56,30.15 46.83,29.87 48.37,29.87 UD11.L3
  BOTTOM w0.16: UCPU1.BD33 v6(66.38,58.98)
DDR_B_MA3: length 179.4
  TOP w0.076: UD14.K2 33.93,31.28 34.25,31.28 34.72,30.81 36.55,30.81 36.78,30.58 v10(36.78,30.33) ; v10(25.73,30.33) 25.73,30.58 25.5,30.81 23.67,30.81 23.2,31.28 22.88,31.28 UD16.K2 ; UD12.K2 44.98,31.28 45.3,31.28 45.77,30.81 47.6,30.81 47.83,30.58 v10(47.83,30.33) ; v10(58.87,30.33) 58.87,30.58 58.65,30.81 56.82,30.81 56.35,31.28 56.03,31.28 UD10.K2
  IN2 w0.122: v4(67.54,61.75) 67.58,61.75 68.16,61.17 68.16,59.14 68.96,58.34 69.75,58.34 71.82,56.27 71.82,55.44 71.97,55.28 72.81,55.28 73.01,55.08 73.01,54.83 72.85,54.67 71.97,54.67 71.84,54.55 71.84,54.22 71.97,54.09 73.1,54.09 73.54,53.65 73.54,50.51 73.41,50.38 73.08,50.38 72.96,50.51 72.96,53.38 72.83,53.51 72.5,53.51 72.37,53.38 72.37,50.04 72.73,49.68 72.73,44.72 72.85,44.59 73.18,44.59 73.31,44.72 73.31,48.5 73.44,48.63 73.78,48.63 73.91,48.5 73.91,44.49 73.7,44.28 73.7,43.91 73.31,43.51 72.98,43.51 72.85,43.64 72.85,43.88 72.73,44.01 72.27,44.01 72.14,44.13 72.14,47.61 72.02,47.74 71.69,47.74 71.56,47.61 71.56,44.13 71.43,44.01 70.49,44.01 70.37,43.88 70.37,43.55 70.49,43.42 72.09,43.42 72.22,43.29 72.22,42.96 72.09,42.84 70.49,42.84 70.37,42.71 70.37,42.38 70.49,42.25 71.55,42.25 71.68,42.13 71.68,41.69 71.49,41.5 70.76,41.5 70.5,41.24 69.43,41.24 69.27,41.08 69.27,40.15 67.63,38.51 67.26,38.51 66.98,38.78 66.64,38.78 66.63,38.77 66.62,38.77 66.02,38.17 66.02,37.28 65.92,37.19 65.92,37.18 65.07,36.33 65.07,35.87 65.32,35.62 65.56,35.62 65.62,35.57 67.42,35.57 67.55,35.44 67.55,35.1 67.42,34.98 66.12,34.98 66,34.85 66,34.51 66.12,34.38 66.3,34.38 66.43,34.25 66.43,33.97 65.97,33.52 65.97,32.8 65.59,32.42 v4(65.43,32.42)
  IN3 w0.122: v7(18.47,32.98) 19.03,32.98 19.41,32.6 19.95,32.6 21.37,31.18 23.02,31.18 24.22,29.98 25.37,29.98 v10(25.73,30.33) 26.31,30.33 26.43,30.21 26.43,29.61 26.56,29.49 26.8,29.49 26.92,29.61 26.92,30.21 27.04,30.33 28.32,30.33 28.39,30.25 28.39,29.72 28.55,29.57 29.36,29.57 29.49,29.7 29.49,30.28 30.2,30.99 30.5,30.99 30.62,30.87 30.62,30.23 30.75,30.1 30.98,30.1 31.11,30.23 31.11,30.71 31.23,30.84 31.55,30.84 31.72,30.66 34.57,30.66 35.25,29.98 36.42,29.98 v10(36.78,30.33) 36.78,30.09 36.9,29.96 37.29,29.96 37.5,30.17 37.5,30.85 37.63,30.98 37.86,30.98 37.99,30.85 37.99,30.45 38.11,30.33 38.35,30.33 38.48,30.45 38.48,30.85 38.6,30.98 38.84,30.98 38.96,30.85 38.96,30.49 39.09,30.37 39.35,30.37 39.48,30.49 39.48,31.15 39.66,31.33 40.7,31.33 41.19,30.84 41.58,30.84 41.71,30.96 41.71,31.21 41.83,31.33 42.07,31.33 42.19,31.21 42.19,30.96 42.32,30.84 42.56,30.84 42.68,30.96 42.68,31.21 42.8,31.33 43.05,31.33 43.17,31.21 43.17,30.96 43.29,30.84 43.94,30.84 44.2,31.1 44.2,31.92 44.33,32.04 44.74,32.04 44.87,31.92 44.87,30.95 45,30.82 45.23,30.82 45.36,30.95 45.36,31.72 45.48,31.84 45.95,31.84 46.07,31.71 46.07,30.1 46.2,29.98 47.47,29.98 v10(47.83,30.33) 48.41,30.33 48.53,30.21 48.53,29.61 48.65,29.49 48.9,29.49 49.02,29.61 49.02,30.21 49.14,30.33 50.41,30.33 50.49,30.25 50.49,29.72 50.64,29.57 51.46,29.57 51.58,29.7 51.58,30.28 52.3,30.99 52.6,30.99 52.72,30.87 52.72,30.23 52.84,30.1 53.08,30.1 53.21,30.23 53.21,30.71 53.33,30.84 53.65,30.84 53.82,30.66 56.66,30.66 57.35,29.98 58.52,29.98 v10(58.87,30.33) 59.62,29.59 59.62,28.84 61.2,27.26 64.52,27.26 64.75,27.49 64.75,31.49 65.19,31.93 65.19,31.94 65.43,32.18 v4(65.43,32.42)
  IN4 w0.091: v5(67.47,62.27) 67.54,62.2 v4(67.54,61.75)
  GND5 w0.102: v5(67.47,62.27) 67.63,62.11 v6(67.89,62.11)
  BOTTOM w0.076: v10(25.73,30.33) 25.73,30.41 26.12,30.8 27.99,30.8 28.11,30.92 28.11,31.15 27.99,31.28 27.68,31.28 UD15.K2 ; v10(36.78,30.33) 36.78,30.41 37.16,30.8 39.04,30.8 39.16,30.92 39.16,31.15 39.04,31.28 UD13.K2 ; v10(58.87,30.33) 58.87,30.41 59.26,30.8 61.14,30.8 61.26,30.92 61.26,31.15 61.13,31.28 UD9.K2 ; v10(47.83,30.33) 47.83,30.41 48.21,30.8 50.09,30.8 50.21,30.92 50.21,31.15 50.09,31.28 49.78,31.28 UD11.K2
  BOTTOM w0.16: v7(18.47,32.98) 18.35,33.11 R1061.1 ; UCPU1.AU30 67.57,61.79 v6(67.89,62.11)
DDR_B_MA4: length 180
  TOP w0.076: v10(25.6,29.19) 25.93,29.19 26.75,30.01 27.14,30.01 27.25,30.12 27.25,30.66 27.45,30.86 27.85,30.86 27.96,30.75 27.96,30.59 27.85,30.48 UD16.L8 ; UD14.L8 38.9,30.48 39.01,30.59 39.01,30.75 38.9,30.86 38.5,30.86 38.3,30.66 38.3,30.12 38.19,30.01 37.8,30.01 36.98,29.19 v10(36.65,29.19) ; v10(58.75,29.19) 59.08,29.19 59.9,30.01 60.29,30.01 60.4,30.12 60.4,30.66 60.6,30.86 61,30.86 61.11,30.75 61.11,30.59 61,30.48 UD10.L8 ; v10(47.7,29.19) 48.03,29.19 48.85,30.01 49.24,30.01 49.35,30.12 49.35,30.66 49.55,30.86 49.95,30.86 50.06,30.75 50.06,30.59 49.95,30.48 UD12.L8
  TOP w0.16: R1049.1 18.19,27.39 v2(18.37,27.57)
  GND1 w0.102: v3(17.99,27.83) 18.24,27.57 v2(18.37,27.57)
  IN1 w0.091: v3(17.99,27.83) 18.99,27.83 19.75,28.59 22.84,28.59 23.88,29.63 25.29,29.63 25.6,29.31 v10(25.6,29.19) 25.7,29.09 26.71,29.09 26.83,28.97 26.83,28.08 26.92,27.99 30.06,27.99 30.17,27.89 30.17,27.54 30.3,27.41 30.6,27.41 30.73,27.54 30.73,27.92 30.86,28.04 31.11,28.04 31.24,27.92 31.24,27.54 31.37,27.41 31.59,27.41 31.72,27.54 31.72,27.92 31.85,28.04 32.1,28.04 32.23,27.92 32.23,27.51 32.36,27.38 32.69,27.38 32.81,27.51 32.81,27.89 32.92,27.99 33.93,27.99 35.57,29.63 36.33,29.63 36.65,29.31 v10(36.65,29.19) 36.75,29.09 37.39,29.09 37.88,28.59 37.88,27.47 38.55,26.8 39.77,26.8 40.1,26.47 40.1,25.48 40.23,25.35 40.54,25.35 40.66,25.48 40.66,26.01 40.79,26.14 41.22,26.14 41.35,26.01 41.35,25.5 41.48,25.37 41.91,25.37 42.03,25.5 42.03,26.05 42.16,26.17 42.57,26.17 42.69,26.05 42.69,25.54 42.82,25.41 43.2,25.41 43.33,25.54 43.33,26.04 43.46,26.17 43.89,26.17 44.02,26.04 44.02,25.57 44.14,25.44 44.6,25.44 44.73,25.57 44.73,27.74 46.62,29.63 47.38,29.63 47.7,29.31 v10(47.7,29.19) 47.8,29.09 48.81,29.09 48.93,28.97 48.93,28.08 49.02,27.99 52.16,27.99 52.27,27.89 52.27,27.54 52.4,27.41 52.7,27.41 52.83,27.54 52.83,27.92 52.96,28.04 53.21,28.04 53.34,27.92 53.34,27.54 53.46,27.41 53.69,27.41 53.82,27.54 53.82,27.92 53.95,28.04 54.2,28.04 54.33,27.92 54.33,27.51 54.45,27.38 54.78,27.38 54.91,27.51 54.91,27.89 55.01,27.99 56.03,27.99 57.69,29.65 58.28,29.65 58.74,29.19 v10(58.75,29.19) 61.02,29.19 61.48,28.73 61.48,27.26 62.59,26.15 64.68,26.15 64.85,26.33 64.85,26.76 65.31,27.22 66.2,27.22 67.27,26.15 67.45,26.15 67.77,26.48 67.77,26.66 66.91,27.52 66.91,29.68 67.7,30.47 67.7,34.98 68.08,35.36 68.08,38.19 68.08,38.19 68.08,38.42 67.93,38.57 67.93,40.09 v4(67.85,40.17)
  IN2 w0.122: v4(67.85,40.17) 68.08,40.17 68.45,40.53 68.45,42.67 65.44,45.67 65.44,45.81 65.32,45.93 65.18,45.93 65.06,46.06 65.06,46.41 65.18,46.54 66.45,46.54 66.58,46.66 66.58,47 66.45,47.13 64.55,47.13 64.42,47.26 64.42,47.56 64.29,47.69 64.04,47.69 63.89,47.54 63.89,47.33 63.76,47.21 63.53,47.21 63.41,47.33 63.41,47.56 63.28,47.69 63.02,47.69 62.9,47.56 62.9,47.33 62.77,47.21 62.47,47.21 62.34,47.33 62.34,48.14 62.47,48.27 68.1,48.27 68.23,48.39 68.23,48.73 68.1,48.86 64.55,48.86 64.42,48.98 64.42,49.21 64.22,49.41 62.41,49.41 62.29,49.54 62.29,49.86 62.41,49.99 67.72,49.99 67.85,50.12 67.85,50.46 67.72,50.58 63.38,50.58 63.25,50.71 63.25,51.04 63.38,51.17 67.7,51.17 67.83,51.3 67.83,51.73 68,51.9 68.21,51.9 68.41,51.7 68.41,51.52 68.54,51.39 70.05,51.39 70.98,52.33 70.98,55.94 69.79,57.14 68.74,57.14 68.11,57.78 68.11,58.11 67.67,58.54 v4(67.64,58.54)
  IN4 w0.091: v4(67.64,58.54) 68.06,58.54 v5(68.13,58.61)
  GND5 w0.102: v5(68.13,58.61) 68.02,58.5 v6(68.02,58.21)
  BOTTOM w0.076: v10(58.75,29.19) 58.34,29.59 57.75,29.59 57.16,30.18 57.16,30.59 56.91,30.84 56.21,30.84 56.02,30.66 56.03,30.66 UD9.L8 ; UD13.L8 33.93,30.66 33.93,30.66 34.11,30.84 34.81,30.84 35.06,30.59 35.06,30.18 35.65,29.59 36.24,29.59 v10(36.65,29.19) ; v10(47.7,29.19) 47.29,29.59 46.7,29.59 46.11,30.18 46.11,30.59 45.86,30.84 45.16,30.84 44.98,30.66 UD11.L8 ; UD15.L8 22.88,30.66 23.06,30.84 23.77,30.84 24.01,30.59 24.01,30.18 24.6,29.59 25.19,29.59 v10(25.6,29.19)
  BOTTOM w0.16: UCPU1.BD30 v6(68.02,58.21)
DDR_B_MA5: length 182.5
  TOP w0.076: UD12.L2 44.93,30.53 44.93,30.76 45.06,30.89 45.21,30.89 45.41,30.69 45.41,30.13 45.54,30 45.91,30 46.65,29.27 46.65,29.01 46.65,28.56 v10(46.89,28.32) ; v10(35.84,28.32) 35.6,28.56 35.6,29.01 35.6,29.27 34.87,30 34.49,30 34.36,30.13 34.36,30.69 34.16,30.89 34.01,30.89 33.88,30.76 33.88,30.53 UD14.L2 ; v10(24.79,28.32) 24.55,28.56 24.55,29.01 24.55,29.27 23.82,30 23.44,30 23.31,30.13 23.31,30.69 23.11,30.89 22.96,30.89 22.83,30.76 22.83,30.53 UD16.L2 ; UD10.L2 55.98,30.53 55.98,30.76 56.11,30.89 56.26,30.89 56.46,30.69 56.46,30.13 56.59,30 56.96,30 57.7,29.27 57.7,29.01 57.7,28.41 57.78,28.32 v10(57.93,28.32)
  IN2 w0.122: v4(67.54,61.17) 67.88,60.83 67.88,58.99 68.83,58.03 69.67,58.03 71.54,56.16 71.54,53.81 71.67,53.68 71.97,53.68 72.1,53.56 72.1,53.1 71.97,52.97 71.66,52.97 71.53,52.84 71.53,52.51 71.66,52.39 71.97,52.39 72.1,52.26 72.1,51.93 71.97,51.8 71.25,51.8 71.13,51.68 71.13,51.35 71.25,51.22 71.97,51.22 72.09,51.09 72.09,50.76 71.97,50.63 71.41,50.63 71.28,50.51 71.28,50.18 71.41,50.05 71.97,50.05 72.45,49.57 72.45,48.15 72.33,48.02 71.99,48.02 71.86,48.15 71.86,49.34 71.74,49.47 71.41,49.47 71.39,49.44 68.92,49.44 68.79,49.31 68.79,48.98 68.92,48.85 70.99,48.85 71.28,48.55 71.28,47.84 71.16,47.71 67.27,47.71 67.14,47.59 67.14,47.25 67.27,47.12 70.99,47.12 71.28,46.83 71.28,46.11 71.16,45.99 66.68,45.99 66.56,45.86 66.56,45.52 66.68,45.4 70.99,45.4 71.28,45.1 71.28,44.41 71.16,44.28 70.38,44.28 70.09,43.99 70.09,42.15 70.42,41.82 70.42,41.62 70.31,41.52 69.6,41.52 69.5,41.62 69.5,44.16 69.37,44.28 68.21,44.28 68.1,44.18 68.1,43.83 68.23,43.7 68.8,43.7 68.99,43.5 68.99,40.31 68.36,39.67 68.35,39.67 67.62,38.94 v4(67.47,38.94)
  IN3 w0.122: v7(18.47,30.01) 18.89,30.42 19.38,30.42 21.38,28.43 24.69,28.43 v10(24.79,28.32) 25.65,27.46 26.7,27.46 26.82,27.34 26.82,27 26.95,26.88 27.18,26.88 27.31,27 27.31,27.43 27.44,27.56 27.67,27.56 27.8,27.43 27.8,27.05 27.92,26.93 28.16,26.93 28.28,27.05 28.28,27.34 28.41,27.46 30.43,27.46 30.55,27.59 30.55,28.1 30.68,28.22 31.77,28.22 31.92,28.06 31.92,27.59 32.05,27.46 33.91,27.46 34.03,27.59 34.03,28.3 34.16,28.43 34.43,28.43 34.56,28.55 34.56,28.71 34.68,28.83 34.92,28.83 35.04,28.71 35.04,28.55 35.17,28.43 35.73,28.43 v10(35.84,28.32) 35.84,27.72 35.96,27.6 38.32,27.6 38.45,27.72 38.45,28.88 38.54,28.97 41.97,28.97 42.37,28.56 43.87,28.56 44,28.44 44,28.16 43.88,28.04 42.97,28.04 42.84,27.91 42.84,27.68 42.97,27.55 43.88,27.55 44,27.43 44,27.19 43.88,27.06 43.29,27.06 43.16,26.94 43.16,26.7 43.29,26.58 43.88,26.58 44,26.45 44,26.01 44.13,25.89 45.54,25.89 45.85,26.2 45.85,27.5 46.68,28.32 v10(46.89,28.32) 47.75,27.46 48.8,27.46 48.92,27.34 48.92,27 49.05,26.88 49.28,26.88 49.41,27 49.41,27.43 49.53,27.56 49.77,27.56 49.89,27.43 49.89,27.05 50.02,26.93 50.26,26.93 50.38,27.05 50.38,27.34 50.5,27.46 52.52,27.46 52.65,27.59 52.65,28.1 52.78,28.22 53.86,28.22 54.02,28.06 54.02,27.59 54.15,27.46 56,27.46 56.13,27.59 56.13,28.3 56.26,28.43 56.53,28.43 56.65,28.55 56.65,28.71 56.78,28.83 57.02,28.83 57.14,28.71 57.14,28.55 57.26,28.43 57.83,28.43 v10(57.93,28.32) 57.93,28.02 57.69,27.77 57.69,27.5 57.82,27.37 58.3,27.37 58.48,27.55 58.68,27.55 58.86,27.37 59.58,27.37 59.8,27.15 59.8,26.71 60.07,26.44 65.11,26.44 65.57,26.9 65.57,31.14 66.53,32.1 66.53,34.75 67.59,35.81 67.59,36.53 67.73,36.68 67.73,38.58 67.47,38.85 v4(67.47,38.94)
  IN4 w0.091: v5(67.49,60.64) 67.49,61.13 v4(67.54,61.17)
  GND5 w0.102: v6(67.89,60.81) 67.84,60.81 67.67,60.64 v5(67.49,60.64)
  BOTTOM w0.076: UD11.L2 49.37,30.08 48.92,30.08 48.11,29.26 48.11,28.81 48.03,28.73 47.19,28.73 46.89,28.43 v10(46.89,28.32) ; UD15.L2 27.27,30.08 26.82,30.08 26.01,29.26 26.01,28.81 25.93,28.73 25.09,28.73 24.79,28.43 v10(24.79,28.32) ; UD9.L2 60.42,30.08 59.97,30.08 59.16,29.26 59.16,28.81 59.08,28.73 58.05,28.73 57.93,28.62 v10(57.93,28.32) ; v10(35.84,28.32) 35.84,28.43 36.14,28.73 36.98,28.73 37.06,28.81 37.06,29.26 37.87,30.08 38.32,30.08 UD13.L2
  BOTTOM w0.16: v6(67.89,60.81) 67.56,61.14 UCPU1.AV30 ; R1067.1 18.04,30.44 v7(18.47,30.01)
DDR_B_MA6: length 187.9
  TOP w0.076: v10(26.24,26.95) 26.55,27.27 26.55,28.99 26.62,29.06 26.62,29.06 26.87,29.31 28.03,29.31 28.14,29.42 28.14,29.84 28.01,29.96 27.81,29.96 27.68,29.84 27.68,29.68 UD16.M8 ; UD14.M8 38.73,29.68 38.73,29.84 38.85,29.96 39.06,29.96 39.19,29.84 39.19,29.42 39.08,29.31 37.92,29.31 37.67,29.06 37.67,29.06 37.6,28.99 37.6,27.27 v10(37.28,26.95) ; UD10.M8 60.83,29.68 60.83,29.84 60.95,29.96 61.16,29.96 61.29,29.84 61.29,29.42 61.18,29.31 60.02,29.31 59.76,29.06 59.76,29.06 59.7,28.99 59.7,27.27 v10(59.38,26.95) ; UD12.M8 49.78,29.68 49.78,29.84 49.9,29.96 50.11,29.96 50.24,29.84 50.24,29.42 50.13,29.31 48.97,29.31 48.71,29.06 48.71,29.06 48.65,28.99 48.65,27.27 v10(48.33,26.95)
  TOP w0.16: v7(18.52,26.86) 18.16,26.86 R1047.1
  IN1 w0.091: v7(18.52,26.86) 18.96,26.86 19.16,27.06 20.02,27.06 20.86,27.9 25.29,27.9 v10(26.24,26.95) 27.17,26.01 27.6,26.01 27.73,26.14 27.73,26.58 27.85,26.71 28.11,26.71 28.23,26.58 28.23,26.14 28.36,26.01 28.61,26.01 28.74,26.14 28.74,26.56 28.87,26.68 29.12,26.68 29.25,26.56 29.25,26.14 29.38,26.01 29.63,26.01 29.76,26.14 29.76,26.39 30.01,26.65 34.21,26.65 34.36,26.8 34.36,27.5 34.73,27.87 36.94,27.87 37.07,27.74 37.07,27.08 37.19,26.95 v10(37.28,26.95) 37.53,26.95 38.22,26.26 38.22,24.9 38.1,24.77 36.29,24.77 36.17,24.64 36.17,24.34 36.29,24.21 39.67,24.21 40.15,24.69 45.34,24.69 45.49,24.84 45.49,27.57 45.78,27.87 47.51,27.87 48.33,27.05 v10(48.33,26.95) 48.64,26.65 56.31,26.65 56.46,26.8 56.46,27.5 56.83,27.87 59.38,27.87 59.82,28.31 60.59,28.31 60.71,28.18 60.71,27.57 60.59,27.44 59.87,27.44 v10(59.38,26.95) 59.71,26.62 61.33,26.62 62.36,25.59 65.29,25.59 65.41,25.72 65.41,26.53 65.54,26.66 65.97,26.66 67.04,25.59 67.72,25.59 68.41,26.28 68.41,27.39 68.66,27.65 68.66,29.68 68.26,30.08 68.26,34.75 68.64,35.13 68.64,37.51 68.64,37.51 68.64,37.96 68.64,37.96 68.64,38.65 68.6,38.69 68.6,39.52 68.6,40.54 68.13,41.01 v4(67.73,41.01)
  IN2 w0.122: v4(67.73,41.01) 67.83,41.1 67.83,42.3 67.56,42.57 67.56,42.78 64.28,46.05 60.85,46.05 60.57,46.34 60.57,47.55 60.85,47.84 61.65,47.84 61.78,47.96 61.78,48.3 61.65,48.43 60.66,48.43 60.41,48.17 60.18,48.17 59.93,48.43 59.62,48.43 59.49,48.3 59.49,48.09 59.37,47.97 59.04,47.97 58.91,48.09 58.91,48.3 58.78,48.43 58.45,48.43 58.33,48.3 58.33,48.09 58.2,47.97 57.87,47.97 57.74,48.09 57.74,48.88 57.87,49.01 58.43,49.01 58.55,49.14 58.55,49.44 58.68,49.56 61.3,49.56 61.42,49.69 61.42,50.03 61.3,50.15 59.8,50.15 59.67,50.28 59.67,50.69 59.54,50.81 59.21,50.81 59.09,50.69 59.09,50.27 58.96,50.15 57.56,50.15 57.44,50.27 57.44,50.58 57.56,50.71 58.4,50.71 58.53,50.84 58.53,51.14 58.4,51.27 56.62,51.27 56.5,51.4 56.5,51.74 56.62,51.86 58.69,51.86 59.36,52.53 63.67,52.53 63.96,52.25 63.96,51.86 64.1,51.72 67.13,51.72 67.25,51.83 67.25,51.99 67.89,52.63 68.28,52.63 68.97,51.94 69.82,51.94 70.44,52.56 70.44,54.44 69.78,55.09 69.78,55.49 70.12,55.83 70.12,56.01 69.8,56.33 69.62,56.33 68.58,55.28 68.3,55.28 67.77,55.81 67.77,56.08 v4(68.03,56.34)
  IN4 w0.091: v4(68.03,56.34) 67.33,56.34 v5(67.29,56.3)
  GND5 w0.102: v6(67.52,56.68) 67.52,56.53 v5(67.29,56.3)
  BOTTOM w0.076: UD13.M8 34.29,29.31 34.74,29.31 35.06,28.99 35.06,27.98 35.4,27.64 36.6,27.64 v10(37.28,26.95) ; v10(59.38,26.95) 58.7,27.64 57.5,27.64 57.16,27.98 57.16,28.99 56.84,29.31 56.39,29.31 UD9.M8 ; UD15.M8 23.24,29.31 23.69,29.31 24.01,28.99 24.01,27.98 24.36,27.64 25.55,27.64 v10(26.24,26.95) ; UD11.M8 45.34,29.31 45.79,29.31 46.11,28.99 46.11,27.98 46.45,27.64 47.65,27.64 v10(48.33,26.95)
  BOTTOM w0.16: v6(67.52,56.68) 67.59,56.75 UCPU1.BG30
DDR_B_MA7: length 194.6
  TOP w0.076: UD16.M2 22.88,29.68 22.83,29.63 22.83,29.47 22.96,29.34 23.69,29.34 23.99,29.04 23.99,28.65 23.86,28.53 23.58,28.53 23.45,28.4 23.45,28.09 23.54,27.99 23.87,27.99 23.99,27.88 23.99,27.68 23.87,27.56 23.61,27.56 23.49,27.44 23.49,27.24 23.61,27.12 24.48,27.12 24.49,27.11 24.81,27.11 v10(24.97,26.95) ; UD14.M2 33.93,29.68 33.88,29.63 33.88,29.47 34.01,29.34 34.74,29.34 35.04,29.04 35.04,28.65 34.91,28.53 34.63,28.53 34.5,28.4 34.5,28.09 34.59,27.99 34.92,27.99 35.04,27.88 35.04,27.68 34.92,27.56 34.66,27.56 34.54,27.44 34.54,27.24 34.66,27.12 35.53,27.12 35.54,27.11 35.86,27.11 v10(36.01,26.95) ; v10(47.06,26.95) 46.91,27.11 46.59,27.11 46.58,27.12 45.71,27.12 45.59,27.24 45.59,27.44 45.71,27.56 45.97,27.56 46.09,27.68 46.09,27.88 45.97,27.99 45.64,27.99 45.55,28.09 45.55,28.4 45.67,28.53 45.96,28.53 46.09,28.65 46.09,29.04 45.79,29.34 45.06,29.34 44.93,29.47 44.93,29.63 44.98,29.68 UD12.M2 ; v10(58.11,26.95) 57.96,27.11 57.64,27.11 57.63,27.12 56.76,27.12 56.63,27.24 56.63,27.44 56.76,27.56 57.02,27.56 57.14,27.68 57.14,27.88 57.02,27.99 56.69,27.99 56.6,28.09 56.6,28.4 56.72,28.53 57.01,28.53 57.14,28.65 57.14,29.04 56.84,29.34 56.11,29.34 55.98,29.47 55.98,29.63 56.03,29.68 UD10.M2
  IN1 w0.091: v7(18.47,25.72) 18.55,25.79 19.87,25.79 21.33,27.26 24.66,27.26 v10(24.97,26.95) 24.97,26.39 24.49,25.92 24.49,25.39 24.77,25.11 26.47,25.11 26.62,25.25 29.79,25.25 30.31,25.77 31.19,25.77 31.71,25.25 35.02,25.25 35.22,25.45 35.22,26.11 35,26.33 35,27.03 35.16,27.19 35.78,27.19 v10(36.01,26.95) 36.01,26.25 35.57,25.8 35.57,24.79 35.44,24.67 34.32,24.67 34.2,24.54 34.2,23.7 34.32,23.57 40.03,23.57 40.51,24.06 45.92,24.06 46.05,24.18 46.05,27.03 46.23,27.22 46.8,27.22 v10(47.06,26.95) 47.06,26.67 46.54,26.15 46.54,25.44 47.02,24.96 48.55,24.96 49.44,25.84 55.68,25.84 56.28,25.25 56.74,25.25 57.26,25.77 57.26,26.16 57.1,26.33 57.1,27.03 57.26,27.19 57.87,27.19 v10(58.11,26.95) 58.11,26.39 58.44,26.06 61.09,26.06 62.13,25.03 65.01,25.03 65.13,24.9 65.13,23.15 65.26,23.03 65.59,23.03 65.72,23.15 65.72,24.9 65.84,25.03 66.17,25.03 66.3,24.9 66.3,23.15 66.43,23.03 66.76,23.03 66.89,23.15 66.89,24.9 67.01,25.03 67.34,25.03 67.47,24.9 67.47,23.14 67.6,23.01 67.93,23.01 68.05,23.14 68.05,24.78 68.18,24.9 68.51,24.9 68.64,24.78 68.64,23.14 68.76,23.01 69.1,23.01 69.22,23.14 69.22,26.38 69.35,26.5 69.78,26.5 69.91,26.38 69.91,23.15 70.03,23.03 71.41,23.03 71.53,23.15 71.53,25.29 71.36,25.46 70.62,25.46 70.49,25.59 70.49,26.05 70.62,26.17 71.41,26.17 71.53,26.3 71.53,28.41 71.41,28.54 70.97,28.54 70.8,28.36 70.8,27.93 70.67,27.8 69.96,27.8 69.83,27.93 69.83,29.3 68.82,30.31 68.82,30.78 68.94,30.9 69.1,30.9 69.22,31.03 69.22,31.29 69.1,31.41 68.94,31.41 68.82,31.54 68.82,31.79 68.94,31.92 69.45,31.92 69.58,32.05 69.58,32.3 69.45,32.43 68.94,32.43 68.82,32.56 68.82,32.81 68.94,32.94 69.07,32.94 69.2,33.06 69.2,33.32 69.07,33.44 68.94,33.44 68.82,33.57 68.82,34.52 70,35.7 70,38.72 70.14,38.86 70.14,39.33 69.69,39.78 v4(69.69,40.24)
  IN2 w0.122: v4(69.69,40.24) 69.89,40.24 70.87,41.22 71.77,41.22 71.96,41.4 71.96,42.3 72.52,42.87 73.05,42.87 73.98,43.8 73.98,44.17 74.18,44.37 74.18,48.62 73.41,49.38 73.41,49.98 73.81,50.38 73.81,53.76 73.6,53.98 73.6,54.88 69.86,58.62 69.26,58.62 v4(69.14,58.73)
  IN4 w0.091: v4(69.14,58.73) 68.89,58.48 v5(68.61,58.48)
  GND5 w0.102: v5(68.61,58.48) 68.55,58.54 v6(68.55,58.93)
  BOTTOM w0.076: UD11.M2 49.35,29.25 48.91,29.25 48.66,29.01 48.66,28.75 49.07,28.35 49.07,26.75 48.87,26.55 47.42,26.55 47.06,26.9 v10(47.06,26.95) ; v10(24.97,26.95) 24.97,26.9 25.32,26.55 26.77,26.55 26.97,26.75 26.97,28.35 26.57,28.75 26.57,29.01 26.81,29.25 27.25,29.25 UD15.M2 ; UD13.M2 38.3,29.25 37.86,29.25 37.62,29.01 37.62,28.75 38.02,28.35 38.02,26.75 37.82,26.55 36.37,26.55 36.01,26.9 v10(36.01,26.95) ; UD9.M2 60.4,29.25 59.96,29.25 59.71,29.01 59.71,28.75 60.12,28.35 60.12,26.75 59.91,26.55 58.47,26.55 58.11,26.9 v10(58.11,26.95)
  BOTTOM w0.16: v7(18.47,25.72) 18.08,25.72 R1059.1 ; v6(68.55,58.93) 68.35,58.73 UCPU1.BD29
DDR_B_MA8: length 195.4
  TOP w0.076: v10(48.33,25.56) 48.39,25.62 49.66,25.62 49.73,25.68 49.73,26.01 49.6,26.14 49.48,26.14 49.35,26.27 49.35,26.41 49.46,26.52 49.67,26.52 49.78,26.63 49.78,26.77 49.65,26.9 49.48,26.9 49.35,27.03 49.35,27.28 49.48,27.41 49.6,27.41 49.73,27.54 49.73,27.79 49.6,27.92 49.48,27.92 49.35,28.04 49.35,28.3 49.48,28.43 49.65,28.43 49.78,28.55 49.78,28.88 UD12.N8 ; v10(59.38,25.56) 60.65,25.56 60.78,25.68 60.78,26.01 60.65,26.14 60.53,26.14 60.4,26.27 60.4,26.41 60.51,26.52 60.71,26.52 60.83,26.63 60.83,26.77 60.7,26.9 60.53,26.9 60.4,27.03 60.4,27.28 60.53,27.41 60.65,27.41 60.78,27.54 60.78,27.79 60.65,27.92 60.53,27.92 60.4,28.04 60.4,28.3 60.53,28.43 60.7,28.43 60.83,28.55 60.83,28.88 UD10.N8 ; v10(37.28,25.56) 38.55,25.56 38.68,25.68 38.68,26.01 38.55,26.14 38.43,26.14 38.3,26.27 38.3,26.41 38.41,26.52 38.62,26.52 38.73,26.63 38.73,26.77 38.6,26.9 38.43,26.9 38.3,27.03 38.3,27.28 38.43,27.41 38.55,27.41 38.68,27.54 38.68,27.79 38.55,27.92 38.43,27.92 38.3,28.04 38.3,28.3 38.43,28.43 38.6,28.43 38.73,28.55 38.73,28.88 UD14.N8 ; v10(26.24,25.56) 26.24,25.63 26.36,25.76 27.51,25.76 27.63,25.88 27.63,26.01 27.51,26.14 27.38,26.14 27.25,26.27 27.25,26.41 27.36,26.52 27.57,26.52 27.68,26.63 27.68,26.77 27.55,26.9 27.38,26.9 27.25,27.03 27.25,27.28 27.38,27.41 27.51,27.41 27.63,27.54 27.63,27.79 27.51,27.92 27.38,27.92 27.25,28.04 27.25,28.3 27.38,28.43 27.55,28.43 27.68,28.55 27.68,28.88 UD16.N8
  IN2 w0.122: v4(67.61,57.95) 67.54,58.03 67.16,58.03 67.05,57.91 67.05,57.58 67.19,57.44 68.05,57.44 68.74,56.76 69.78,56.76 70.71,55.83 70.71,55.48 70.62,55.38 70.62,54.76 70.71,54.67 70.71,52.44 69.93,51.67 68.86,51.67 68.16,52.36 68,52.36 67.52,51.88 67.52,51.57 67.39,51.44 63.81,51.44 63.68,51.57 63.68,52.13 63.56,52.26 63.23,52.26 63.1,52.13 63.1,51.52 62.97,51.4 62.64,51.4 62.52,51.52 62.52,52.13 62.39,52.26 62.06,52.26 61.93,52.13 61.93,51.52 61.81,51.4 61.48,51.4 61.35,51.52 61.35,52.13 61.22,52.26 59.72,52.26 59.6,52.13 59.6,51.78 59.72,51.65 60.38,51.65 60.51,51.52 60.51,50.55 60.64,50.43 61.14,50.43 61.27,50.55 61.27,50.69 61.4,50.81 62.85,50.81 62.97,50.69 62.97,50.39 62.85,50.26 62.11,50.26 61.98,50.14 61.98,49.85 61.42,49.29 58.96,49.29 58.83,49.16 58.83,48.83 58.96,48.7 61.65,48.7 62.08,49.14 64.02,49.14 64.14,49.01 64.14,48.68 64.02,48.55 62.34,48.55 62.06,48.27 62.06,47.69 61.93,47.56 60.97,47.56 60.84,47.43 60.84,46.46 60.97,46.33 61.32,46.33 61.45,46.46 61.45,46.85 61.58,46.98 61.93,46.98 62.06,46.85 62.06,46.46 62.19,46.33 62.52,46.33 62.64,46.46 62.64,46.8 62.77,46.93 64.02,46.93 64.15,46.8 64.15,46.58 67.83,42.9 67.83,42.77 68.17,42.43 68.17,40.85 67.91,40.59 67.66,40.59 67.28,40.21 67.28,40.25 v4(67.27,40.25)
  IN3 w0.122: v4(67.27,40.25) 67.28,40.24 67.28,40.16 67.43,40 67.43,40 67.68,39.75 67.68,39.75 67.75,39.69 67.83,39.69 68.01,39.5 68.01,36.56 67.87,36.42 67.87,35.69 66.81,34.64 66.81,32 65.84,31.03 65.84,26.78 65.22,26.16 59.99,26.16 v10(59.38,25.56) 58.63,26.31 57.29,26.31 57.08,26.51 57.08,27.85 56.95,27.98 56.55,27.98 56.42,27.85 56.42,27.27 56.26,27.11 53.75,27.11 53.65,27.21 53.65,27.8 53.52,27.93 53.12,27.93 52.99,27.8 52.99,27.23 52.86,27.11 50.96,27.11 50.44,26.58 48.75,26.58 48.33,26.17 v10(48.33,25.56) 47.59,26.3 46.4,26.3 45.65,25.56 42.99,25.56 42.88,25.67 42.88,26.91 42.53,27.27 42.53,27.88 42.4,28 41.83,28 41.7,27.88 41.7,27.03 41.58,26.9 41.34,26.9 41.22,27.03 41.22,27.88 41.09,28 40.85,28 40.73,27.88 40.73,27.27 40.6,27.14 40.37,27.14 40.24,27.27 40.24,27.88 40.12,28 39.87,28 39.75,27.88 39.75,27.22 39.63,27.09 39.39,27.09 39.27,27.22 39.27,27.88 39.14,28 38.87,28 38.74,27.88 38.74,27.37 38.62,27.24 37.9,27.24 37.78,27.11 37.78,26.05 v10(37.28,25.56) 36.52,26.32 35.2,26.32 34.41,27.11 31.71,27.11 31.58,27.23 31.58,27.47 31.45,27.6 31.2,27.6 31.07,27.47 31.07,27.23 30.94,27.11 30.81,27.11 30.69,26.98 30.69,26.75 30.56,26.62 30.32,26.62 30.2,26.75 30.2,27.03 30.07,27.16 29.84,27.16 29.71,27.03 29.71,26.47 29.59,26.34 29.34,26.34 29.22,26.47 29.22,27.05 29.1,27.18 28.83,27.18 28.7,27.05 28.7,26.46 28.57,26.33 26.4,26.33 26.24,26.17 v10(26.24,25.56) 25.46,26.33 24.11,26.33 23.63,26.81 22.28,26.81 19.74,29.35 18.68,29.35 v7(18.47,29.15)
  IN4 w0.091: v5(67.67,57.47) 67.61,57.53 v4(67.61,57.95)
  GND5 w0.102: v5(67.67,57.47) 67.87,57.66 v6(68.04,57.66)
  BOTTOM w0.076: v10(48.33,25.56) 47.9,25.12 46.81,25.12 44.98,26.96 UD11.N8 ; UD13.N8 33.93,28.88 33.93,26.96 35.76,25.12 36.85,25.12 v10(37.28,25.56) ; UD15.N8 22.88,26.96 24.71,25.12 25.8,25.12 v10(26.24,25.56) ; v10(59.38,25.56) 58.95,25.12 57.86,25.12 56.02,26.96 56.02,28.88 UD9.N8
  BOTTOM w0.16: v7(18.47,29.15) 18.07,29.55 R1053.1 ; v6(68.04,57.66) 67.81,57.89 UCPU1.BE30
DDR_B_MA9: length 186.8
  TOP w0.076: v10(26.06,28.32) 25.12,27.38 24.61,27.38 24.27,27.73 24.27,29.12 23.71,29.68 UD16.M3 ; UD10.M3 56.86,29.68 57.42,29.12 57.42,27.73 57.76,27.38 58.43,27.38 59.2,28.16 v10(59.2,28.32) ; v10(48.16,28.32) 47.22,27.38 46.71,27.38 v1(46.69,27.41) 46.69,27.41 46.37,27.73 46.37,29.12 45.81,29.68 UD12.M3 ; UD14.M3 34.76,29.68 35.32,29.12 35.32,27.73 35.66,27.38 36.17,27.38 v10(37.11,28.32)
  IN2 w0.122: v4(67.08,39.38) 67.08,39.37 67.15,39.43 67.73,39.43 68.19,39.9 68.2,39.9 68.72,40.42 68.72,43.19 68.48,43.43 68.08,43.43 67.34,44.16 67.34,44.41 67.49,44.56 69.49,44.56 69.64,44.4 70.1,44.4 70.26,44.56 70.87,44.56 71,44.69 71,45 70.87,45.12 66.4,45.12 66.28,45.25 66.28,45.55 66.15,45.68 65.84,45.68 65.72,45.81 65.72,46.13 65.84,46.26 70.87,46.26 71,46.39 71,46.72 70.87,46.85 66.99,46.85 66.86,46.98 66.86,47.21 66.66,47.4 64.83,47.4 64.7,47.53 64.7,47.87 64.83,47.99 70.87,47.99 71,48.12 71,48.45 70.87,48.58 68.74,48.58 68.52,48.8 68.52,48.98 68.36,49.13 64.83,49.13 64.7,49.26 64.7,49.59 64.83,49.72 70.87,49.72 71,49.84 71,50.18 70.87,50.3 68.26,50.3 68.13,50.43 68.13,50.99 68.26,51.12 70.64,51.12 70.85,51.33 70.85,51.81 71.26,52.21 71.26,56.05 69.69,57.62 v4(68.82,57.62)
  IN3 w0.122: v7(18.47,31.86) 18.85,31.86 19.34,32.35 19.77,32.35 21.48,30.65 22.89,30.65 23.91,29.62 25.82,29.62 26.06,29.39 v10(26.06,28.32) 26.47,28.32 26.59,28.45 26.59,29.01 26.72,29.13 26.95,29.13 27.08,29.01 27.08,28.45 27.2,28.32 28.14,28.32 28.65,28.83 29.79,28.83 29.92,28.96 29.92,29.54 30.05,29.67 31.95,29.67 32.18,29.44 32.18,28.65 32.32,28.51 32.67,28.51 33.78,29.62 36.87,29.62 37.11,29.39 v10(37.11,28.32) 37.52,28.32 37.64,28.45 37.64,29.45 37.82,29.63 38.15,29.63 38.27,29.75 38.27,29.94 38.39,30.06 38.64,30.06 38.76,29.94 38.76,29.75 38.88,29.63 40.67,29.63 40.79,29.75 40.79,30.4 40.92,30.52 41.16,30.52 41.28,30.4 41.28,29.75 41.4,29.63 41.65,29.63 41.77,29.75 41.77,30.4 41.89,30.52 42.13,30.52 42.26,30.4 42.26,29.53 42.38,29.4 43.19,29.4 43.31,29.53 43.31,30.42 43.44,30.54 45.6,30.54 45.73,30.42 45.73,30.04 45.6,29.91 45.22,29.91 45.09,29.78 45.09,29.27 45.22,29.15 46.36,29.15 46.49,29.27 46.49,29.5 46.62,29.62 47.92,29.62 48.16,29.39 v10(48.16,28.32) 48.57,28.32 48.69,28.45 48.69,29.01 48.81,29.13 49.05,29.13 49.18,29.01 49.18,28.45 49.3,28.32 50.24,28.32 50.75,28.83 51.89,28.83 52.02,28.96 52.02,29.54 52.14,29.67 54.05,29.67 54.28,29.44 54.28,28.65 54.42,28.51 54.77,28.51 55.88,29.62 58.97,29.62 59.2,29.39 v10(59.2,28.32) 59.6,28.32 60.93,26.99 64.88,26.99 65.02,27.13 65.02,31.37 65.97,32.32 65.97,34.96 66.99,35.98 66.99,36.08 66.99,36.09 66.99,36.58 66.99,36.59 66.99,36.69 66.38,37.29 66.38,38.57 66.58,38.77 66.63,38.77 66.64,38.79 66.69,38.79 67.08,39.18 v4(67.08,39.38)
  IN4 w0.091: v5(68.41,57.9) 68.69,57.62 v4(68.82,57.62)
  GND5 w0.102: v6(69.03,58.12) 69.02,58.1 68.61,58.1 v5(68.41,57.9)
  BOTTOM w0.076: UD11.M3 48.39,29.09 48.39,28.63 48.79,28.23 48.79,27.38 48.74,27.33 48.35,27.33 47.88,27.81 47.88,28.12 48.08,28.32 v10(48.16,28.32) ; v10(26.06,28.32) 25.98,28.32 25.78,28.12 25.78,27.81 26.25,27.33 26.64,27.33 26.69,27.38 26.69,28.23 26.29,28.63 26.29,29.09 UD15.M3 ; v10(59.2,28.32) 59.13,28.32 58.82,28.02 58.82,27.91 59.4,27.33 59.79,27.33 59.84,27.38 59.84,28.23 59.43,28.63 59.43,29.09 UD9.M3 ; UD13.M3 37.34,29.09 37.34,28.63 37.74,28.23 37.74,27.38 37.69,27.33 37.3,27.33 36.83,27.81 36.83,28.12 37.03,28.32 v10(37.11,28.32)
  BOTTOM w0.16: UCPU1.BE28 68.81,57.89 v6(69.03,58.12) ; v7(18.47,31.86) 18.12,32.22 R1063.1
DDR_B_MA10: length 166.8
  TOP w0.076: UD16.H7 26.88,32.88 27.24,32.88 27.37,32.76 27.37,32.59 27.24,32.47 25.98,32.47 25.85,32.59 v10(25.85,32.71) ; v10(59,32.71) 59,32.59 59.13,32.47 60.39,32.47 60.51,32.59 60.51,32.76 60.29,32.98 60.13,32.98 UD10.H7 ; UD12.H7 48.98,32.88 49.34,32.88 49.46,32.76 49.46,32.59 49.34,32.47 48.08,32.47 47.95,32.59 v10(47.95,32.71) ; UD14.H7 37.93,32.88 38.29,32.88 38.41,32.76 38.41,32.59 38.29,32.47 37.03,32.47 36.9,32.59 v10(36.9,32.71)
  TOP w0.16: v8(18.78,32.42) 17.98,32.42 R1043.1
  IN1 w0.091: v4(64.84,39.97) 64.64,39.76 64.09,39.76 63.89,39.57 63.89,39.32 64.04,39.18 64.04,36.66 64.17,36.54 64.93,36.54 65.06,36.41 65.06,35.88 65.3,35.63 65.61,35.63 65.98,35.27 65.98,32.33 65.63,31.98 63.42,31.98 62.55,32.85 59.14,32.85 v10(59,32.71) 58.54,32.25 58.54,32.25 57.39,32.25 57.15,32.5 56.79,32.5 56.66,32.37 56.66,31.68 56.54,31.55 56.13,31.55 56,31.68 56,31.88 55.88,32.01 55.42,32.01 55.29,31.88 55.29,31.4 55.14,31.25 54.38,31.25 54.25,31.37 54.25,31.97 54.12,32.09 53.87,32.09 53.74,31.97 53.74,31.37 53.62,31.25 53.36,31.25 53.01,31.6 52.07,31.6 51.94,31.73 51.94,31.91 51.81,32.04 51.48,32.04 51.36,31.91 51.36,31.73 51.23,31.6 50.95,31.6 50.44,32.11 48.1,32.11 47.95,32.26 v10(47.95,32.71) 47.49,32.25 47.49,32.25 45.69,32.25 45.62,32.18 45.62,31.68 45.49,31.55 45.08,31.55 44.95,31.68 44.95,31.88 44.83,32.01 44.37,32.01 44.24,31.88 44.24,31.4 44.09,31.25 43.33,31.25 43.2,31.37 43.2,32.59 43.08,32.72 42.82,32.72 42.69,32.59 42.69,31.37 42.57,31.25 42.31,31.25 42.19,31.37 42.19,33.07 42.06,33.2 41.81,33.2 41.68,33.07 41.68,31.68 41.6,31.6 41.02,31.6 40.89,31.73 40.89,32.03 40.76,32.16 40.43,32.16 40.31,32.03 40.31,31.64 40.18,31.51 39.91,31.51 39.78,31.64 39.78,32.02 39.69,32.11 37,32.11 36.9,32.21 v10(36.9,32.71) 36.45,32.25 36.44,32.25 35.3,32.25 35.05,32.5 34.69,32.5 34.57,32.37 34.57,31.68 34.44,31.55 34.03,31.55 33.91,31.68 33.91,31.88 33.78,32.01 33.32,32.01 33.19,31.88 33.19,31.4 33.04,31.25 32.28,31.25 32.15,31.37 32.15,31.97 32.03,32.09 31.77,32.09 31.65,31.97 31.65,31.37 31.52,31.25 31.26,31.25 30.91,31.6 29.97,31.6 29.84,31.73 29.84,31.91 29.71,32.04 29.38,32.04 29.26,31.91 29.26,31.73 29.13,31.6 28.85,31.6 28.34,32.11 26,32.11 25.85,32.26 v10(25.85,32.71) 25.45,32.3 24.06,32.3 23.43,32.93 21.42,32.93 21.22,32.73 19.08,32.73 v8(18.78,32.42)
  IN2 w0.122: v4(61.58,58.53) 61.42,58.38 61.42,57.42 60.57,56.56 49.59,56.56 47.51,54.48 47.51,49.26 47.35,49.11 45.17,49.11 45.04,48.98 45.04,48.65 45.17,48.53 46.74,48.53 46.9,48.37 46.9,48.1 46.74,47.94 42.65,47.94 42,47.29 42,46.93 41.83,46.76 40.25,46.76 39.16,45.68 39.16,43.99 39.95,43.2 39.95,42.01 40.66,41.3 50.86,41.3 51.47,41.91 52,41.91 52.79,41.12 54.43,41.12 55.22,41.91 62.53,41.91 62.77,41.67 62.77,40.81 63.72,39.87 64.74,39.87 v4(64.84,39.97)
  IN4 w0.091: v4(61.58,58.53) 61.58,59.02 v5(61.55,59.04)
  GND5 w0.102: v5(61.55,59.04) 61.68,58.91 v6(61.98,58.91)
  BOTTOM w0.076: v10(47.95,32.71) 47.54,33.12 46.02,33.12 UD11.H7 ; v10(59,32.71) 58.59,33.12 57.07,33.12 UD9.H7 ; UD13.H7 34.97,33.12 36.49,33.12 v10(36.9,32.71) ; UD15.H7 23.92,33.12 25.44,33.12 v10(25.85,32.71)
  BOTTOM w0.16: v6(61.98,58.91) 61.76,58.7 UCPU1.BD43
DDR_B_MA11: length 174
  TOP w0.076: UD16.M7 26.34,29.14 26.34,28.78 26.26,28.71 25.96,28.71 25.85,28.81 25.17,28.81 25.08,28.71 25.08,28.6 25.17,28.51 25.17,28.45 25.3,28.32 v10(25.44,28.32) ; UD14.M7 37.39,29.14 37.39,28.78 37.31,28.71 37,28.71 36.9,28.81 36.22,28.81 36.13,28.71 36.13,28.6 36.22,28.51 36.22,28.45 36.34,28.32 v10(36.48,28.32) ; UD12.M7 48.44,29.14 48.44,28.78 48.36,28.71 48.05,28.71 47.95,28.81 47.27,28.81 47.17,28.71 47.17,28.6 47.27,28.51 47.27,28.45 47.39,28.32 v10(47.53,28.32) ; UD10.M7 59.49,29.14 59.49,28.78 59.41,28.71 59.1,28.71 59,28.81 58.32,28.81 58.22,28.71 58.22,28.6 58.32,28.51 58.32,28.45 58.44,28.32 v10(58.58,28.32)
  IN2 w0.122: v4(66.81,37.78) 66.82,37.78 66.82,37.78 66.95,37.66 67.55,37.66 69.38,39.49 69.91,39.49 71.1,40.67 72.57,40.67 72.72,40.82 72.72,40.96 72.5,41.17 72.5,42.04 72.79,42.32 73.76,42.32 73.95,42.51 73.95,42.99 74.18,43.22 74.61,43.22 74.91,42.91 75.55,42.91 75.7,43.07 75.7,43.45 75.88,43.63 75.88,44.6 76.17,44.89 77.55,44.89 77.72,45.06 77.72,45.28 77.5,45.5 76.16,45.5 75.98,45.68 75.98,49.9 76.11,50.03 76.44,50.03 76.56,49.9 76.56,46.37 76.79,46.14 77.25,46.14 77.46,46.34 77.46,47.66 77.15,47.97 77.15,51.43 76.63,51.94 76.63,54.11 76.5,54.24 75.01,54.24 74.89,54.37 74.89,54.7 75.01,54.83 76.5,54.83 76.63,54.95 76.63,55.28 76.5,55.41 73.84,55.41 73.72,55.54 73.72,55.87 73.84,55.99 76.66,55.99 76.79,56.12 76.79,56.45 76.66,56.58 74.28,56.58 74,56.86 74,58.18 73.87,58.31 73.54,58.31 73.41,58.18 73.41,56.81 73.13,56.53 72.96,56.53 72.36,57.12 72.36,57.3 72.78,57.72 72.78,58.15 72.65,58.29 72.47,58.29 71.91,57.72 71.74,57.72 71.56,57.89 71.56,58.07 72.13,58.63 72.13,58.8 71.96,58.98 71.78,58.98 71.22,58.41 71.05,58.41 70.87,58.58 70.87,58.76 71.44,59.32 71.44,59.49 71.23,59.7 71.23,60.03 70.01,61.25 69.6,61.25 68.64,62.22 v4(68.64,62.73)
  IN3 w0.122: v4(66.81,37.78) 66.82,37.78 66.82,37.78 66.95,37.66 67.2,37.66 67.46,37.4 67.46,37.39 67.46,37.39 67.46,36.79 67.32,36.65 67.32,35.92 66.24,34.85 66.24,32.21 65.3,31.26 65.3,27.01 65,26.71 60.18,26.71 60.07,26.82 60.07,27.31 59.49,27.89 59.01,27.89 v10(58.58,28.32) 58.15,28.76 57.78,28.76 57.33,29.21 56.03,29.21 55.85,29.04 55.85,28.38 55.67,28.2 54.28,28.2 54,28.48 54,29.24 53.84,29.39 53.5,29.39 53.38,29.27 53.38,28.65 53.26,28.53 53.02,28.53 52.89,28.65 52.89,29.12 52.77,29.25 52.5,29.25 52.37,29.12 52.37,28.02 52.24,27.89 47.97,27.89 v10(47.53,28.32) 47.53,28.58 47.36,28.76 45.66,28.76 45.54,28.64 45.54,26.33 45.41,26.2 45.15,26.2 45.03,26.33 45.03,26.5 44.9,26.62 44.46,26.62 44.33,26.74 44.33,26.98 44.46,27.11 44.9,27.11 45.03,27.23 45.03,27.47 44.9,27.59 44.55,27.59 44.43,27.72 44.43,27.96 44.55,28.08 44.9,28.08 45.03,28.2 45.03,28.55 44.74,28.84 44.74,29.48 44.61,29.6 44.33,29.6 44.2,29.48 44.2,28.99 44.05,28.84 42.55,28.84 42.12,29.27 38.25,29.27 38.12,29.15 38.12,28.52 37.49,27.89 36.92,27.89 v10(36.48,28.32) 36.05,28.76 35.68,28.76 35.23,29.21 33.93,29.21 33.75,29.04 33.75,28.38 33.58,28.2 32.18,28.2 31.9,28.48 31.9,29.24 31.75,29.39 31.41,29.39 31.28,29.27 31.28,28.65 31.16,28.53 30.92,28.53 30.8,28.65 30.8,29.12 30.67,29.25 30.4,29.25 30.27,29.12 30.27,28.02 30.15,27.89 25.87,27.89 v10(25.44,28.32) 25,28.76 21.58,28.76 19.49,30.85 18.52,30.85 v7(18.47,30.9)
  IN4 w0.091: v5(68.61,62.19) 68.61,62.7 v4(68.64,62.73)
  GND5 w0.102: v5(68.61,62.19) 68.39,62.42 v6(68.22,62.42)
  BOTTOM w0.076: UD11.M7 46.37,29.09 46.37,28.3 46.73,27.94 47.17,27.94 47.53,28.31 v10(47.53,28.32) ; UD13.M7 35.32,29.09 35.32,28.3 35.68,27.94 36.12,27.94 36.48,28.31 v10(36.48,28.32) ; v10(58.58,28.32) 58.58,28.31 58.21,27.94 57.78,27.94 57.42,28.3 57.42,29.09 UD9.M7 ; v10(25.44,28.32) 25.44,28.31 25.07,27.94 24.63,27.94 24.27,28.3 24.27,29.09 UD15.M7
  BOTTOM w0.16: v7(18.47,30.9) 18.04,31.33 R1065.1 ; UCPU1.AT28 v6(68.22,62.42)
DDR_B_MA12: length 176
  TOP w0.076: v10(25.09,30.41) 25.09,30.18 25.35,29.93 25.89,29.93 26.42,30.46 26.42,30.83 UD16.K7 ; UD12.K7 48.52,30.83 48.52,30.46 47.99,29.93 47.44,29.93 47.19,30.18 v10(47.19,30.41) ; UD14.K7 37.47,30.83 37.47,30.46 36.94,29.93 36.4,29.93 36.14,30.18 v10(36.14,30.41) ; v10(58.24,30.41) 58.19,30.35 58.19,30.11 58.37,29.93 59.04,29.93 59.57,30.46 59.57,30.89 59.96,31.28 UD10.K7
  TOP w0.16: R1037.1 v2(17.8,29.98)
  GND1 w0.102: v2(17.8,29.98) 17.96,29.82 v3(17.96,29.56)
  IN1 w0.091: v4(67.32,38.07) 67.48,37.91 67.48,35.55 67.14,35.21 67.14,30.7 66.78,30.34 66.47,30.34 66.1,29.97 66.1,29.54 66.35,29.29 66.35,28.08 66.05,27.77 63.91,27.77 63.79,27.65 63.79,27.37 63.91,27.24 64.17,27.24 64.29,27.11 64.29,26.84 64.17,26.71 62.82,26.71 62.21,27.32 62.21,27.55 62.34,27.67 63.01,27.67 63.38,28.04 63.38,29.13 62.85,29.65 61.63,29.65 61.4,29.88 59.94,29.88 59.05,30.76 58.6,30.76 v10(58.24,30.41) 57.63,31.02 57.39,31.02 55.99,29.61 55.79,29.61 55.66,29.49 55.66,29.3 55.86,29.1 55.86,28.81 55.73,28.68 52.78,28.68 52.14,29.31 50.31,29.31 50.21,29.21 50.21,28.99 50.09,28.87 49.7,28.87 49.58,28.99 49.58,29.37 49.7,29.49 49.94,29.49 50.07,29.62 50.07,29.95 49.94,30.07 48.7,30.07 48,30.76 47.97,30.76 47.96,30.77 47.56,30.77 v10(47.19,30.41) 46.58,31.02 46.34,31.02 45.5,30.17 45.18,30.17 45.03,30.03 45.03,29.56 44.89,29.42 44.32,29.42 44.19,29.29 44.19,28.98 44.32,28.86 44.53,28.86 44.66,28.73 44.66,28.5 44.53,28.38 43.94,28.38 43.81,28.5 43.81,28.59 43.68,28.72 43.3,28.72 43.18,28.59 43.18,28.07 43.05,27.94 42.21,27.94 42.01,27.74 42.01,26.9 41.88,26.77 40.92,26.77 40.21,27.49 38.78,27.49 38.53,27.74 38.53,28.32 38.66,28.45 39.06,28.45 39.19,28.58 39.19,28.83 39.06,28.96 38.66,28.96 38.53,29.09 38.53,29.37 38.66,29.49 38.94,29.49 39.04,29.59 39.04,29.9 38.86,30.07 37.36,30.07 37.21,30.23 37.21,30.51 36.96,30.76 36.5,30.76 v10(36.14,30.41) 35.53,31.02 35.29,31.02 33.89,29.61 33.69,29.61 33.56,29.49 33.56,29.3 33.76,29.1 33.76,28.81 33.64,28.68 30.68,28.68 30.05,29.31 28.22,29.31 28.11,29.21 28.11,28.99 27.99,28.87 27.61,28.87 27.48,28.99 27.48,29.37 27.61,29.49 27.85,29.49 27.97,29.62 27.97,29.95 27.85,30.07 26.6,30.07 25.91,30.76 25.45,30.76 v10(25.09,30.41) 24.65,30.85 24.08,30.85 23.75,30.52 20.5,30.52 19.51,29.53 18.8,29.53 18.75,29.58 17.98,29.58 v3(17.96,29.56)
  IN2 w0.122: v4(67.32,38.07) 67.37,38.12 67.64,38.12 69.27,39.76 69.8,39.76 70.99,40.95 72.03,40.95 72.23,41.15 72.23,42.19 72.64,42.6 73.5,42.6 73.67,42.77 73.67,43.1 74.25,43.68 74.25,44.06 74.45,44.26 74.45,48.73 73.69,49.49 73.69,49.85 74.09,50.24 74.09,53.28 74.21,53.4 74.56,53.4 74.68,53.28 74.68,50.1 75.04,49.75 75.04,44.01 74.84,43.81 74.84,43.37 75.03,43.19 75.31,43.19 75.43,43.3 75.43,43.57 75.61,43.74 75.61,44.96 75.66,45.01 75.66,49.96 75.19,50.43 75.19,53.28 75.32,53.4 75.65,53.4 75.78,53.28 75.78,50.69 76.05,50.41 76.64,50.41 76.88,50.64 76.88,51.31 76.36,51.83 76.36,53.76 76.15,53.97 74,53.97 73.87,54.09 73.87,54.42 74,54.55 74.48,54.55 74.61,54.67 74.61,55.01 74.48,55.14 73.73,55.14 69.97,58.89 69.78,58.89 69.5,59.17 69.5,59.68 69.04,60.13 69.04,60.97 68.55,61.47 v4(68.53,61.47)
  IN4 w0.091: v4(68.53,61.47) 68.76,61.47 68.97,61.68 v5(68.98,61.68)
  GND5 w0.102: v6(68.98,61.24) v5(68.98,61.68)
  BOTTOM w0.076: UD13.K7 34.77,31.28 35.24,30.81 36.03,30.81 36.24,31.02 36.42,31.02 36.55,30.89 36.55,30.64 36.31,30.41 v10(36.14,30.41) ; UD11.K7 45.82,31.28 46.29,30.81 47.08,30.81 47.29,31.02 47.47,31.02 47.6,30.89 47.6,30.64 47.36,30.41 v10(47.19,30.41) ; v10(58.24,30.41) 58.41,30.41 58.72,30.72 58.72,30.87 58.54,31.05 58.37,31.05 58.13,30.81 57.34,30.81 56.87,31.28 UD9.K7 ; v10(25.09,30.41) 25.26,30.41 25.5,30.64 25.5,30.89 25.37,31.02 25.19,31.02 24.98,30.81 24.19,30.81 23.72,31.28 UD15.K7
  BOTTOM w0.16: v6(68.98,61.24) 68.78,61.45 UCPU1.AV28
