# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D36: length 63.4
  IN1 w0.071: v4(60.76,59.73) 60.89,59.86 61.25,59.86 61.34,59.76 61.34,59.62 61.68,59.28 61.68,59.04 61.73,58.99 61.83,58.99 61.92,58.9 61.92,58.74 62.03,58.64 62.36,58.64 62.44,58.71 62.44,58.86 62.34,58.97 62.34,59.12 62.41,59.19 62.67,59.19 62.8,59.07 62.97,59.07 63.1,59.19 63.23,59.19 63.38,59.04 63.38,58.89 63.15,58.66 63.15,57.82 63.25,57.72 63.25,57.57 63.18,57.49 62.92,57.49 62.82,57.39 62.82,57.16 62.92,57.06 63.2,57.06 63.28,56.98 63.28,56.81 63.53,56.55 63.68,56.55 63.89,56.76 63.89,57.13 63.92,57.16 63.92,57.44 63.89,57.48 63.89,57.78 63.92,57.81 63.92,58.35 63.95,58.37 63.95,58.64 64.05,58.74 64.32,58.74 64.41,58.65 64.41,58.57 64.47,58.52 64.78,58.52 64.88,58.41 64.88,58.2 64.78,58.1 64.44,58.1 64.35,58 64.35,57.77 64.44,57.68 64.7,57.68 64.8,57.58 64.8,57.39 64.67,57.26 64.42,57.26 64.32,57.16 64.32,56.9 64.46,56.76 64.46,56.31 64.55,56.22 64.75,56.22 64.9,56.38 64.9,56.5 64.98,56.58 65.13,56.58 65.39,56.83 65.62,56.83 65.89,56.55 65.89,56.18 65.81,56.1 65.64,56.1 65.49,56.25 65.39,56.25 65.19,56.05 65.19,55.85 65.34,55.7 66.73,55.7 66.83,55.6 66.83,55.45 67,55.28 67.14,55.28 67.29,55.43 68.19,55.43 68.45,55.18 68.63,55.18 68.9,55.45 69.61,55.45 69.77,55.6 69.77,56.65 69.87,56.76 70.09,56.76 70.19,56.65 70.19,55.47 70.29,55.37 70.52,55.37 70.62,55.47 70.62,55.89 70.72,55.99 70.95,55.99 71.05,55.89 71.05,55.47 71.15,55.37 71.25,55.37 72.1,54.51 72.1,54.26 72.33,54.02 72.59,54.02 73.27,53.34 73.27,53.01 73.43,52.86 73.76,52.86 74.39,52.23 74.39,51.79 74.61,51.57 74.96,51.57 76.47,50.06 76.47,49.93 79.49,46.9 80.15,46.9 82.03,45.02 82.03,45.02 82.32,44.73 82.32,43.84 84.61,41.56 84.61,41.31 85.26,40.65 85.26,40.18 85.26,40.18 85.26,39.65 86.4,38.51 86.4,37.87 86.52,37.75 86.78,37.49 86.78,37.09 86.94,36.93 87.15,36.93 87.19,36.93 87.85,36.27 87.85,36.07 87.97,35.95 88.2,35.95 88.3,35.85 88.3,35.73 88.15,35.57 88.15,35.43 88.34,35.24 88.47,35.24 88.67,35.44 88.83,35.44 88.9,35.37 88.9,35.08 88.74,34.92 88.74,34.57 88.86,34.45 88.86,34.26 88.74,34.14 88.74,33.73 v10(88.65,33.64)
  IN4 w0.084: v5(60.08,59.82) 60.67,59.82 v4(60.76,59.73)
  GND5 w0.104: v6(60.27,59.44) 60.27,59.48 60.08,59.68 v5(60.08,59.82)
  BOTTOM w0.104: v10(88.65,33.64) 88.54,33.53 88.54,32.45 88.29,32.21 87.78,32.21 87.37,31.8 UD5.C2
  BOTTOM w0.122: v6(60.27,59.44) 60.51,59.2 UCPU1.BC45
DDR_A_D37: length 64.4
  IN1 w0.071: v10(89.21,30.04) 89.34,30.04 89.6,30.3 89.6,35.47 89.6,35.67 87.22,38.06 87.11,38.16 87.11,38.81 85.97,39.95 85.97,40.95 85.31,41.6 85.31,41.85 83.03,44.14 83.03,45.03 80.44,47.61 80.25,47.61 79.79,47.61 78.52,48.87 78.52,48.88 77.2,50.2 77.2,50.47 71.87,55.8 71.87,56.49 70.03,58.33 68.92,58.33 68.69,58.56 68.69,59.07 68.29,59.47 67.64,59.47 67.52,59.35 67.52,59.17 67.75,58.94 67.83,58.94 68.03,58.74 68.03,57.7 67.9,57.57 67.37,57.57 67.22,57.72 67.22,58.41 67.04,58.59 66.91,58.59 66.68,58.81 66.68,59.35 66.62,59.41 66.62,59.74 66.66,59.78 66.66,60.06 66.17,60.54 65.92,60.54 65.82,60.44 65.82,60.29 65.89,60.21 65.89,59.7 65.8,59.61 65.35,59.61 65.12,59.83 65.12,60.02 64.95,60.19 64.95,60.34 65.12,60.5 65.12,60.65 64.93,60.85 64.75,60.85 64.65,60.74 64.45,60.74 64.35,60.85 63.84,60.85 63.76,60.77 63.76,60.52 63.63,60.39 63.02,60.39 62.83,60.19 62.83,60.09 62.69,59.96 62.3,59.96 62.08,60.18 62.08,60.51 62.35,60.78 62.35,60.99 62.26,61.07 62.26,61.28 62.41,61.43 62.41,61.83 62.25,61.99 62.08,61.99 61.96,61.87 61.96,61.58 61.89,61.51 61.7,61.51 61.69,61.51 61.44,61.51 61.3,61.51 61.2,61.61 61.2,63.41 61.09,63.51 60.84,63.51 60.74,63.41 60.74,63.31 60.66,63.23 v4(60.43,63.23)
  IN4 w0.084: v5(60.89,63.49) 60.69,63.49 v4(60.43,63.23)
  GND5 w0.104: v5(60.89,63.49) 60.89,63.32 61.08,63.13 v6(61.08,63.1)
  BOTTOM w0.104: UD5.E3 86.57,30.39 86.75,30.57 88.68,30.57 v10(89.21,30.04)
  BOTTOM w0.122: UCPU1.AR45 v6(61.08,63.1)
DDR_A_D38: length 64
  IN1 w0.071: v4(58.68,62.52) 58.68,62.62 58.45,62.85 58.35,62.85 58.25,62.95 58.25,63.23 58.33,63.31 58.94,63.31 58.99,63.26 58.99,62.83 59.16,62.65 59.48,62.65 59.73,62.4 60.09,62.4 60.51,61.97 60.58,61.97 60.99,61.56 60.99,61.44 61.21,61.23 61.58,61.23 61.81,61 61.81,60.11 62.21,59.7 63.43,59.7 63.87,59.26 64.27,59.26 64.6,59.59 64.99,59.59 65.16,59.42 65.31,59.42 65.59,59.14 65.59,59.09 65.69,58.99 65.91,58.99 66.01,59.09 66.01,59.41 66.07,59.47 66.22,59.47 66.43,59.27 66.43,58.71 66.96,58.18 66.96,57.62 67.22,57.37 68.03,57.37 68.26,57.6 68.26,58.19 68.36,58.28 68.54,58.28 68.72,58.09 69.93,58.09 71.64,56.39 71.64,55.7 76.96,50.37 76.96,50.1 78.29,48.78 79.69,47.37 80.35,47.37 82.79,44.93 82.79,44.04 85.08,41.75 85.08,41.5 85.73,40.85 85.73,39.85 86.88,38.71 86.88,38.06 86.99,37.95 89.37,35.57 89.37,31.16 87.8,29.59 83.2,29.59 82.2,30.59 v10(82.18,30.59)
  IN4 w0.084: v5(58.91,62.95) 58.68,62.73 v4(58.68,62.52)
  GND5 w0.104: v6(59.2,62.6) 59.2,62.63 58.91,62.93 v5(58.91,62.95)
  BOTTOM w0.104: UD5.E8 82.57,30.2 v10(82.18,30.59)
  BOTTOM w0.122: UCPU1.AT48 58.94,62.6 v6(59.2,62.6)
DDR_A_D39: length 64.6
  IN1 w0.071: v4(58.72,60.57) 58.88,60.57 58.99,60.47 58.99,60.27 58.9,60.19 58.76,60.19 58.66,60.08 58.66,59.86 58.76,59.75 59.16,59.75 59.26,59.65 59.26,59.19 59.04,58.97 59.04,58.33 59.47,57.9 59.47,57.32 59.88,56.91 60.69,56.91 60.79,56.81 60.79,56.28 61.71,55.37 61.77,55.37 61.94,55.2 61.94,54.85 63.15,53.64 63.99,53.64 64.12,53.51 64.12,52.74 64.24,52.61 67.34,52.61 67.44,52.71 67.44,53.12 67.55,53.23 68.87,53.23 68.97,53.12 68.97,52.62 69.07,52.52 69.7,52.52 69.82,52.65 69.82,53.14 69.95,53.26 70.41,53.26 70.83,52.85 70.83,52.51 70.93,52.41 71.26,52.41 71.28,52.39 71.46,52.39 71.54,52.31 71.54,52.15 71.54,51.96 72.37,51.13 72.57,51.13 72.64,51.13 73.61,50.15 74.37,50.15 75.05,49.47 75.05,49.34 75.75,48.64 75.75,48.52 75.55,48.32 75.55,48.32 75.42,48.19 75.42,48.06 75.65,47.83 75.76,47.83 76.08,48.15 76.24,48.15 78.91,45.49 79.02,45.49 79.39,45.12 79.93,45.12 80.61,44.44 80.61,42.38 81.01,41.97 81.21,41.97 81.56,41.97 82,41.54 82,41.24 82.39,40.85 83.01,40.85 83.34,40.52 83.34,40.36 83.15,40.17 83.05,40.17 82.95,40.07 82.95,39.89 82.94,39.89 82.94,39.77 82.94,39.77 82.94,39.46 82.94,39.05 82.94,38.85 83.09,38.71 83.09,38.62 82.98,38.51 82.98,38.34 83.1,38.22 83.57,38.22 83.66,38.13 84.78,38.13 84.87,38.04 84.87,37.39 85.24,37.03 85.24,36.09 85.48,35.86 85.99,35.35 86.87,34.47 86.87,34.24 86.71,34.09 86.71,33.93 86.72,33.92 86.87,33.78 86.87,33.48 86.62,33.23 86.62,32.88 86.34,32.6 85.88,32.6 85.78,32.5 85.78,32.22 85.88,32.12 86.09,32.12 86.19,32.02 86.19,31.51 86.06,31.38 85.23,31.38 85.15,31.47 85.15,31.58 85.07,31.66 84.81,31.66 84.73,31.58 84.73,31.47 84.65,31.38 84.34,31.38 84.26,31.46 84.26,31.71 84.16,31.81 83.85,31.81 83.75,31.71 83.75,31.18 84,30.92 84.14,30.78 84.14,30.25 83.95,30.06 83.5,30.06 83.37,30.19 83.37,30.73 83.12,30.98 82.46,30.98 82.35,31.08 82.35,31.27 82.46,31.38 v10(82.96,31.38)
  IN4 w0.084: v4(58.72,60.57) 58.73,60.57 58.96,60.34 v5(58.96,60.13)
  GND5 w0.104: v5(58.96,60.13) 59.11,60.29 v6(59.34,60.29)
  BOTTOM w0.104: UD5.C8 82.57,31.77 v10(82.96,31.38)
  BOTTOM w0.122: UCPU1.AY48 58.8,60.5 59.01,60.29 v6(59.34,60.29)
DDR_A_D40: length 48.7
  TOP w0.076: v10(85.23,32.02) 85.45,32.02 86.06,31.41 86.06,30.71 UD6.E7
  IN1 w0.071: v4(58.26,60.17) 57.94,59.85 57.94,59.38 58.25,59.08 58.25,57.54 64.09,51.7 70.78,51.7 75.42,47.06 76.15,47.06 78.75,44.47 78.96,44.47 79.9,43.53 79.9,42.07 81.01,40.97 81.01,40.84 81.74,40.11 81.74,38.52 82.53,37.73 83.27,37 83.27,36 85.53,33.74 85.53,32.58 85.23,32.28 v10(85.23,32.02)
  IN4 w0.084: v5(57.44,59.87) 57.74,60.17 v4(58.26,60.17)
  GND5 w0.104: v5(57.44,59.87) 57.48,59.87 57.78,60.17 v6(57.78,60.17)
  BOTTOM w0.122: UCPU1.BA49 v6(57.78,60.17)
DDR_A_D41: length 52.3
  TOP w0.104: v10(85.14,33.54) 85.15,33.54 85.66,33.03 85.66,32.73 86.57,31.82 UD6.C7
  IN1 w0.071: v4(57.54,60.59) 57.61,60.67 57.77,60.67 57.89,60.54 57.89,60.31 57.69,60.11 57.69,59.37 57.97,59.09 57.97,57.49 63.99,51.47 70.68,51.47 75.32,46.83 76.06,46.83 78.65,44.24 78.86,44.24 79.67,43.43 79.67,41.97 80.01,41.62 80.01,41.12 80.18,40.95 80.3,40.95 80.42,41.07 80.54,41.07 80.71,40.9 80.71,40.78 80.59,40.66 80.59,40.54 80.71,40.42 80.91,40.42 80.99,40.34 80.99,40.21 80.88,40.1 80.88,39.72 81.08,39.52 81.39,39.52 81.49,39.42 81.49,39.22 81.39,39.12 81.16,39.12 81.06,39.02 81.06,38.79 81.16,38.7 81.41,38.7 81.51,38.6 81.51,38.42 81.51,38.42 81.51,38.37 81.41,38.28 81.16,38.28 81.06,38.18 81.06,37.98 81.16,37.88 81.52,37.88 81.59,37.81 81.59,37.66 81.44,37.51 81.44,37.4 81.62,37.22 81.74,37.22 82.15,37.63 82.29,37.63 82.45,37.48 82.45,37.34 82.03,36.92 82.03,36.8 82.21,36.63 82.33,36.63 82.73,37.03 82.9,37.03 83.03,36.9 83.03,36.73 82.62,36.33 82.62,36.21 84.85,33.99 84.85,33.61 84.92,33.54 v10(85.14,33.54)
  IN4 w0.084: v5(57.44,61.1) 57.54,61 v4(57.54,60.59)
  GND5 w0.104: v6(57.82,61.28) 57.64,61.1 v5(57.44,61.1)
  BOTTOM w0.122: UCPU1.AV49 58.03,61.28 v6(57.82,61.28)
DDR_A_D42: length 48.8
  TOP w0.104: v10(83.01,33.82) 83.01,32.95 UD6.B3
  IN1 w0.071: v4(56.67,59.3) 56.52,59.3 56.47,59.25 56.47,56.96 63.38,50.05 70.09,50.05 74.73,45.41 75.47,45.41 77.93,42.95 77.93,42.65 77.93,41.57 78.16,41.34 78.29,41.34 78.6,41.04 78.6,40 79.65,38.95 79.65,36.98 79.47,36.81 79.47,36.55 79.56,36.47 79.62,36.47 79.7,36.39 79.7,35.94 80.23,35.41 80.35,35.41 80.42,35.41 80.63,35.2 80.63,34.66 80.73,34.57 81.27,34.57 81.77,34.06 81.77,33.74 81.52,33.49 81.52,33.26 81.62,33.16 81.76,33.16 82.01,33.41 82.35,33.41 82.52,33.58 82.67,33.58 82.8,33.45 82.8,33.3 82.56,33.06 82.56,32.93 82.63,32.85 83.22,32.85 83.34,32.98 83.34,33.49 v10(83.01,33.82)
  IN4 w0.084: v5(57.21,59.42) 56.8,59.42 v4(56.67,59.3)
  GND5 w0.104: v6(57.38,59.03) 57.21,59.2 v5(57.21,59.42)
  BOTTOM w0.122: UCPU1.BB51 57.23,59.17 v6(57.38,59.03)
DDR_A_D43: length 50.5
  TOP w0.104: v10(80.65,33) 80.65,31.58 80.86,31.38 82.19,31.38 UD6.D2
  IN1 w0.071: v10(80.65,33) 80.4,33 80.16,33.25 80.16,34.81 78.35,36.62 78.35,37.02 78.45,37.12 78.85,37.12 78.95,37.22 78.95,37.86 78.85,37.96 78.45,37.96 78.35,38.06 78.35,38.19 78.45,38.29 78.9,38.29 79,38.39 79,38.52 78.9,38.62 78.45,38.62 78.35,38.72 78.35,38.85 78.45,38.95 78.6,38.95 78.7,39.05 78.7,39.19 78.6,39.29 78.47,39.29 78.35,39.4 78.35,39.54 78.09,39.8 78.09,40.74 77.46,41.37 77.46,42.76 77.22,42.99 77.1,42.99 76.86,43.23 76.86,43.23 76.86,43.35 76.63,43.59 76.62,43.59 76.5,43.59 76.27,43.82 76.27,43.83 76.27,43.95 76.03,44.18 76.03,44.18 75.91,44.18 75.67,44.41 75.67,44.42 75.67,44.54 75.44,44.77 75.43,44.77 75.32,44.77 75.15,44.94 74.54,44.94 69.9,49.58 63.18,49.58 55.99,56.77 55.99,58.79 55.7,59.08 55.7,59.48 55.51,59.67 55.51,59.86 55.68,60.03 55.68,60.44 v4(55.61,60.52)
  IN4 w0.084: v4(55.61,60.52) 55.96,60.52 v5(56.22,60.77)
  GND5 w0.104: v6(55.88,61.03) 55.96,61.03 v5(56.22,60.77)
  BOTTOM w0.122: v6(55.88,61.03) 56.16,60.74 UCPU1.AY53
DDR_A_D44: length 48.9
  TOP w0.104: UD6.C8 87.37,32.13 87.79,32.55 87.79,33.49 87.51,33.77 86.19,33.77 v10(86.08,33.66)
  IN1 w0.071: v10(86.08,33.66) 86.08,34.34 85.82,34.6 85.47,34.6 85.38,34.51 85.22,34.51 84.97,34.76 84.97,34.91 85.16,35.1 85.16,35.43 84.85,35.75 84.69,35.75 84.36,35.42 84.19,35.42 83.52,36.08 83.52,36.21 83.65,36.33 83.65,36.49 83.52,36.62 83.52,37.08 82.63,37.97 81.98,38.62 81.98,40.2 81.24,40.94 81.24,41.06 80.14,42.17 80.14,43.63 79.06,44.71 78.84,44.71 76.25,47.3 75.52,47.3 70.88,51.94 64.18,51.94 58.5,57.62 58.5,59.52 58.42,59.61 v4(58.31,59.61)
  IN4 w0.084: v4(58.31,59.61) 58.16,59.77 v5(57.83,59.77)
  GND5 w0.104: v6(57.68,59.39) 57.83,59.54 v5(57.83,59.77)
  BOTTOM w0.122: v6(57.68,59.39) 57.81,59.52 UCPU1.BB49
DDR_A_D45: length 50.2
  TOP w0.076: UD6.E8 87.37,30.2 87.01,30.2 86.62,30.59 86.43,30.59 86.24,30.78 86.24,31.55 85.12,32.67 v10(85.12,32.73)
  IN1 w0.071: v10(57.75,62.33) 57.54,62.12 57.54,61.66 57.17,61.29 57.17,60.44 57.18,60.42 57.18,60.41 57.46,60.14 57.46,59.28 57.74,58.99 57.74,57.38 63.89,51.23 70.58,51.23 75.22,46.59 75.96,46.59 78.55,44 78.77,44 79.43,43.33 79.43,41.87 79.77,41.53 79.77,41.02 80.64,40.16 80.64,39.63 80.83,39.44 80.83,37.72 81.13,37.42 81.13,37.37 84.61,33.89 84.61,33.45 85.12,32.94 v10(85.12,32.73)
  BOTTOM w0.122: v10(57.75,62.33) 57.96,62.12 UCPU1.AU49
DDR_A_D46: length 49.6
  TOP w0.104: v10(81.11,33.46) 81.39,33.19 81.39,32.32 81.52,32.19 82.17,32.19 UD6.C2
  IN1 w0.071: v4(56.14,59.88) 55.94,59.88 55.86,59.8 55.86,59.58 55.96,59.47 56.17,59.47 56.24,59.4 56.24,59.25 56.08,59.08 56.08,58.96 56.24,58.8 56.24,56.85 63.28,49.82 70,49.82 74.64,45.18 75.37,45.18 77.69,42.86 77.69,41.47 78.06,41.1 78.2,41.1 78.34,40.96 78.34,39.92 78.94,39.33 78.94,39.04 79.03,38.95 79.31,38.95 79.41,38.85 79.41,38.66 79.26,38.5 79.26,38.33 79.41,38.17 79.41,37.85 79.33,37.77 79.29,37.77 79.2,37.68 79.2,37.52 79.29,37.43 79.33,37.43 79.41,37.35 79.41,37.2 79.1,36.89 78.8,36.89 78.7,36.78 78.7,36.61 78.85,36.46 79.16,36.46 79.24,36.39 79.24,36.07 80.4,34.91 80.4,34.43 80.5,34.33 81.17,34.33 81.39,34.11 81.39,33.99 81.31,33.91 80.5,33.91 80.4,33.81 80.4,33.54 80.5,33.44 81.08,33.44 v10(81.11,33.46)
  IN4 w0.084: v5(56.45,60.31) 56.45,60.35 56.14,60.03 v4(56.14,59.88)
  GND5 w0.104: v5(56.45,60.31) 56.36,60.4 v6(55.93,60.4)
  BOTTOM w0.122: UCPU1.BA53 v6(55.93,60.4)
DDR_A_D47: length 48.4
  TOP w0.076: UD6.E3 83.37,30.21 83.76,30.6 v10(83.76,30.63)
  IN1 w0.071: v4(55.33,59.32) 55.33,59.12 55.73,58.71 55.73,56.69 63.08,49.34 69.8,49.34 74.44,44.7 75.05,44.7 77.22,42.53 77.22,41.27 77.83,40.66 77.83,39.72 78.11,39.44 78.11,36.53 79.92,34.72 79.92,33.15 80.45,32.63 80.45,32.63 80.48,32.59 83.12,32.59 83.37,32.35 83.37,31.03 83.76,30.64 v10(83.76,30.63)
  IN4 w0.084: v5(55.84,59.45) 55.61,59.45 55.48,59.32 v4(55.33,59.32)
  GND5 w0.104: v5(55.84,59.45) 55.84,59.4 55.57,59.13 v6(55.57,59.11)
  BOTTOM w0.122: UCPU1.BB55 55.25,59.43 v6(55.57,59.11)
DDR_A_D48: length 57.7
  IN1 w0.071: v10(71.13,30.59) 71.13,30.1 73.17,28.06 74.77,28.06 75.32,28.62 77.81,28.62 79.69,30.49 79.69,34.62 77.88,36.43 77.88,39.34 77.58,39.64 77.58,40.58 76.98,41.18 76.98,42.44 74.95,44.47 74.34,44.47 69.73,49.08 63.01,49.08 55.5,56.6 55.5,58.63 54.96,59.17 54.96,59.48 55.13,59.64 55.13,60 v4(55.23,60.1)
  IN4 w0.084: v4(55.23,60.1) v5(54.74,60.1)
  GND5 w0.104: v6(55.62,59.82) 55.62,59.83 55.35,60.1 v5(54.74,60.1)
  BOTTOM w0.104: v10(71.13,30.59) 71.52,30.2 UD7.E8
  BOTTOM w0.122: UCPU1.BA55 55.35,60.09 v6(55.62,59.82)
DDR_A_D49: length 59.4
  IN1 w0.071: v10(71.91,32.2) 70.96,32.2 70.89,32.13 70.89,31.39 71.53,30.75 71.53,30.12 72.22,29.43 73.41,29.43 73.59,29.6 74.07,29.6 74.82,28.85 77.72,28.85 79.45,30.59 79.45,34.52 77.64,36.33 77.64,39.24 77.32,39.56 77.32,40.5 76.75,41.08 76.75,42.34 74.85,44.23 74.22,44.23 69.6,48.85 62.91,48.85 55.26,56.5 55.26,58.52 54.76,59.02 54.76,60.4 v4(54.96,60.59)
  IN4 w0.084: v4(54.96,60.59) 54.57,60.99 v5(54.57,60.9)
  GND5 w0.104: v5(54.57,60.9) 54.57,61.06 v6(54.77,61.27)
  BOTTOM w0.104: v10(71.91,32.2) 72.31,31.8 UD7.C7
  BOTTOM w0.122: UCPU1.AV56 v6(54.77,61.27)
DDR_A_D50: length 62.1
  IN1 w0.071: v4(57.56,63.77) 57.75,63.58 57.75,63.37 57.61,63.22 57.07,63.22 56.88,63.03 55.94,63.03 55.76,62.85 54.43,62.85 53.55,61.96 53.55,61.46 53.24,61.15 52.74,61.15 52.48,60.9 52.48,60.74 52.66,60.57 52.66,60.39 52.48,60.21 52.48,56.2 59.18,49.51 59.46,49.51 59.67,49.31 60.1,49.31 61.4,48.01 61.4,47.79 61.58,47.61 61.8,47.61 62.21,47.2 62.21,46.59 62.33,46.47 62.5,46.47 62.63,46.59 62.63,47.09 62.73,47.19 62.83,47.19 62.97,47.05 63.15,47.05 63.29,47.19 63.45,47.19 63.53,47.11 63.53,47 63.63,46.9 63.85,46.9 63.95,47 63.95,47.11 64.03,47.19 64.27,47.19 64.37,47.09 64.37,46.8 64.27,46.7 64.22,46.7 64.12,46.6 64.12,46.38 64.22,46.28 65.2,46.28 65.29,46.37 65.29,47.11 65.38,47.19 66.07,47.19 66.2,47.07 66.2,46.39 66.3,46.29 67.39,46.29 67.49,46.39 67.49,46.62 67.39,46.72 66.73,46.72 66.63,46.82 66.63,47.09 66.73,47.19 68.31,47.19 68.41,47.09 68.41,46.38 68.51,46.28 69.83,46.28 73.54,42.57 73.68,42.57 74.63,41.62 74.63,41.29 74.82,41.1 74.82,40.33 75.1,40.06 75.1,39.45 75.79,38.76 75.79,35.19 76.18,34.79 76.18,34.05 76.28,33.95 76.52,33.95 76.69,34.12 76.84,34.12 77.15,33.82 77.48,33.82 77.6,33.69 v10(77.6,33.64)
  IN4 w0.084: v5(58.25,63.21) 58.12,63.21 v4(57.56,63.77)
  GND5 w0.104: v6(57.78,63.35) 57.92,63.21 v5(58.25,63.21)
  BOTTOM w0.104: v10(77.6,33.64) 77.49,33.53 77.49,32.45 77.25,32.21 76.73,32.21 UD7.C2
  BOTTOM w0.122: v6(57.78,63.35) 58.08,63.65 UCPU1.AP50
DDR_A_D51: length 61.8
  IN1 w0.071: v4(56.13,63.68) 55.96,63.51 55.35,63.51 55.16,63.32 54.24,63.32 53.13,62.21 53.13,61.69 53.02,61.59 52.51,61.59 52.01,61.09 52.01,56.01 58.98,49.04 59.27,49.04 59.47,48.84 59.91,48.84 60.93,47.81 60.93,47.2 61.14,46.98 61.26,46.98 61.42,47.14 61.57,47.14 61.72,46.99 61.72,46.85 61.56,46.69 61.56,46.57 62.32,45.81 69.63,45.81 73.34,42.1 73.47,42.1 74.12,41.45 74.12,41.04 74.35,40.81 74.35,39.23 74.21,39.09 74.21,38.37 74.83,37.76 74.93,37.76 75,37.83 75.1,37.83 75.2,37.73 75.2,37.63 75.13,37.56 75.13,37.46 75.31,37.27 75.31,34.99 75.68,34.63 75.68,33.32 75.57,33.21 75.57,32.8 75.27,32.5 75.27,32.31 75.18,32.23 74.92,32.23 74.84,32.15 74.84,31.89 74.92,31.81 75.18,31.81 75.27,31.73 75.27,31.53 75.1,31.36 74.25,31.36 74.12,31.24 73.71,31.24 73.6,31.34 73.28,31.34 73.05,31.12 73.05,30.8 73.1,30.75 73.29,30.57 73.29,30.42 72.87,30 72.38,30 72.3,30.09 72.3,30.75 72.17,30.88 72.17,31.08 72.3,31.21 72.3,31.71 72.2,31.81 71.38,31.81 71.28,31.71 71.28,31.47 71.38,31.37 v10(71.91,31.37)
  IN4 w0.084: v5(55.71,63.36) 55.81,63.36 v4(56.13,63.68)
  GND5 w0.104: v6(56.13,63.2) 55.97,63.36 v5(55.71,63.36)
  BOTTOM w0.104: v10(71.91,31.37) 71.52,31.76 UD7.C8
  BOTTOM w0.122: v4(56.13,63.68) v6(56.13,63.2)
DDR_A_D52: length 59.7
  IN1 w0.071: v4(56.19,61.58) 56.04,61.58 55.89,61.43 55.89,61.1 55.76,60.97 54.77,60.97 54.54,60.74 54.54,58.89 55.03,58.41 55.03,57.57 54.9,57.44 54.81,57.44 54.69,57.32 54.69,57.11 54.82,56.98 54.9,56.98 55.03,56.86 55.03,56.4 55.3,56.12 55.3,55.89 55.58,55.61 55.81,55.61 56.06,55.37 56.06,55.25 55.84,55.04 55.84,54.92 56.02,54.74 56.14,54.74 56.35,54.95 56.47,54.95 56.65,54.78 56.65,54.66 56.43,54.44 56.43,54.32 56.61,54.15 56.73,54.15 56.95,54.36 57.06,54.36 57.24,54.18 57.24,54.07 57.03,53.85 57.03,53.73 57.2,53.55 57.32,53.55 57.54,53.77 57.66,53.77 62.82,48.61 69.5,48.61 74.12,44 74.76,44 76.51,42.24 76.51,40.04 77.4,39.14 77.4,36.44 77.2,36.23 77.2,36 77.3,35.9 77.74,35.9 79.21,34.42 79.21,31.74 79.09,31.61 78.24,31.61 78.11,31.48 78.11,31.3 78.24,31.18 79.11,31.18 79.21,31.07 79.21,30.87 79.11,30.76 78.95,30.76 78.87,30.67 78.87,30.34 78.74,30.21 78.57,30.21 78.45,30.34 78.45,30.67 78.37,30.76 77.99,30.76 77.86,30.63 77.86,30.16 77.99,30.04 v10(78.16,30.04)
  IN4 w0.084: v5(56.6,61.88) 56.6,61.88 56.59,61.88 56.29,61.58 v4(56.19,61.58)
  GND5 w0.104: v5(56.6,61.88) 56.6,61.85 56.24,61.49 v6(56.24,61.26)
  BOTTOM w0.104: UD7.E3 75.52,30.39 75.72,30.59 77.6,30.59 v10(78.16,30.04)
  BOTTOM w0.122: v6(56.24,61.26) 56.07,61.43 UCPU1.AV54
DDR_A_D53: length 60.2
  IN1 w0.071: v4(56.27,62.62) 56.24,62.6 54.49,62.6 53.75,61.86 53.75,61.4 53.32,60.97 53.19,60.97 53.1,60.88 53.1,60.63 53.19,60.55 53.29,60.55 53.37,60.46 53.37,59.34 53.29,59.26 52.81,59.26 52.72,59.17 52.72,58.93 52.81,58.84 53.29,58.84 53.37,58.76 53.37,57.59 53.25,57.47 52.82,57.47 52.72,57.37 52.72,57.13 52.8,57.05 53.3,57.05 53.37,56.97 53.37,56.7 53.3,56.63 52.8,56.63 52.72,56.54 52.72,56.3 52.82,56.2 53.17,56.2 53.3,56.08 53.3,55.73 53.42,55.6 53.54,55.6 53.78,55.85 53.91,55.85 54.08,55.68 54.08,55.55 53.83,55.31 53.83,55.19 54.01,55.01 54.13,55.01 54.25,55.13 54.36,55.13 54.54,54.95 54.54,54.83 54.43,54.72 54.43,54.6 57.4,51.63 57.75,51.63 57.87,51.5 57.87,51.32 57.85,51.3 57.85,51.18 58.02,51 58.14,51 58.17,51.03 58.29,51.03 58.46,50.85 58.46,50.73 58.44,50.7 58.44,50.59 58.62,50.41 58.74,50.41 58.76,50.43 58.88,50.43 59.06,50.26 59.06,50.14 59.03,50.11 59.03,49.99 59.21,49.81 59.33,49.81 59.35,49.84 59.47,49.84 59.77,49.54 60.2,49.54 62.31,47.43 64.47,47.43 64.61,47.3 64.61,46.62 64.71,46.52 64.94,46.52 65.05,46.62 65.05,47.35 65.13,47.43 68.56,47.43 68.69,47.3 68.69,46.62 68.79,46.52 68.99,46.52 69.17,46.7 69.75,46.7 73.63,42.82 73.84,42.82 74.26,42.39 74.5,42.39 74.64,42.24 74.64,42.01 74.87,41.78 74.89,41.78 74.89,41.39 75.06,41.22 75.06,40.43 75.33,40.16 75.33,39.55 76.02,38.86 76.02,35.29 76.59,34.72 76.78,34.72 77.02,34.48 77.02,34.28 77.25,34.05 77.77,34.05 78.01,33.81 78.01,33.21 v10(77.91,33.11)
  IN4 w0.084: v4(56.27,62.62) 56.38,62.62 v5(56.7,62.3)
  GND5 w0.104: v5(56.7,62.3) 56.15,62.3 v6(56.05,62.19)
  BOTTOM w0.104: UD7.D2 76.64,31 77.1,31.45 77.33,31.45 77.4,31.52 78.02,31.52 78.2,31.7 78.2,32.82 v10(77.91,33.11)
  BOTTOM w0.122: v6(56.05,62.19) 56.05,62.67 UCPU1.AT54
DDR_A_D54: length 59.7
  IN1 w0.071: v10(75.13,32.99) 75.24,32.99 75.34,33.09 75.34,33.34 75.45,33.44 75.45,33.97 75.34,34.07 75.17,34.07 75.08,34.16 75.08,34.38 75.15,34.46 75.23,34.46 75.29,34.52 75.29,34.68 75.08,34.9 75.08,37.18 73.98,38.28 73.98,39.23 74.12,39.37 74.12,40.72 73.88,40.95 73.59,40.95 73.49,41.05 73.49,41.18 73.69,41.39 73.69,41.55 73.37,41.86 73.25,41.86 69.54,45.57 62.22,45.57 62.01,45.78 61.85,45.78 61.64,45.58 61.4,45.58 61.3,45.69 61.3,45.83 61.57,46.1 61.57,46.22 61.39,46.4 61.28,46.4 61.01,46.14 60.87,46.14 60.72,46.29 60.72,46.43 60.98,46.69 60.98,46.81 60.47,47.32 60.47,47.42 60.7,47.65 60.7,47.71 60.57,47.84 60.22,47.84 60.12,47.94 60.12,48.07 60.17,48.11 60.17,48.24 60.01,48.39 59.77,48.39 59.6,48.22 59.6,48.04 59.75,47.89 59.75,47.75 59.56,47.56 59.21,47.56 59.14,47.64 59.14,48.37 59.32,48.55 59.32,48.66 59.17,48.81 58.88,48.81 56.08,51.6 55.96,51.6 55.75,51.39 55.64,51.39 55.46,51.58 55.46,51.69 55.67,51.9 55.67,52.02 55.48,52.2 55.36,52.2 55.16,52 55.04,52 54.86,52.17 54.86,52.29 55.07,52.5 55.07,52.62 54.89,52.8 54.77,52.8 54.56,52.59 54.44,52.59 54.27,52.77 54.27,52.89 54.47,53.09 54.47,53.21 54.3,53.39 54.18,53.39 53.97,53.18 53.85,53.18 53.67,53.36 53.67,53.48 53.88,53.69 53.88,53.8 53.7,53.98 53.59,53.98 53.38,53.77 53.26,53.77 53.08,53.95 53.08,54.07 53.29,54.28 53.29,54.4 53.11,54.58 52.99,54.58 52.78,54.37 52.67,54.37 52.49,54.55 52.49,54.66 52.7,54.87 52.7,54.99 52.52,55.17 52.4,55.17 52.19,54.96 52.07,54.96 51.9,55.14 51.9,55.26 52.1,55.46 52.1,55.58 51.78,55.91 51.78,61.19 52.41,61.83 52.83,61.83 52.94,61.94 52.94,62.4 54.06,63.51 54.76,63.51 54.86,63.61 v4(54.86,63.77)
  IN4 w0.084: v4(54.86,63.77) 54.86,63.77 54.57,63.77 v5(54.39,63.59)
  GND5 w0.104: v5(54.39,63.59) 54.46,63.59 54.83,63.22 v6(54.83,63.22)
  BOTTOM w0.104: UD7.B3 75.52,32.6 75.13,32.99 v10(75.13,32.99)
  BOTTOM w0.122: UCPU1.AP56 v6(54.83,63.22)
DDR_A_D55: length 61.6
  IN1 w0.071: v10(71.91,30.59) 71.91,30.04 72.13,29.82 72.99,29.82 73.58,30.41 74.8,30.41 75.51,31.12 75.51,31.56 75.6,31.64 75.6,31.95 75.52,32.03 75.52,32.35 75.74,32.57 76.23,32.57 76.36,32.7 76.36,33.62 76.26,33.72 76.08,33.72 75.94,33.85 75.94,34.7 75.55,35.09 75.55,38.66 74.59,39.62 74.59,40.98 74.38,41.19 74.38,41.53 73.57,42.34 73.44,42.34 69.73,46.05 68.26,46.05 68.16,46.15 68.16,46.82 68.05,46.93 67.83,46.93 67.72,46.82 67.72,46.15 67.62,46.05 66.04,46.05 65.95,46.13 65.95,46.87 65.87,46.95 65.62,46.95 65.53,46.87 65.53,46.13 65.45,46.05 62.42,46.05 61.97,46.49 61.97,47.11 61.7,47.38 61.48,47.38 61.17,47.69 61.17,47.91 60,49.07 59.57,49.07 59.37,49.28 59.08,49.28 52.25,56.11 52.25,60.99 52.61,61.35 53.18,61.35 53.36,61.54 53.36,62.11 54.34,63.08 55.25,63.08 55.45,63.27 56.35,63.27 v4(56.78,63.71)
  IN4 w0.084: v4(56.78,63.71) 56.89,63.71 57.18,63.41 v5(57.21,63.41)
  GND5 w0.104: v6(56.78,63.22) 56.88,63.22 57.07,63.41 v5(57.21,63.41)
  BOTTOM w0.104: UD7.E7 72.31,30.2 v10(71.91,30.59)
  BOTTOM w0.122: UCPU1.AP52 v6(56.78,63.22)
DDR_A_D56: length 56.9
  TOP w0.076: v10(72.69,30.63) 72.69,30.6 72.32,30.23 UD8.E3
  IN1 w0.071: v10(72.69,30.63) 72.69,31.45 72.85,31.61 74.4,31.61 74.61,31.81 74.61,33.7 74.6,33.7 74.6,36.98 73.51,38.08 73.51,38.77 73.08,39.19 73.08,40.67 72.56,41.2 72.56,41.88 69.34,45.1 61.21,45.1 60.22,46.09 60.22,46.2 60.22,46.63 60.08,46.78 59.73,46.78 59.42,47.09 58.92,47.09 58.67,47.34 58.67,47.4 58.67,47.88 58.58,47.97 58.2,47.97 58.12,48.04 58.12,48.2 58.03,48.29 56.9,49.42 56.81,49.42 56.21,48.83 56.07,48.83 55.52,49.37 55.52,49.52 56.45,50.45 56.45,50.56 56.08,50.94 55.97,50.94 55.87,50.84 55.53,50.84 55.28,50.58 55.15,50.58 55.05,50.68 55.05,51.31 51.3,55.06 51.3,61.54 53.93,64.16 v4(54.12,64.16)
  IN4 w0.084: v5(54.65,64.21) 54.55,64.21 54.51,64.16 v4(54.12,64.16)
  GND5 w0.104: v5(54.65,64.21) 54.65,64.33 54.45,64.53 v6(54.45,64.66)
  BOTTOM w0.122: UCPU1.AN57 54.5,64.6 v6(54.45,64.66)
DDR_A_D57: length 59.2
  TOP w0.104: v10(74.09,33.54) 74.1,33.54 74.58,33.06 74.58,32.68 75.46,31.8 UD8.C7
  IN1 w0.071: v4(56.45,64.19) 56.45,64.15 56.35,64.05 56.29,64.05 56.28,64.05 55.79,64.05 55.68,64.15 55.68,64.43 55.58,64.54 53.97,64.54 51.07,61.63 51.07,54.96 54.79,51.24 54.79,50.25 54.89,50.15 55.35,50.15 55.46,50.05 55.46,49.82 55.35,49.72 55.2,49.72 55.07,49.59 55.07,49.44 56.06,48.46 56.2,48.46 56.79,49.05 56.93,49.05 57.41,48.58 57.89,48.1 57.89,47.58 57.75,47.45 57.47,47.16 57.47,47.02 57.63,46.86 57.77,46.86 58.2,47.29 58.39,47.29 58.82,46.85 59.26,46.85 59.39,46.72 59.39,46.52 59.28,46.41 58.57,46.41 58.48,46.32 58.48,46.11 58.99,45.61 60.37,45.61 61.12,44.86 69.24,44.86 72.32,41.79 72.32,41.1 72.85,40.57 72.85,39.09 73.27,38.67 73.27,37.98 74.37,36.88 74.37,33.82 v10(74.09,33.54)
  IN4 w0.084: v5(56.06,64.5) 56.38,64.19 v4(56.45,64.19)
  GND5 w0.104: v6(56.45,64.72) 56.44,64.72 56.22,64.5 v5(56.06,64.5)
  BOTTOM w0.122: UCPU1.AN53 v6(56.45,64.72)
DDR_A_D58: length 57.6
  TOP w0.104: v10(70.06,33.49) 70.34,33.21 70.34,32.32 70.45,32.21 71.11,32.21 UD8.C2
  IN1 w0.071: v4(53.96,66.94) 53.35,66.94 48.85,62.45 48.85,54.14 49.07,53.92 49.07,52.75 50.37,51.46 50.37,50.77 53.04,48.09 53.04,47.08 53.35,46.77 53.68,46.77 53.96,47.06 54.08,47.06 54.26,46.88 54.26,46.76 53.89,46.39 53.89,46.27 54.07,46.1 54.19,46.1 54.55,46.46 54.67,46.46 57.25,43.88 57.59,43.88 58.02,43.45 59.53,43.45 60.24,42.74 68.36,42.74 70.1,41.01 70.1,40.55 70.2,40.45 70.2,40.01 70.67,39.54 70.67,38.6 70.52,38.44 70.52,37.94 70.52,37.94 70.52,37.61 70.52,37.61 70.52,35.51 70.45,35.44 70.45,34.91 70.59,34.77 70.59,34.27 70.38,34.07 70.38,33.81 v10(70.06,33.49)
  IN4 w0.084: v5(54.74,67.07) 54.62,66.94 v4(53.96,66.94)
  GND5 w0.104: v6(54.69,66.66) 54.72,66.69 54.72,67.04 v5(54.74,67.07)
  BOTTOM w0.122: UCPU1.AG56 54.69,67 v6(54.69,66.66)
DDR_A_D59: length 59.2
  TOP w0.104: v10(71.97,33.82) 71.97,32.95 UD8.B3
  IN1 w0.071: v10(71.97,33.82) 72.12,33.97 72.12,34.71 71.53,35.29 71.53,36.39 71.62,36.47 71.62,37.98 71.16,38.44 71.16,39.86 70.67,40.35 70.67,41.1 68.56,43.21 60.43,43.21 59.73,43.92 58.22,43.92 57.61,44.53 57.49,44.53 57.44,44.48 57.33,44.48 57.15,44.65 57.15,44.77 57.2,44.82 57.2,44.94 57.02,45.12 56.9,45.12 56.85,45.07 56.73,45.07 56.55,45.25 56.55,45.37 56.6,45.41 56.6,45.53 56.42,45.71 56.31,45.71 56.26,45.66 56.14,45.66 55.96,45.84 55.96,45.96 56.01,46.01 56.01,46.13 55.83,46.3 55.71,46.3 55.67,46.26 55.55,46.26 55.37,46.43 55.37,46.55 55.42,46.6 55.42,46.72 55.24,46.9 55.12,46.9 55.07,46.85 54.95,46.85 54.78,47.03 54.78,47.14 54.82,47.19 54.82,47.31 54.65,47.49 54.53,47.49 54.48,47.44 54.36,47.44 54.18,47.62 54.18,47.74 54.23,47.79 54.23,47.9 54.05,48.08 53.94,48.08 53.89,48.03 53.77,48.03 53.59,48.21 53.59,48.33 53.64,48.38 53.64,48.5 53.46,48.68 53.34,48.68 53.29,48.63 53.18,48.63 53,48.8 53,48.92 53.05,48.97 53.05,49.09 52.77,49.37 52.44,49.37 51.98,49.83 51.98,49.99 52.19,50.2 52.19,50.32 52.01,50.5 51.89,50.5 51.68,50.29 51.56,50.29 51.39,50.47 51.39,50.59 51.6,50.8 51.6,50.91 51.42,51.09 51.29,51.09 51.12,50.92 51,50.92 50.86,51.07 50.86,51.24 50.98,51.37 50.98,51.51 49.56,52.93 49.56,54.1 49.32,54.34 49.32,62.25 52.95,65.87 53.83,65.87 53.93,65.98 53.93,66.25 54.03,66.35 54.3,66.35 54.57,66.61 55.63,66.61 55.98,66.96 v4(55.99,66.96)
  IN4 w0.084: v5(56.17,67.45) 55.99,67.27 v4(55.99,66.96)
  GND5 w0.104: v6(55.75,67.41) 55.78,67.45 v5(56.17,67.45)
  BOTTOM w0.122: UCPU1.AG53 56.07,67.09 v6(55.75,67.41)
DDR_A_D60: length 58.8
  TOP w0.104: UD8.C8 76.32,31.8 76.32,32.13 76.74,32.55 76.74,33.49 76.46,33.77 75.14,33.77 v10(75.03,33.66)
  IN1 w0.071: v10(75.03,33.66) 74.84,33.84 74.84,37.08 73.74,38.18 73.74,38.87 73.32,39.29 73.32,40.77 72.79,41.3 72.79,41.98 69.44,45.34 62.12,45.34 62,45.45 61.85,45.45 61.74,45.34 61.5,45.34 61.3,45.34 61.06,45.59 61.06,45.77 60.93,45.9 60.75,45.9 60.46,46.19 60.46,46.51 60.64,46.69 60.64,46.82 60.45,47.01 59.83,47.01 59.52,47.33 59.02,47.33 58.9,47.44 58.9,48.12 58.8,48.22 58.53,48.22 58.43,48.32 58.43,48.48 58.59,48.64 58.59,48.76 58.44,48.91 58.32,48.91 58.09,48.68 57.97,48.68 57.79,48.86 57.79,48.98 58.02,49.21 58.02,49.33 57.85,49.51 57.73,49.51 57.5,49.28 57.38,49.28 57.2,49.45 57.2,49.57 57.43,49.8 57.43,49.92 57.26,50.09 57.14,50.09 56.21,49.16 56.07,49.16 55.92,49.32 55.92,49.45 56.85,50.39 56.85,50.5 56.08,51.27 55.96,51.27 55.79,51.09 55.36,51.09 55.29,51.17 55.29,51.41 51.54,55.16 51.54,61.29 52.32,62.06 52.68,62.06 52.76,62.14 52.76,62.47 54.02,63.74 54.29,63.74 54.69,64.15 55.27,64.15 v4(55.31,64.11)
  IN4 w0.084: v4(55.31,64.11) 55.31,64.61 v5(55.33,64.63)
  GND5 w0.104: v5(55.33,64.63) 55.26,64.56 v6(54.85,64.56)
  BOTTOM w0.122: UCPU1.AN55 55.15,64.26 v6(54.85,64.56)
DDR_A_D61: length 60.7
  TOP w0.076: UD8.E8 76.32,30.2 75.97,30.2 75.57,30.59 75.47,30.59 75.19,30.87 75.19,31.55 74.23,32.52 74.23,32.55 v10(74.1,32.68)
  IN1 w0.071: v10(74.1,32.68) 74.1,32.68 73.69,33.08 73.69,33.77 74.13,34.21 74.13,36.78 73.03,37.88 73.03,38.57 72.61,38.99 72.61,40.48 72.08,41 72.08,41.69 69.14,44.63 61.02,44.63 60.28,45.37 58.89,45.37 58.22,46.03 58.22,46.47 58.07,46.62 57.52,46.62 57.08,47.06 57.08,47.39 57.17,47.49 57.46,47.49 57.65,47.68 57.65,48 57.56,48.09 56.95,48.7 56.81,48.7 56.71,48.6 56.71,47.97 56.61,47.87 56.27,47.87 54.82,49.32 54.82,49.87 54.55,50.14 54.55,51.14 53.23,52.46 53.04,52.46 52.83,52.68 52.83,52.87 50.83,54.87 50.83,55.06 50.83,61.73 53.83,64.73 55.79,64.73 55.92,64.6 56.69,64.6 v4(57.1,64.19)
  IN4 w0.084: v4(57.1,64.19) 57.43,64.19 v5(57.59,64.34)
  GND5 w0.104: v5(57.59,64.34) 57.48,64.34 v6(57.1,64.72)
  BOTTOM w0.122: UCPU1.AN52 v6(57.1,64.72)
DDR_A_D62: length 58.9
  TOP w0.104: UD8.D2 71.14,31.38 69.81,31.38 69.6,31.58 69.6,32.88 v10(69.7,32.98)
  IN1 w0.071: v4(55.43,67.02) 54.59,67.02 54.13,66.56 53.3,66.56 49.09,62.35 49.09,54.24 49.31,54.02 49.31,52.85 50.6,51.55 50.6,50.86 57.35,44.11 57.69,44.11 58.12,43.68 59.63,43.68 60.33,42.98 68.46,42.98 70.43,41 70.43,40.18 70.92,39.69 70.92,38.34 71.37,37.9 71.37,36.97 71,36.61 71,35.66 70.68,35.34 70.68,35.01 70.82,34.87 70.82,34.17 70.62,33.97 70.62,33.5 70.1,32.98 v10(69.7,32.98)
  IN4 w0.084: v4(55.43,67.02) 55.43,66.76 v5(55.23,66.56)
  GND5 w0.104: v6(55.63,66.56) v5(55.23,66.56)
  BOTTOM w0.122: v6(55.63,66.56) 55.63,66.59 55.42,66.8 UCPU1.AG55
DDR_A_D63: length 59
  TOP w0.076: UD8.E7 75.01,30.71 75.01,31.41 74.4,32.02 v10(74.18,32.02)
  IN1 w0.071: v10(74.18,32.02) 73.98,31.81 72.54,31.81 72.32,32.04 72.32,32.69 72.21,32.8 72.21,33.21 72.37,33.38 72.37,34.81 72.92,35.36 72.92,35.71 71.85,36.77 71.85,38.08 71.4,38.54 71.4,40 70.91,40.49 70.91,41.2 68.66,43.45 60.53,43.45 59.82,44.16 58.31,44.16 53.37,49.1 52.87,49.6 52.79,49.6 52.54,49.85 52.54,50.47 52.53,50.47 51.44,51.56 51.44,51.8 51.28,51.97 50.86,51.97 50.16,52.67 50.16,52.9 50.06,53 49.9,53 49.8,53.1 49.8,53.58 49.94,53.72 49.94,54.05 49.85,54.14 49.65,54.34 49.65,54.38 49.65,62.24 53.03,65.62 54.24,65.62 54.34,65.72 v4(54.34,65.98)
  IN4 w0.084: v4(54.34,65.98) 54.67,66.31 v5(54.9,66.31)
  GND5 w0.104: v6(54.31,66.32) 54.34,66.34 54.86,66.34 v5(54.9,66.31)
  BOTTOM w0.122: UCPU1.AK56 54.55,66.09 v6(54.31,66.32)
DDR_A_DQS0: length 67.4
  IN1 w0.071: v10(109.05,32.19) 108.77,32.19 108.67,32.09 108.67,31.89 108.77,31.79 109.42,31.79 109.66,31.55 109.66,31.32 109.74,31.24 110.06,31.24 110.5,31.68 110.5,32.03 110.21,32.31 109.79,32.31 109.61,32.49 109.61,33.51 109.46,33.66 109.46,34.63 107.38,36.71 104.97,39.12 104.26,39.12 103.94,39.43 103.94,40.14 103.73,40.35 103.73,40.35 103.22,40.87 103.01,40.87 102.46,40.32 102.12,40.32 101.76,40.68 101.76,41.02 102.31,41.57 102.31,41.78 102.05,42.04 101.89,42.04 101.32,41.47 100.98,41.47 100.6,41.84 100.6,42.15 101.14,42.69 101.14,42.95 100.91,43.18 100.76,43.18 100.16,42.58 99.86,42.58 99.45,43 99.45,43.28 99.97,43.81 99.97,44.03 99.7,44.29 99.57,44.29 99.04,43.76 98.68,43.76 98.18,44.27 98.18,44.57 98.43,44.82 98.52,44.91 98.52,45.15 98.38,45.29 98.17,45.29 98.17,45.29 98.05,45.29 97.76,45 97.45,45 97.04,45.41 97.04,45.68 97.3,45.95 97.3,46.06 97.01,46.35 96.83,46.35 96.62,46.14 96.3,46.14 95.92,46.53 95.92,46.84 96.16,47.08 96.16,47.22 95.42,47.96 95.24,47.96 95.11,47.82 94.75,47.82 94.11,48.45 94.11,48.76 94.28,48.92 94.28,49.08 93.46,49.9 93.02,49.9 92.79,49.67 92.41,49.67 91.65,50.43 91.65,50.67 91.46,50.86 91.22,50.86 91.17,50.91 90.9,51.18 90.9,51.42 90.65,51.67 90.41,51.67 90.35,51.73 90.14,51.94 90.14,52.16 89.9,52.39 89.69,52.39 89.66,52.42 83.53,58.55 83.53,58.88 83.74,59.08 84.03,59.08 84.11,59.17 84.11,59.55 84.07,59.6 84.07,59.6 83.98,59.69 83.74,59.69 83.53,59.89 83.53,61.54 80.35,64.72 78.3,64.72 77.99,65.04 77.99,66.06 77.8,66.25 77.41,66.25 77.31,66.15 77.31,66.04 77.5,65.85 v10(77.55,65.85)
  BOTTOM w0.114: v10(77.55,65.85) 77.23,66.17 UCPU1.AJ11
  BOTTOM w0.127: UD1.C3 108.67,31.81 v10(109.05,32.19)
DDR_A_DQS1: length 49.9
  TOP w0.076: UD2.C3 105.47,31.63 105.62,31.48 105.77,31.48 106.23,31.95 106.23,32.63 v10(105.85,33.01)
  IN1 w0.071: v10(77.9,62.43) 78.09,62.25 78.09,62.01 78.29,61.81 78.92,61.81 79.32,62.2 79.87,62.2 80.12,61.95 81.41,60.66 81.41,57.82 81.41,57.82 81.41,57.67 93.81,45.27 94.17,45.27 97.85,41.59 97.85,40.52 101.43,36.94 102.56,36.94 102.7,36.8 102.7,35.94 102.95,35.69 103.5,35.69 103.69,35.88 103.69,36.57 103.79,36.68 104.06,36.68 104.64,36.09 104.64,35.39 104.94,35.09 105.64,35.09 105.96,34.77 105.96,34.56 105.63,34.22 105.63,33.83 105.82,33.64 106.06,33.64 106.14,33.57 106.14,33.25 105.9,33.01 v10(105.85,33.01)
  BOTTOM w0.114: UCPU1.AR10 78,62.81 78,62.53 v10(77.9,62.43)
DDR_A_DQS2: length 47.8
  IN1 w0.071: v10(98,32.19) 97.9,32.09 97.9,31.9 98,31.8 98.56,31.8 98.66,31.9 98.66,32.55 98.94,32.83 98.94,33.09 98.56,33.47 98.56,33.65 97.58,34.63 97.22,34.63 96.39,35.47 96.39,35.88 96.11,36.16 95.66,36.16 94.09,37.73 94.09,38.03 94.19,38.14 94.19,38.25 93.86,38.58 93.73,38.58 93.65,38.49 93.36,38.49 92.92,38.94 92.92,39.2 93.38,39.65 93.38,39.75 92.54,40.59 92.3,40.59 91.87,41.02 91.87,41.26 91.86,41.27 91.58,41.54 91.22,41.54 90.96,41.8 90.96,42.17 90.72,42.41 90.56,42.41 90.37,42.22 90.11,42.22 89.5,42.83 89.5,43.11 89.69,43.3 89.69,43.43 86.86,46.26 86.86,47.17 81.92,52.11 81.81,52.11 81.71,52.01 81.44,52.01 81.03,52.41 81.03,52.7 81.1,52.76 81.1,52.89 80.83,53.15 80.64,53.15 80.3,53.49 79.76,54.03 79.05,54.03 78.82,54.25 78.82,54.56 78.96,54.7 78.96,54.9 78.77,55.09 78.58,55.09 78.42,54.93 78.12,54.93 77.75,55.29 77.75,55.6 77.97,55.82 77.97,56.06 77.74,56.29 77.59,56.29 77.32,56.02 77.02,56.02 76.71,56.34 76.71,56.72 76.95,56.96 76.95,57.09 76.73,57.31 76.73,57.55 77.21,58.03 77.21,58.51 76.48,59.23 76.48,59.87 77.34,60.72 77.34,60.92 77.27,60.99 76.87,60.99 76.82,60.94 v10(76.82,60.78)
  BOTTOM w0.114: UCPU1.AY11 77.31,60.91 76.95,60.91 v10(76.82,60.78)
  BOTTOM w0.127: UD3.C3 97.62,31.81 v10(98,32.19)
DDR_A_DQS3: length 42.6
  TOP w0.076: UD4.C3 94.42,31.63 94.57,31.48 94.72,31.48 95.18,31.95 95.18,32.63 v10(94.8,33.01)
  IN1 w0.071: v10(94.8,33.01) 94.85,33.01 95.17,33.32 95.17,33.44 93.67,34.93 93.06,34.93 90.69,37.3 90.69,38.08 89.94,38.84 89.94,38.84 89.49,39.29 89.49,39.8 86.99,42.3 86.99,42.54 84.7,44.83 84.7,45.72 80.51,49.91 79.99,49.91 78.91,50.99 78.91,51.13 74.58,55.46 74.58,59.77 74.29,60.06 74.29,61.73 73.68,62.34 73.51,62.34 73.43,62.26 v10(73.43,62.1)
  BOTTOM w0.114: UCPU1.AU17 73.92,62.11 73.77,62.27 73.6,62.27 v10(73.43,62.1)
DDR_A_DQS4: length 63.5
  IN1 w0.071: v10(60.05,61.21) 60.05,61.25 60.27,61.47 60.41,61.47 60.57,61.3 60.57,61.03 60.08,60.53 60.08,59.61 60.53,59.16 60.84,59.16 60.99,59 60.99,58.26 61.31,57.95 61.99,57.95 62.12,57.82 62.12,57.37 62.03,57.28 61.77,57.28 61.67,57.18 61.58,57.08 61.58,56.53 62.01,56.1 62.33,56.1 62.6,56.36 62.74,56.36 63.04,56.07 63.04,55.87 62.67,55.5 62.67,55.16 62.68,55.14 62.74,55.09 62.93,54.9 63.09,54.9 63.16,54.82 63.16,54.66 63.46,54.37 63.86,54.37 64.08,54.58 64.08,55.31 64.3,55.52 64.52,55.52 64.69,55.36 64.69,54.58 64.88,54.39 65.56,54.39 65.78,54.61 65.78,54.95 65.84,55.02 66.3,55.02 66.39,54.92 66.39,54.61 66.59,54.41 67.33,54.41 67.67,54.75 67.91,54.75 68.27,54.39 68.82,54.39 69.18,54.76 69.45,54.76 69.55,54.66 69.55,54.19 69.75,53.99 70.37,53.99 70.57,54.19 70.57,54.38 70.57,54.57 70.69,54.69 70.96,54.69 71.42,54.23 71.42,54.05 71.2,53.84 71.2,53.51 71.58,53.12 71.91,53.12 72.13,53.34 72.31,53.34 72.59,53.06 72.59,52.91 72.27,52.59 72.27,52.26 72.67,51.86 72.96,51.86 73.27,52.17 73.48,52.17 73.71,51.94 73.71,51.79 73.51,51.6 73.51,51.3 73.93,50.88 74.68,50.88 75.78,49.78 75.78,49.64 79.21,46.22 79.32,46.22 79.69,45.85 80.24,45.85 81.34,44.74 81.63,44.45 81.63,43.56 82.81,42.38 82.81,42.05 83.2,41.66 83.51,41.66 83.92,41.24 83.92,41.02 84.58,40.37 84.58,40.02 84.48,39.93 83.94,39.93 83.67,39.66 83.67,39.15 83.97,38.86 85.09,38.86 85.72,38.23 85.72,38.1 85.61,37.99 85.61,37.7 85.74,37.57 85.83,37.47 86.1,37.2 86.1,37.02 85.97,36.9 85.97,36.4 86.14,36.23 86.14,36.23 86.3,36.08 86.56,36.08 86.73,36.25 86.86,36.25 87.17,35.94 87.17,35.8 87.03,35.66 87.03,35.34 87.37,35 87.61,35 87.73,34.88 87.73,34.58 88.06,34.25 88.06,34.01 87.89,33.85 87.89,33.44 88.21,33.12 88.21,31.46 87.98,31.23 87.73,31.23 87.6,31.36 87.6,31.6 87.4,31.79 86.87,31.79 86.77,31.89 86.77,32.01 v10(86.95,32.19)
  BOTTOM w0.114: v10(60.05,61.21) 60.14,61.3 60.47,61.3 UCPU1.AW45
  BOTTOM w0.127: v10(86.95,32.19) 86.57,31.81 UD5.C3
DDR_A_DQS5: length 50.1
  TOP w0.076: UD6.C3 83.37,31.63 83.52,31.48 83.67,31.48 84.13,31.95 84.13,32.63 v10(83.75,33.01)
  IN1 w0.071: v10(83.75,33.01) 83.93,33.19 83.93,33.6 83.33,34.21 82.84,34.69 81.84,34.69 81.45,35.08 81.42,35.11 81.39,35.14 81.39,35.47 81.63,35.71 81.63,35.9 81.36,36.17 81.22,36.17 80.94,35.89 80.64,35.89 80.19,36.33 80.19,36.6 80.49,36.9 80.49,37.09 80.14,37.44 80.14,39.15 79.09,40.21 79.09,41.24 78.75,41.58 78.75,43.05 78.48,43.31 78.27,43.31 75.67,45.91 74.94,45.91 70.3,50.55 63.61,50.55 57.25,56.91 57.25,57.06 57.25,58.91 57.05,59.11 57.05,59.97 56.85,60.17 56.38,60.17 56.04,60.52 56.04,60.97 56.25,61.19 56.55,61.19 v10(56.74,61.37)
  BOTTOM w0.114: UCPU1.AV51 57.1,61.26 56.85,61.26 v10(56.74,61.37)
DDR_A_DQS6: length 59
  IN1 w0.071: v10(54.9,62.19) 55.11,61.98 55.11,61.89 54.97,61.75 54.84,61.75 54.26,61.17 53.96,60.86 53.96,60.44 54.07,60.32 54.13,60.26 54.13,58.81 53.87,58.55 53.87,57.97 54.05,57.79 54.05,57.45 53.87,57.28 53.87,56.75 54.06,56.57 54.23,56.57 54.34,56.46 54.34,56.12 54.62,55.84 54.62,55.61 55.16,55.07 55.16,54.63 55.37,54.42 57.43,52.36 57.66,52.13 57.93,52.13 58.06,52.26 58.19,52.26 58.53,51.93 58.53,51.48 59.97,50.04 60.42,50.04 62.53,47.93 62.98,47.93 69.22,47.92 73.83,43.31 74.47,43.31 75.83,41.96 75.83,40.32 75.83,39.76 76.72,38.86 76.72,38.62 76.52,38.41 76.52,37.99 76.72,37.78 76.72,37.56 76.54,37.38 76.54,37.08 76.72,36.89 76.72,36.72 76.52,36.52 76.52,35.49 76.79,35.22 77.45,35.22 77.71,34.96 77.71,34.82 77.87,34.66 78.08,34.44 78.23,34.44 78.49,34.18 78.53,34.14 78.53,32.42 78.4,32.29 78.2,32.29 77.88,32.62 77.39,32.62 77.16,32.38 77.16,30.26 76.94,30.04 76.94,29.86 76.82,29.74 76.64,29.74 76.34,30.05 76.02,30.05 75.78,29.81 75.78,29.59 75.7,29.51 75.09,29.51 74.98,29.63 74.98,29.88 75.65,30.56 76.24,30.56 76.51,30.82 76.51,31.64 76.35,31.8 75.99,31.8 75.9,31.89 v10(75.9,32.19)
  BOTTOM w0.114: v10(54.9,62.19) 54.98,62.27 54.98,62.48 UCPU1.AT56
  BOTTOM w0.127: UD7.C3 75.52,31.81 v10(75.9,32.19)
DDR_A_DQS7: length 58.4
  TOP w0.076: v10(72.7,33.01) 72.91,32.8 72.91,32.55 73.08,32.37 73.08,31.95 72.67,31.53 72.42,31.53 72.32,31.63 UD8.C3
  IN1 w0.071: v10(55.93,65.57) 55.85,65.65 55.85,66.06 55.63,66.28 54.98,66.28 54.74,66.04 54.74,65.8 54.31,65.37 53.51,65.37 50.17,62.03 50.17,55.33 50.17,54.56 50.97,53.76 50.97,53.51 50.68,53.22 50.68,52.88 51.07,52.49 51.37,52.49 51.69,52.81 51.9,52.81 52.17,52.54 52.17,52.36 51.96,52.16 51.96,51.78 52.37,51.36 52.75,50.99 53.05,50.99 53.34,51.28 53.48,51.28 53.89,50.87 53.89,50.29 53.55,49.95 53.55,49.65 53.89,49.31 58.53,44.67 60.04,44.67 60.74,43.97 68.87,43.97 71.43,41.41 71.43,40.73 71.95,40.2 71.95,38.72 72.37,38.3 72.37,37.61 72.89,37.09 72.89,36.47 73.44,35.92 73.44,34.82 73.33,34.71 73.09,34.71 72.89,34.51 72.89,33.19 72.71,33.01 v10(72.7,33.01)
  BOTTOM w0.114: v10(55.93,65.57) 55.82,65.68 55.82,65.92 UCPU1.AK54
DDR_A_DQS#0: length 67.3
  IN1 w0.071: v7(109.06,31.39) 109.06,31.59 109.1,31.63 109.35,31.63 109.49,31.48 109.49,31.25 109.67,31.08 110.13,31.08 110.66,31.61 110.66,32.1 110.28,32.47 109.85,32.47 109.77,32.55 109.77,33.58 109.62,33.73 109.62,34.7 107.5,36.82 105.04,39.28 104.33,39.28 104.11,39.5 104.11,40.21 103.29,41.03 102.94,41.03 102.39,40.49 102.19,40.49 101.92,40.75 101.92,40.96 102.47,41.5 102.47,41.85 102.12,42.2 101.82,42.2 101.25,41.63 101.05,41.63 100.77,41.91 100.77,42.09 101.3,42.62 101.3,43.02 100.97,43.35 100.69,43.35 100.09,42.75 99.93,42.75 99.61,43.06 99.61,43.22 100.13,43.74 100.13,44.1 99.77,44.46 99.51,44.46 98.98,43.93 98.75,43.93 98.34,44.33 98.34,44.5 98.6,44.75 98.69,44.84 98.69,45.21 98.45,45.45 98.24,45.45 98.24,45.45 97.99,45.45 97.69,45.16 97.52,45.16 97.2,45.48 97.2,45.61 97.47,45.88 97.47,46.13 97.08,46.52 96.77,46.52 96.55,46.3 96.37,46.3 96.08,46.6 96.08,46.77 96.32,47.01 96.32,47.29 95.49,48.12 95.18,48.12 95.04,47.98 94.81,47.98 94.28,48.52 94.28,48.69 94.44,48.85 94.44,49.15 93.53,50.06 92.95,50.06 92.72,49.83 92.48,49.83 91.82,50.5 91.82,50.74 91.53,51.02 91.29,51.02 91.07,51.25 91.07,51.49 90.72,51.84 90.48,51.84 90.3,52.01 90.3,52.22 89.97,52.56 89.75,52.56 89.73,52.59 89.73,52.59 83.7,58.61 83.7,58.81 83.81,58.92 84.1,58.92 84.28,59.1 84.28,59.62 84.18,59.72 84.05,59.86 83.81,59.86 83.7,59.96 83.7,61.61 80.42,64.89 78.37,64.89 78.15,65.11 78.15,66.13 77.87,66.41 77.34,66.41 77.15,66.22 77.15,66.04 v10(76.96,65.86)
  BOTTOM w0.114: UCPU1.AL11 77.28,65.53 v10(76.96,65.86)
  BOTTOM w0.127: UD1.D3 108.67,31 v7(109.06,31.39)
DDR_A_DQS#1: length 50
  TOP w0.076: v10(106.46,33.01) 106.4,32.94 106.4,31.88 105.84,31.32 105.68,31.32 105.47,31.1 UD2.D3
  IN1 w0.071: v10(78.49,62.42) 78.25,62.18 78.25,62.08 78.36,61.98 78.86,61.98 79.25,62.37 79.94,62.37 80.19,62.12 81.58,60.73 81.58,57.73 93.87,45.43 94.24,45.43 98.01,41.66 98.01,40.59 101.49,37.11 102.63,37.11 102.86,36.87 102.86,36.01 103.02,35.85 103.43,35.85 103.52,35.95 103.52,36.64 103.73,36.84 104.12,36.84 104.81,36.16 104.81,35.46 105.01,35.26 105.71,35.26 106.13,34.84 106.13,34.49 105.8,34.16 105.8,33.9 105.89,33.81 106.13,33.81 106.31,33.63 106.31,33.16 v10(106.46,33.01)
  BOTTOM w0.114: v10(78.49,62.42) 78.35,62.57 78.35,62.79 UCPU1.AR8
DDR_A_DQS#2: length 47.9
  IN1 w0.071: v7(98.01,31.39) 98.25,31.64 98.63,31.64 98.83,31.83 98.83,32.48 99.11,32.76 99.11,33.16 98.72,33.54 98.72,33.72 97.65,34.8 97.29,34.8 96.55,35.54 96.55,35.94 96.17,36.32 95.73,36.32 94.25,37.8 94.25,37.97 94.36,38.07 94.36,38.32 93.93,38.74 93.66,38.74 93.58,38.66 93.43,38.66 93.09,39 93.09,39.13 93.54,39.58 93.54,39.82 92.61,40.75 92.37,40.75 92.03,41.09 92.03,41.33 91.97,41.39 91.65,41.71 91.29,41.71 91.12,41.87 91.12,42.24 90.79,42.57 90.5,42.57 90.3,42.38 90.18,42.38 89.67,42.9 89.67,43.05 89.86,43.24 89.86,43.5 87.03,46.33 87.03,47.24 81.99,52.28 81.75,52.28 81.64,52.17 81.51,52.17 81.2,52.48 81.2,52.63 81.26,52.69 81.26,52.95 80.9,53.31 80.71,53.31 80.42,53.6 79.83,54.19 79.12,54.19 78.99,54.32 78.99,54.5 79.13,54.64 79.13,54.97 78.84,55.26 78.51,55.26 78.35,55.09 78.19,55.09 77.92,55.36 77.92,55.53 78.14,55.75 78.14,56.13 77.81,56.45 77.52,56.45 77.25,56.18 77.09,56.18 76.87,56.4 76.87,56.65 77.11,56.89 77.11,57.16 76.89,57.37 76.89,57.48 77.38,57.96 77.38,58.58 76.65,59.3 76.65,59.8 77.5,60.65 77.5,60.99 77.34,61.15 77.06,61.15 v10(76.84,61.38)
  BOTTOM w0.114: UCPU1.AV11 77.33,61.25 76.96,61.25 v10(76.84,61.38)
  BOTTOM w0.127: v7(98.01,31.39) 97.62,31 UD3.D3
DDR_A_DQS#3: length 42.7
  TOP w0.076: v10(95.41,33.01) 95.35,32.94 95.35,31.88 94.79,31.32 94.64,31.32 94.42,31.1 UD4.D3
  IN1 w0.071: v10(95.41,33.01) 95.33,33.08 95.33,33.5 93.74,35.1 93.13,35.1 90.86,37.37 90.86,38.15 90.1,38.91 90.1,38.91 89.65,39.36 89.65,39.87 87.15,42.37 87.15,42.61 84.87,44.9 84.87,45.79 80.58,50.08 80.06,50.08 79.08,51.06 79.08,51.2 74.75,55.53 74.75,59.84 74.45,60.13 74.45,61.8 73.75,62.51 73.64,62.51 v10(73.43,62.72)
  BOTTOM w0.114: v10(73.43,62.72) 73.43,62.72 73.43,62.69 73.56,62.56 73.79,62.56 UCPU1.AT17
DDR_A_DQS#4: length 63.5
  IN1 w0.071: v7(86.96,31.39) 86.96,31.42 87.17,31.63 87.34,31.63 87.43,31.53 87.43,31.29 87.66,31.06 88.05,31.06 88.38,31.39 88.38,33.19 88.06,33.51 88.06,33.78 88.22,33.95 88.22,34.32 87.89,34.65 87.89,34.95 87.68,35.17 87.44,35.17 87.19,35.41 87.19,35.6 87.33,35.74 87.33,36.01 86.93,36.41 86.66,36.41 86.49,36.24 86.36,36.24 86.3,36.3 86.14,36.47 86.14,36.83 86.27,36.95 86.27,37.27 86,37.54 85.94,37.6 85.77,37.77 85.77,37.92 85.88,38.03 85.88,38.3 85.16,39.03 84.04,39.03 83.84,39.22 83.84,39.59 84.01,39.76 84.55,39.76 84.74,39.95 84.74,40.44 84.09,41.09 84.09,41.31 83.58,41.82 83.27,41.82 82.98,42.12 82.98,42.45 81.8,43.63 81.8,44.52 81.51,44.81 80.3,46.01 79.76,46.01 79.39,46.38 79.28,46.38 75.95,49.71 75.95,49.85 74.74,51.05 74,51.05 73.68,51.36 73.68,51.53 73.87,51.72 73.87,52.01 73.55,52.34 73.2,52.34 72.89,52.02 72.74,52.02 72.44,52.33 72.44,52.52 72.75,52.84 72.75,53.13 72.38,53.51 72.06,53.51 71.85,53.29 71.65,53.29 71.37,53.57 71.37,53.77 71.58,53.98 71.58,54.3 71.03,54.85 70.62,54.85 70.4,54.64 70.4,54.31 70.4,54.26 70.3,54.16 69.82,54.16 69.72,54.26 69.72,54.73 69.52,54.93 69.11,54.93 68.75,54.56 68.34,54.56 67.98,54.91 67.6,54.91 67.26,54.57 66.66,54.57 66.56,54.68 66.56,54.99 66.37,55.18 65.78,55.18 65.62,55.02 65.62,54.68 65.5,54.56 64.95,54.56 64.85,54.65 64.85,55.43 64.59,55.69 64.23,55.69 63.91,55.37 63.91,54.65 63.79,54.53 63.52,54.53 63.33,54.73 63.33,54.89 63.16,55.06 63,55.06 62.85,55.21 62.83,55.22 62.83,55.43 63.2,55.8 63.2,56.14 62.81,56.53 62.53,56.53 62.26,56.26 62.08,56.26 61.74,56.6 61.74,57.01 61.79,57.06 61.84,57.11 62.1,57.11 62.28,57.3 62.28,57.89 62.06,58.12 61.38,58.12 61.16,58.33 61.16,59.07 60.91,59.32 60.6,59.32 60.24,59.68 60.24,60.47 60.74,60.96 60.74,61.37 60.48,61.63 60.2,61.63 v10(60.04,61.79)
  BOTTOM w0.114: UCPU1.AV45 60.48,61.65 60.19,61.65 v10(60.04,61.79)
  BOTTOM w0.127: v7(86.96,31.39) 86.57,31 UD5.D3
DDR_A_DQS#5: length 50
  TOP w0.076: v10(84.36,33.01) 84.3,32.94 84.3,31.88 83.74,31.32 83.59,31.32 83.37,31.1 UD6.D3
  IN1 w0.071: v10(84.36,33.01) 84.09,33.27 84.09,33.67 83.39,34.37 83.29,34.47 83.07,34.69 82.91,34.85 81.91,34.85 81.57,35.19 81.55,35.21 81.55,35.4 81.8,35.64 81.8,35.97 81.43,36.33 81.15,36.33 80.87,36.05 80.71,36.05 80.36,36.4 80.36,36.54 80.65,36.83 80.65,37.16 80.31,37.51 80.31,39.22 79.26,40.28 79.26,41.31 78.91,41.65 78.91,43.12 78.55,43.48 78.34,43.48 75.74,46.07 75.01,46.07 70.37,50.71 63.67,50.71 57.41,56.97 57.41,57 57.41,58.98 57.22,59.18 57.22,60.04 56.92,60.34 56.45,60.34 56.42,60.37 56.2,60.58 56.2,60.9 56.32,61.02 56.51,61.02 56.74,60.79 v10(56.74,60.78)
  BOTTOM w0.114: v10(56.74,60.78) 56.88,60.92 57.06,60.92 UCPU1.AY51
DDR_A_DQS#6: length 59.2
  IN1 w0.071: v7(75.91,31.39) 75.91,31.48 76.07,31.64 76.28,31.64 76.35,31.57 76.35,30.89 76.18,30.72 75.58,30.72 74.81,29.95 74.81,29.56 75.02,29.35 75.76,29.35 75.94,29.53 75.94,29.74 76.09,29.88 76.27,29.88 76.57,29.58 76.89,29.58 77.1,29.79 77.1,29.97 77.32,30.19 77.32,32.32 77.46,32.45 77.82,32.45 78.14,32.13 78.47,32.13 78.7,32.36 78.7,34.21 78.61,34.29 78.29,34.61 78.15,34.61 78.03,34.73 78.03,34.73 77.87,34.89 77.87,35.03 77.52,35.38 76.86,35.38 76.68,35.56 76.68,36.45 76.89,36.65 76.89,36.96 76.7,37.14 76.7,37.31 76.89,37.49 76.89,37.85 76.68,38.05 76.68,38.34 76.89,38.55 76.89,38.93 75.99,39.82 75.99,40.25 75.99,42.03 74.54,43.48 73.9,43.48 69.29,48.09 63.04,48.09 62.6,48.09 60.49,50.2 60.04,50.2 58.69,51.55 58.69,52 58.26,52.43 57.99,52.43 57.86,52.3 57.72,52.3 57.47,52.55 55.44,54.59 55.37,54.66 55.32,54.7 55.32,55.14 54.78,55.68 54.78,55.91 54.51,56.18 54.51,56.53 54.3,56.73 54.12,56.73 54.03,56.82 54.03,57.21 54.21,57.39 54.21,57.86 54.03,58.04 54.03,58.48 54.3,58.75 54.3,60.33 54.19,60.44 54.12,60.51 54.12,60.79 54.91,61.58 55.04,61.58 55.28,61.82 55.28,61.94 v10(55.54,62.2)
  BOTTOM w0.114: UCPU1.AT55 55.33,62.6 55.33,62.41 v10(55.54,62.2)
  BOTTOM w0.127: UD7.D3 75.52,31 v7(75.91,31.39)
DDR_A_DQS#7: length 58.4
  TOP w0.076: v10(73.31,33.01) 73.07,32.77 73.07,32.62 73.25,32.44 73.25,31.88 72.74,31.37 72.44,31.37 72.32,31.25 UD8.D3
  IN1 w0.071: v10(55.33,65.57) 55.34,65.57 55.39,65.57 55.68,65.87 55.68,65.99 55.56,66.12 55.05,66.12 54.91,65.97 54.91,65.74 54.38,65.21 53.58,65.21 50.34,61.96 50.34,55.27 50.34,54.63 51.14,53.83 51.14,53.44 50.85,53.15 50.85,52.95 51.14,52.65 51.3,52.65 51.62,52.97 51.97,52.97 52.33,52.61 52.33,52.3 52.13,52.09 52.13,51.84 52.54,51.43 52.82,51.16 52.98,51.16 53.27,51.45 53.55,51.45 54.06,50.94 54.06,50.23 53.72,49.88 53.72,49.72 54.06,49.38 58.6,44.84 60.11,44.84 60.81,44.13 68.94,44.13 71.59,41.48 71.59,40.8 72.12,40.27 72.12,38.79 72.54,38.37 72.54,37.68 73.06,37.16 73.06,36.54 73.6,35.99 73.6,34.75 73.4,34.54 73.16,34.54 73.06,34.44 73.06,33.19 73.24,33.01 v10(73.31,33.01)
  BOTTOM w0.114: v10(55.33,65.57) 55.47,65.71 55.47,65.95 UCPU1.AK55
DDR_A_MA0: length 167.5
  TOP w0.076: UD2.K3 105.47,26.2 105.67,26.2 105.83,26.04 107.11,26.04 v10(107.52,26.45) ; UD4.K3 94.42,26.2 94.62,26.2 94.78,26.04 96.06,26.04 v10(96.47,26.45) ; UD6.K3 83.37,26.2 83.57,26.2 83.73,26.04 85.01,26.04 v10(85.42,26.45) ; UD8.K3 72.32,26.2 72.52,26.2 72.68,26.04 73.96,26.04 v10(74.37,26.45)
  TOP w0.16: v2(119.18,29.98) 119.18,30.35 R1040.1
  GND1 w0.102: v3(118.88,30.31) 118.88,30.29 v2(119.18,29.98)
  IN1 w0.127: v3(118.88,30.31) 118.55,30.31 v4(118.37,30.49)
  IN3 w0.122: v4(66.51,56.32) 66.43,56.24 66.43,55.84 66.56,55.71 66.94,55.71 67.56,55.09 72.01,55.09 76.2,50.9 76.2,49.41 77.09,48.52 77.09,48.31 76.96,48.18 76.4,48.18 76.28,48.3 76.28,48.63 76.15,48.76 75.92,48.76 75.79,48.63 75.79,48.3 75.67,48.18 75.39,48.18 75.27,48.31 75.27,49.14 75.14,49.26 74.91,49.26 74.78,49.14 74.78,48.31 74.65,48.18 74.5,48.18 73.82,48.18 73.69,48.31 73.69,49.03 73.58,49.15 73.33,49.15 73.2,49.03 73.2,47.8 73.31,47.69 76.08,47.69 76.2,47.57 76.2,45.84 75.79,45.43 75.27,45.43 75.16,45.33 75.16,44.8 74.8,44.44 73.28,44.44 73.15,44.31 73.15,42.68 73.99,41.84 73.99,41.44 74.2,41.23 74.2,40.25 74.02,40.07 74.02,39.83 74.14,39.71 74.6,39.71 75.17,39.15 75.17,38.95 75.08,38.87 v4(74.76,38.87)
  IN4 w0.091: v5(65.97,56.32) v4(66.51,56.32) ; v4(118.37,30.49) 118.22,30.65 113.34,30.65 112.9,30.21 112.9,29.97 110.46,27.53 108.75,27.53 107.67,26.45 v10(107.52,26.45) 107.34,26.62 107.34,26.63 107.08,26.88 107.07,26.89 106.05,26.89 105,25.84 102.56,25.84 102.44,25.71 102.44,25.48 102.31,25.35 102.05,25.35 101.93,25.48 101.93,25.71 101.8,25.84 101.52,25.84 101.39,25.71 101.39,25.1 101.27,24.97 100.86,24.97 100.73,25.1 100.73,25.94 100.45,26.22 99.31,26.22 99.18,26.09 99.18,25.86 99.06,25.73 98.74,25.73 98.61,25.86 98.61,26.09 98.48,26.21 98.23,26.21 98.1,26.09 98.1,25.92 97.97,25.79 97.63,25.79 97.51,25.92 97.51,26.57 97.38,26.7 96.72,26.7 v10(96.47,26.45) 96.29,26.62 96.29,26.63 96.04,26.88 96.03,26.88 96.02,26.89 95.01,26.89 93.95,25.84 91.51,25.84 91.39,25.71 91.39,25.48 91.26,25.35 91.01,25.35 90.88,25.48 90.88,25.71 90.75,25.84 90.47,25.84 90.34,25.71 90.34,25.1 90.07,24.82 90.07,23.04 89.99,22.96 89.71,22.96 89.58,23.09 89.58,23.68 89.43,23.83 88.77,23.83 88.64,23.96 88.64,24.44 88.77,24.57 89.05,24.57 89.13,24.64 89.13,25.17 89.68,25.73 89.68,25.94 89.4,26.22 88.42,26.22 88.13,25.94 88.13,25.78 88.01,25.66 86.59,25.66 86.46,25.78 86.46,26.57 86.33,26.7 85.67,26.7 v10(85.42,26.45) 85.24,26.62 85.24,26.63 84.99,26.88 84.97,26.89 83.96,26.89 82.9,25.84 80.46,25.84 80.34,25.71 80.34,25.48 80.21,25.35 79.96,25.35 79.83,25.48 79.83,25.79 79.7,25.92 79.42,25.92 79.3,25.79 79.3,25.1 79.17,24.97 78.76,24.97 78.64,25.1 78.64,25.94 78.36,26.22 77.35,26.22 77.09,25.95 77.09,25.86 76.96,25.73 76.45,25.73 76.23,25.95 75.95,25.95 75.8,25.79 75.54,25.79 75.41,25.92 75.41,26.57 75.28,26.7 74.62,26.7 v10(74.37,26.45) 74.19,26.62 74.19,26.63 73.94,26.88 72.89,26.88 71.85,25.84 69.31,25.84 69.18,25.97 67.89,25.97 66.22,27.64 66.22,29.45 66.99,30.21 66.99,31.69 67.05,31.76 67.05,34.74 68.46,36.15 68.46,36.96 68.76,37.26 68.76,37.98 68.94,38.16 69.01,38.16 69.01,38.17 69.42,38.17 69.5,38.09 69.79,38.09 70.19,38.48 70.19,38.49 71.47,38.49 72.81,37.16 73.57,37.16 73.7,37.29 73.7,38.47 73.82,38.6 74.08,38.6 74.21,38.47 74.21,37.29 74.33,37.16 74.59,37.16 74.71,37.29 74.71,37.78 74.84,37.91 75.09,37.91 75.22,37.78 75.22,37.29 75.35,37.16 76.62,37.16 76.75,37.29 76.75,39.31 76.62,39.43 76.36,39.43 76.24,39.31 76.24,37.76 76.11,37.63 75.86,37.63 75.73,37.76 75.73,39.31 75.6,39.43 75.32,39.43 v4(74.76,38.87)
  GND5 w0.102: v6(65.61,56.72) 65.61,56.67 v5(65.97,56.32)
  BOTTOM w0.076: v10(96.47,26.45) 96.67,26.65 97.86,26.65 97.99,26.52 97.99,26.33 97.86,26.2 UD3.K3 ; v10(107.52,26.45) 107.72,26.65 108.91,26.65 109.04,26.52 109.04,26.33 108.91,26.2 108.67,26.2 UD1.K3 ; UD5.K3 86.57,26.2 86.81,26.2 86.94,26.33 86.94,26.52 86.81,26.65 85.62,26.65 v10(85.42,26.45) ; UD7.K3 75.77,26.2 75.89,26.33 75.89,26.52 75.77,26.65 74.57,26.65 v10(74.37,26.45)
  BOTTOM w0.16: UCPU1.BG35 v6(65.61,56.72)
