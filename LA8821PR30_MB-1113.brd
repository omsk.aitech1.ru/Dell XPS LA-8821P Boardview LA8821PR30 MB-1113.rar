# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N1_CONN: length 26.5
  BOTTOM w0.114: JUSB1.2 217.63,36.31 217.63,37.07 217.46,37.25 216.14,37.25 215.39,36.5 v7(215.39,22.86) 215.39,22.64 215.41,22.62 215.41,20.22 215.57,20.06 D74.6 217.25,20.06 217.33,19.98 217.33,19.75 217.41,19.67 217.52,19.67 217.67,19.82 217.67,20.09 217.43,20.33 217.43,22.08 217.33,22.19 217.1,22.19 216.98,22.31 L40.2 216.87,22.89 R222.2
USB20_N4: length 102.2
  IN1 w0.071: v4(174.38,54.42) 174.14,54.66 173.77,54.66 173.53,54.9 173.53,55.47 172.75,56.25 172.14,56.25 170.42,57.96 168.91,57.96 168.08,57.14 166.39,57.14 163.75,59.78 159.37,59.78 158.59,60.57 155.61,60.57 155.15,61.02 154.99,61.02 150.95,65.06 150.95,65.44 148.74,67.65 146,67.65 145.59,67.25 137.87,67.25 137.47,66.85 137.47,66.41 137.22,66.16 130.08,66.16 129.93,66.01 128.63,66.01 127.94,65.32 127.94,64.78 127.1,63.93 125.35,63.93 124.73,63.32 124.73,61.91 124.92,61.72 124.92,61.16 124.25,60.49 123.67,60.49 122.72,59.54 118.3,59.54 116.38,61.46 114.86,61.46 114.46,61.06 114.01,61.06 113.73,61.34 113.57,61.34 112.97,61.94 112.97,64.9 112.62,65.26 112.62,65.84 v4(112.43,66.03)
  IN4 w0.091: v5(173.87,54.55) 173.99,54.67 174.13,54.67 v4(174.38,54.42) ; v4(112.43,66.03) 112.61,66.21 112.61,66.38 v5(112.48,66.51)
  GND5 w0.076: v6(112.25,65.95) 112.48,66.18 v5(112.48,66.51) ; v6(173.44,54.52) 173.59,54.67 173.74,54.67 v5(173.87,54.55)
  BOTTOM w0.114: v6(112.25,65.95) 112.26,65.96 UH1.M26 ; L49.1 174.41,38.13 174.09,38.45 v7(173.5,38.45) 173.26,38.45 172.86,38.85 172.86,40.49 172.1,41.25 172.1,43.97 172.86,44.73 172.86,46.78 172.7,46.95 172.7,51.53 173.99,52.83 173.99,54.49 173.8,54.68 173.6,54.68 v6(173.44,54.52)
  BOTTOM w0.127: R742.1 174.7,38.06 L49.1
USB20_N4_R: length 9.2
  IN4 w0.071: JWLAN1.36 181.71,41.75 181.4,42.06 181.16,42.06 180.63,41.53 180.63,40.2 178.81,38.38 178.24,38.38 178.19,38.43 177.9,38.43 v5(177.78,38.32)
  GND5 w0.076: v6(177.35,38.32) v5(177.78,38.32)
  BOTTOM w0.114: R742.2 175.95,38.13 L49.2 176.68,38.13 176.93,38.37 177.29,38.37 v6(177.35,38.32)
USB20_N9: length 67.2
  IN4 w0.071: v5(116.11,68.44) 116.26,68.59 116.26,68.73 116.44,68.91 116.75,68.91 117,68.65 118.66,68.65 119.41,69.4 119.41,71.4 121.35,73.35 125.11,73.35 128.14,70.32 130.35,70.32 133.26,67.41 145.1,67.41 145.92,66.59 146.75,66.59 147.49,67.32 149.54,67.32 150.21,66.65 154.49,66.65 154.67,66.47 157.26,66.47 157.37,66.59 157.37,66.69 157.25,66.81 v5(157.23,66.81)
  GND5 w0.076: v5(157.23,66.81) 157.37,66.95 157.37,67.21 v6(157.23,67.35) ; v5(116.11,68.44) 116.11,68.31 115.88,68.08 v6(115.88,68.07)
  BOTTOM w0.114: v6(157.23,67.35) 157.35,67.23 157.35,66.94 157.18,66.77 156.93,66.77 155.32,68.38 155.32,70.62 155.13,70.81 155.13,71.72 155.37,71.96 155.37,74.35 155.77,74.75 157.06,74.75 157.85,75.55 D90.3 157.85,76.98 156.98,77.85 156.98,78.05 v7(157.3,78.36) 157.58,78.64 157.58,78.87 157.75,79.04 JLVDS1.18 ; v6(115.88,68.07) UH1.C29
USB20_N12: length 77.5
  IN4 w0.071: v7(176.47,76.67) 176.34,76.54 171.21,76.54 167.18,72.51 167.18,71.37 166.54,70.73 166.54,69.45 165,67.91 161.59,67.91 161.23,67.55 150.3,67.55 149.33,68.53 147.64,68.53 147.29,68.19 146.27,68.19 145.83,68.63 142.61,68.63 142.33,68.91 139.54,68.91 139.26,68.63 137.94,68.63 137.4,68.1 133.56,68.1 128.88,72.78 126.68,72.78 125.1,74.37 121.46,74.37 118.77,71.68 118.77,69.68 118.38,69.29 116.94,69.29 116.67,69.56 115.92,69.56 115.37,69.01 114.58,69.01 114.34,68.77 114.34,68.55 114.23,68.44 v5(114.21,68.44)
  GND5 w0.076: v5(114.21,68.44) 114.21,68.58 v6(113.99,68.8)
  BOTTOM w0.114: R1005.1 177.38,76.69 L55.4 176.95,76.63 176.78,76.45 176.67,76.45 176.47,76.65 v7(176.47,76.67) ; v6(113.99,68.8) UH1.H30
USB20_N12_CONN: length 9.4
  BOTTOM w0.114: R1005.2 178.95,76.69 L55.3 179.25,76.63 179.99,75.88 180.37,75.88 180.48,75.99 D50.1 180.48,77.77 180.68,77.97 v7(181.07,77.97) 182.62,77.97 183.27,78.62 184.27,78.62 184.41,78.76 184.41,78.94 184.24,79.1 JLVDS2.3
USB20_N13: length 61.5
  TOP w0.076: U636.C1 159.03,62.31 159.03,61.81
  TOP w0.114: 159.03,61.81 159.03,61.19 159.47,60.76 159.75,60.76 v2(160.04,60.46)
  GND1 w0.102: v3(160.1,61.16) 160.1,60.53 v2(160.04,60.46)
  IN1 w0.071: v4(158.99,62.31) 158.99,62.62 159.07,62.71 159.85,62.71 159.98,62.58 159.98,61.28 v3(160.1,61.16)
  IN4 w0.071: v5(112.48,69.41) 112.59,69.3 112.59,69.09 112.85,68.82 113.13,68.82 114.15,67.79 119.02,67.79 120.62,69.4 120.62,70.24 120.75,70.37 120.75,70.88 120.95,71.08 121.08,71.21 122.37,72.49 124.77,72.49 128.34,68.92 128.92,68.92 129.04,68.81 130.28,68.81 133,66.09 140.81,66.09 141.22,66.5 144.86,66.5 145.63,65.74 154.24,65.74 154.7,65.28 155.35,65.28 158.12,62.51 158.78,62.51 v4(158.99,62.31)
  GND5 w0.076: v5(112.48,69.41) 112.48,69.56 112.28,69.76 v6(112.26,69.76)
  BOTTOM w0.114: v6(112.26,69.76) UH1.M33
USB20_P0: length 123.8
  IN1 w0.071: v4(114.1,65.04) 114.14,65.04 114.32,65.21 114.32,65.46 115,66.14 115.57,66.14 115.7,66.27 118.62,66.27 118.99,65.9 119.52,65.9 119.69,66.07 125.07,66.07 127.31,68.3 127.31,69.34 128.97,71.01 129.41,71.01 129.54,71.15 132.51,71.15 133.97,72.61 136.14,72.61 136.59,73.06 138.25,73.06 138.62,72.69 146.57,72.69 146.82,72.44 148.23,72.44 149.54,73.75 153.51,73.75 153.66,73.9 168.35,73.9 169.25,73 181.52,73 184.32,75.8 184.32,75.94 188.19,79.81 193.51,79.81 195.3,78.02 198.09,78.02 201.67,74.43 207.83,74.43 209.57,72.7 209.57,60.64 210.21,60.01 210.47,60.01 v7(210.83,60.36)
  IN4 w0.091: v4(114.1,65.04) 114.26,65.04 114.36,65.14 114.36,65.44 v5(114.23,65.57)
  GND5 w0.076: v6(113.99,65.04) 114.23,65.28 v5(114.23,65.57)
  BOTTOM w0.114: UH1.H24 v6(113.99,65.04) ; v7(210.83,60.36) 210.9,60.43 L52.4 211.76,60.54 R889.1
USB20_P0_CONN: length 10.6
  BOTTOM w0.114: JUSB2.3 218.17,55.77 217.81,55.77 217.7,55.88 217.7,57.31 216.86,58.14 216.39,58.14 216.19,58.34 D82.5 214.89,58.34 214.76,58.22 214.4,58.22 214.32,58.3 214.32,58.65 214.65,58.98 214.65,59.74 v7(214.45,59.95) 214.22,60.18 213.82,60.18 213.57,60.43 L52.3 213.25,60.54 R889.2
USB20_P1: length 127.9
  TOP w0.114: v7(208.59,53.8) 208.81,53.58 209.69,53.58 209.92,53.81 210.56,53.81 210.68,53.93 UI1.6
  IN1 w0.071: v7(208.59,53.8) 208.59,53.7 208.43,53.53 208.21,53.53 208.08,53.66 208.08,54.41 209.4,55.74 209.4,58.94 208.88,59.46 208.88,72.48 207.59,73.77 201.43,73.77 197.84,77.37 194.86,77.37 193.09,79.15 188.43,79.15 185.19,75.9 185.19,75.73 181.63,72.18 168.66,72.18 167.57,73.26 154.26,73.26 154.1,73.1 150.73,73.1 149.03,71.4 146.46,71.4 145.96,71.89 139.16,71.89 138.33,71.07 135.25,71.07 133.4,69.22 131.26,69.22 129.37,67.32 127.25,67.32 125.35,65.43 119.96,65.43 119.77,65.24 118.73,65.24 118.36,65.61 117.78,65.61 117.28,65.1 116.5,65.1 116.35,65.25 116.35,65.34 116.54,65.52 v4(116.59,65.52)
  IN4 w0.091: v4(116.59,65.52) 116.56,65.52 116.39,65.68 116.39,65.87 v5(116.52,66)
  GND5 w0.076: v6(116.75,65.63) 116.52,65.86 v5(116.52,66)
  BOTTOM w0.114: v6(116.75,65.63) UH1.A25
USB20_P1_CONN: length 26.6
  BOTTOM w0.114: R262.2 217.89,22.89 L40.3 217.78,22.36 217.69,22.28 217.69,20.44 217.93,20.2 217.93,19.72 217.62,19.41 D74.5 215.83,19.41 215.59,19.65 215.42,19.65 215.16,19.91 215.16,22.51 215.13,22.53 v7(215.13,25.07) 215.13,36.6 216.03,37.51 217.16,37.51 217.42,37.76 JUSB1.3
USB20_P4: length 102.1
  IN1 w0.071: v4(174.38,55.08) 174.43,55.03 174.43,54.9 174.35,54.83 173.83,54.83 173.69,54.97 173.69,55.54 172.82,56.41 172.21,56.41 170.49,58.13 168.84,58.13 168.02,57.3 166.46,57.3 163.82,59.94 159.44,59.94 158.66,60.73 155.68,60.73 155.22,61.19 155.05,61.19 151.11,65.13 151.11,65.51 148.81,67.82 145.93,67.82 145.52,67.41 137.8,67.41 137.31,66.91 137.31,66.48 137.15,66.32 130.01,66.32 129.86,66.18 128.57,66.18 127.78,65.39 127.78,64.85 127.03,64.1 125.28,64.1 124.57,63.39 124.57,61.85 124.76,61.66 124.76,61.23 124.18,60.65 123.6,60.65 122.65,59.7 118.37,59.7 116.45,61.62 114.79,61.62 114.39,61.23 114.08,61.23 113.8,61.51 113.64,61.51 113.14,62 113.14,64.97 112.78,65.32 112.78,65.9 112.91,66.03 v4(112.99,66.03)
  IN4 w0.091: v5(173.87,54.98) 173.99,54.86 174.16,54.86 v4(174.38,55.08) ; v5(112.88,66.51) 112.87,66.51 112.8,66.43 112.8,66.22 v4(112.99,66.03)
  GND5 w0.076: v5(112.88,66.51) 112.86,66.48 112.86,66.23 v6(113.11,65.98) ; v5(173.87,54.98) 173.73,54.84 173.63,54.84 v6(173.44,55.03)
  BOTTOM w0.114: v6(173.44,55.03) 173.78,55.03 173.86,54.94 173.91,54.94 174.25,54.6 174.25,52.72 172.96,51.42 172.96,47.06 173.12,46.89 173.12,44.62 172.36,43.86 172.36,41.35 173.12,40.59 v7(173.12,40.29) 173.12,38.96 173.37,38.71 174.09,38.71 174.31,38.93 L49.4 ; v6(113.11,65.98) 113.13,65.99 UH1.K26
  BOTTOM w0.127: L49.4 174.79,39.08 R741.1
USB20_P4_R: length 9.3
  IN4 w0.071: JWLAN1.38 181.66,42.55 181.34,42.23 181.09,42.23 180.46,41.59 180.46,40.26 178.74,38.54 178.3,38.54 178.25,38.6 177.93,38.6 v5(177.78,38.75)
  GND5 w0.076: v5(177.78,38.75) v6(177.35,38.75)
  BOTTOM w0.114: v6(177.35,38.75) 177.24,38.63 177.02,38.63 176.72,38.93 L49.3 176.03,38.93 R741.2
USB20_P9: length 67.3
  IN4 w0.071: v5(157.66,66.81) 157.54,66.69 157.54,66.52 157.33,66.31 154.6,66.31 154.42,66.48 150.14,66.48 149.47,67.16 147.56,67.16 146.82,66.42 145.85,66.42 145.03,67.25 133.19,67.25 130.28,70.15 128.07,70.15 125.05,73.18 121.42,73.18 119.57,71.33 119.57,69.33 118.73,68.49 116.94,68.49 116.68,68.75 116.51,68.75 116.43,68.66 116.43,68.53 v5(116.52,68.44)
  GND5 w0.076: v5(116.52,68.44) 116.52,68.31 116.75,68.08 v6(116.75,68.07) ; v5(157.66,66.81) 157.54,66.94 157.54,67.23 v6(157.7,67.4)
  BOTTOM w0.114: JLVDS1.19 157.25,79.04 157.32,78.97 157.32,78.73 156.73,78.14 156.73,77.74 155.95,76.96 D90.1 155.95,75.55 156.04,75.46 156.18,75.46 156.25,75.39 156.25,75.09 156.18,75.01 155.66,75.01 155.11,74.46 155.11,72.06 154.87,71.82 154.87,70.7 155.06,70.51 155.06,68.28 156.83,66.51 157.28,66.51 157.61,66.84 157.61,67.31 v6(157.7,67.4) ; v6(116.75,68.07) UH1.A29
USB20_P12: length 77.4
  IN4 w0.071: v8(176.47,75.96) 176.47,76.18 176.4,76.25 176.27,76.25 176.14,76.38 171.28,76.38 167.34,72.44 167.34,71.3 166.71,70.66 166.71,69.38 165.07,67.74 161.66,67.74 161.3,67.39 150.24,67.39 149.26,68.36 147.71,68.36 147.36,68.02 146.2,68.02 145.76,68.47 142.54,68.47 142.26,68.75 139.61,68.75 139.33,68.47 138.01,68.47 137.47,67.93 133.49,67.93 128.81,72.62 126.62,72.62 125.03,74.2 121.52,74.2 118.93,71.61 118.93,69.61 118.45,69.13 116.87,69.13 116.6,69.39 115.99,69.39 115.44,68.85 114.65,68.85 114.5,68.7 114.5,68.55 v5(114.61,68.44)
  GND5 w0.076: v5(114.61,68.44) 114.61,68.55 v6(114.85,68.8)
  BOTTOM w0.114: R1004.1 177.36,75.78 L55.1 177.03,75.83 176.76,76.1 176.61,76.1 v8(176.47,75.96) ; UH1.F30 v6(114.85,68.8)
USB20_P12_CONN: length 9.5
  BOTTOM w0.114: R1004.2 178.97,75.78 L55.2 179.67,75.83 179.87,75.62 180.16,75.62 180.28,75.5 181.96,75.5 182.38,75.92 D50.3 182.38,77.36 183.38,78.36 v7(183.88,78.36) 184.37,78.36 184.67,78.65 184.67,78.98 184.74,79.06 JLVDS2.2
USB20_P13: length 64.4
  TOP w0.076: 158.81,61.8 158.81,62.2 158.8,62.22 158.8,62.55 159.05,62.8 U636.C2
  TOP w0.114: R1104.1 162.17,59.84 R817.2 159.9,59.96 v2(159.46,60.4) v7(159.07,60.79) 158.81,61.05 158.81,61.8
  GND1 w0.102: v3(159.67,61.16) 159.67,60.62 v2(159.46,60.4)
  IN1 w0.091: v4(159.57,62.29) 159.8,62.06 159.8,61.29 v3(159.67,61.16)
  IN4 w0.071: v5(112.88,69.41) 112.86,69.41 112.75,69.3 112.75,69.16 112.92,68.98 113.2,68.98 114.22,67.96 118.95,67.96 120.45,69.46 120.45,70.3 120.59,70.44 120.59,70.95 120.79,71.14 120.97,71.32 122.3,72.66 124.83,72.66 128.4,69.09 128.99,69.09 129.1,68.98 130.35,68.98 133.07,66.26 140.74,66.26 141.15,66.66 144.93,66.66 145.69,65.9 154.31,65.9 154.77,65.44 155.42,65.44 158.19,62.67 159.19,62.67 v4(159.57,62.29)
  GND5 w0.076: v5(112.88,69.41) 112.88,69.51 v6(113.13,69.75)
  BOTTOM w0.114: UH1.K33 v6(113.13,69.75)
USB_MCARD1_DET#: length 101.9
  IN2 w0.094: v4(178.54,45.11) 177.49,45.11 176.59,46.01 176.59,49.75 174.65,51.69 171.08,51.69 170.79,51.4 170.14,51.4 169.88,51.14 168.31,51.14 167.81,50.65 163.53,50.65 162.78,49.9 159.3,49.9 157.95,48.54 148.91,48.54 145.89,51.56 145.89,53.67 143.44,56.12 140.94,56.12 140.24,56.82 139.16,56.82 137.44,58.54 136.64,58.54 135.98,59.19 135.47,59.19 135.14,58.87 134.77,58.87 133.93,59.71 130.17,59.71 129.47,60.4 127.31,60.4 126.92,60.79 126.93,60.79 126.93,62.21 126.77,62.37 126.77,63.09 124.95,64.91 119.39,64.91 117.83,66.46 115.61,66.46 115.08,66.99 113,66.99 112.17,67.83 112.17,71.87 112.39,72.09 112.8,72.09 113.29,71.6 116.35,71.6 116.96,72.21 v7(117.43,72.21)
  IN4 w0.071: JWLAN1.40 180.27,43.35 178.57,45.05 178.57,45.08 v4(178.54,45.11)
  BOTTOM w0.122: RH301.1 v1(118.9,73.45) 118.9,73.44 117.7,72.25 117.47,72.25 v7(117.43,72.21) 117.43,72.25 117.14,72.54 UH1.A41
USB_OC0#: length 141.1
  TOP w0.122: v7(217.89,66.31) 217.15,65.57 v1(217.15,64.91) 217.15,60.64 215.82,59.31 U657.5 ; v7(125.6,62.28) 126.04,62.28 126.13,62.19 RH318.1
  IN1 w0.071: v4(130.59,65.34) 130.52,65.27 129.47,65.27 128.52,64.33 128.17,64.33 127.28,63.44 125.55,63.44 125.23,63.11 125.23,62.65 v7(125.6,62.28)
  IN2 w0.094: v4(116.87,62.62) 117.55,62.62 117.71,62.46 119.29,62.46 119.82,62.99 123.48,62.99 124.19,62.28 v7(125.6,62.28) ; v7(217.89,66.31) 216.57,67.63 216.57,69.34 213.91,72 213.91,73.77 211.53,76.15 210.19,76.15 209.53,76.81 202,76.81 199.71,79.09 198.29,79.09 196.71,80.67 190.35,80.67 185.64,75.96 185.64,74.93 182.18,71.46 180.66,71.46 180.15,70.96 179.7,70.96 175.54,66.8 175.54,62.69 174.36,61.51 170.89,61.51 168.85,63.55 166.26,63.55 165.6,62.89 163.92,62.89 162.48,61.45 158.28,61.45 157.63,62.1 156.34,62.1 156.11,62.34 153.06,62.34 152,61.28 150.57,61.28 149.51,62.34 148.63,62.34 146.77,64.2 144.78,64.2 144.2,64.78 136.7,64.78 134.98,63.06 132.49,63.06 130.59,64.96 v4(130.59,65.34)
  IN4 w0.071: v5(116.73,63.11) 116.87,62.97 v4(116.87,62.62)
  GND5 w0.104: v5(116.73,63.11) 116.73,63.11 116.41,62.79 v6(116.3,62.79)
  BOTTOM w0.122: UH1.C17 v6(116.3,62.79)
USB_OC1#: length 142.5
  TOP w0.122: U656.5 212.82,55.76 212.63,55.94 212.26,55.94 211.82,56.39 211.82,58.43 212.59,59.21 212.59,61.77 v7(212.94,62.12) ; v7(123.12,62.5) 123.34,62.5 RH321.1 124.51,63.68 129.13,63.68 v2(129.39,63.94)
  GND1 w0.104: v2(129.39,63.94) v3(129.83,63.94)
  IN1 w0.071: v3(129.83,63.94) v4(130.23,64.35)
  IN2 w0.094: v7(212.94,62.12) 212.99,62.17 214.4,62.17 216.14,63.9 216.14,69.43 213.58,71.98 213.58,73.69 211.42,75.84 210.22,75.84 209.45,76.61 201.92,76.61 199.63,78.9 198.21,78.9 196.63,80.47 190.43,80.47 186.04,76.08 186.04,75.04 182.26,71.27 180.74,71.27 180.15,70.68 179.69,70.68 175.9,66.89 175.9,62.75 174.47,61.31 170.81,61.31 168.89,63.23 166.43,63.23 165.79,62.6 164.04,62.6 162.27,60.82 157.76,60.82 157.51,61.07 157.51,61.53 157.14,61.9 156.23,61.9 155.99,62.14 153.14,62.14 152.08,61.08 150.49,61.08 149.43,62.14 148.55,62.14 146.69,64 144.7,64 144.12,64.58 137.12,64.58 136.17,63.63 136.17,63.06 135.86,62.75 133.28,62.75 133.17,62.86 132.41,62.86 130.92,64.35 v4(130.23,64.35)
  BOTTOM w0.122: UH1.A17 116.81,62.85 117.57,62.85 118.12,62.31 v1(118.46,62.31) 118.8,62.31 118.94,62.17 120.3,62.17 121.09,61.38 122.5,61.38 122.59,61.47 122.59,62 123.09,62.5 v7(123.12,62.5)
USB_OC2#: length 11.1
  TOP w0.122: v7(125.67,62.96) 125.92,63.21 RH317.1
  BOTTOM w0.122: UH1.A13 116.81,61.1 117.57,61.1 117.66,61.01 v1(118.43,61.01) 120.09,61.01 120.56,60.54 122.99,60.54 125.41,62.96 v7(125.67,62.96)
USB_OC3#: length 13.8
  TOP w0.122: v7(125.84,61.01) 126.11,61.01 126.7,60.41 RH320.1
  IN2 w0.094: v7(125.84,61.01) 125.42,61.01 124.62,61.81 123.87,61.81 123.43,61.37 118.03,61.37 v4(117.66,61)
  IN4 w0.071: v5(115.7,62.75) 115.88,62.57 115.88,62.32 117.2,61 v4(117.66,61)
  GND5 w0.104: v6(115.88,62.38) 115.88,62.57 v5(115.7,62.75)
  BOTTOM w0.122: UH1.D16 v6(115.88,62.38)
USB_OC4#: length 9.9
  TOP w0.122: RH323.1 122.89,61.3 v2(122.33,60.74)
  GND1 w0.104: v2(122.33,60.74) 122.18,60.74 v3(121.83,60.39)
  IN1 w0.071: v4(122.31,60.23) 121.98,60.23 v3(121.83,60.39)
  IN4 w0.071: v5(122.59,59.8) 122.59,59.96 122.31,60.23 v4(122.31,60.23)
  GND5 w0.104: v5(122.59,59.8) 122.23,59.8 v6(122.15,59.72)
  BOTTOM w0.122: UH1.A11 117.75,60.35 118.37,59.73 v1(118.82,59.73) 119.07,59.98 121.88,59.98 v6(122.15,59.72)
USB_OC5#: length 8.9
  TOP w0.122: RH322.1 123.64,62.19 123.31,61.86 v7(123.1,61.86)
  BOTTOM w0.122: UH1.B16 116.83,62.38 117.08,62.62 117.48,62.62 118.29,61.82 v1(119.7,61.82) 120.19,61.82 120.89,61.13 122.6,61.13 123.1,61.62 v7(123.1,61.86)
USB_PWR_EN#: length 118.2
  TOP w0.076: v2(140.43,55.59) 140.43,55.75 140.67,55.99 140.67,56.35 U34.L12
  TOP w0.122: U657.4 208.57,59.31 208.55,59.33 R887.2 208.08,59.12 208.35,58.86 209.68,58.86 209.72,58.81 v2(210.07,58.81)
  GND1 w0.104: v2(140.43,55.59) 140.39,55.62 v3(140.39,56.12) ; v2(210.07,58.81) v3(210.07,59.25)
  IN1 w0.071: v4(151.94,60.67) 151.94,60.17 150.44,58.68 148.66,58.68 147.83,57.85 147.3,57.85 147.04,57.59 146.3,57.59 146.18,57.47 145.31,57.47 144.29,58.48 141.43,58.48 141.29,58.34 141.29,57.96 141.48,57.77 141.48,57.47 140.39,56.38 v3(140.39,56.12) ; v4(210.55,59.04) 210.27,59.04 v3(210.07,59.25)
  IN2 w0.094: v4(210.55,59.04) 210.85,59.04 212.02,60.21 212.02,63.18 215.93,67.09 215.93,69.34 211.71,73.56 211.71,75.28 211.34,75.65 210.14,75.65 209.37,76.41 201.84,76.41 199.55,78.7 198.13,78.7 196.55,80.28 190.51,80.28 186.87,76.64 186.87,75.61 182.34,71.07 180.82,71.07 180.13,70.38 179.68,70.38 176.1,66.8 176.1,62.67 174.55,61.12 170.73,61.12 168.85,62.99 166.7,62.99 166.02,62.32 164.35,62.32 162.66,60.63 157.04,60.63 155.73,61.94 153.22,61.94 151.94,60.66 v4(151.94,60.67)
USBCHG_DET#: length 139.3
  TOP w0.122: v1(136.84,69.75) 137.03,69.94 D83.1 139.82,70.59 v7(139.71,70.7)
  IN2 w0.094: JUSB1.10 220.19,41.68 219.29,40.78 218.47,40.78 216.85,42.41 216.85,47.39 216.22,48.02 216.22,52.88 215.15,53.94 213.19,53.94 212.43,54.7 212.43,55.44 214.21,57.21 214.21,61.43 218.29,65.52 218.29,66.71 217.56,67.45 217.56,71.59 216.01,73.14 216.01,74.84 213.65,77.2 212.16,77.2 211.12,78.25 202.75,78.25 200.5,80.5 198.88,80.5 197.38,81.99 197.38,82.35 195.27,84.47 193.25,84.47 192.82,84.04 183.12,84.04 179.19,80.11 171.99,80.11 167.82,75.95 167.82,73.59 165.95,71.72 165.2,71.72 164.73,71.25 164.73,68.71 164.55,68.53 154.25,68.53 153,67.28 150.62,67.28 150.08,67.81 147.9,67.81 147.2,68.52 147.2,68.88 146.52,69.56 143.16,69.56 142.42,70.29 141.61,70.29 141.43,70.47 139.94,70.47 v7(139.71,70.7)
USBCHG_DET_D: length 66.4
  TOP w0.122: R938.1 v1(143.5,71.72) 143.85,71.37 143.85,70.54 Q321.1 143.25,69.34 143.52,69.08 v7(144.18,69.08) ; v7(188.32,74.33) 188.59,74.6 PD906.2
  IN2 w0.094: v7(183.57,81.43) 183.56,81.43 183.37,81.62 180.98,81.62 179.24,79.88 172.32,79.88 168.12,75.68 168.12,73.61 166.03,71.52 165.28,71.52 164.93,71.17 164.93,68.53 164.71,68.31 160.1,68.31 159.5,67.71 157.58,67.71 157.01,68.28 154.28,68.28 153.09,67.08 150.54,67.08 150,67.62 147.82,67.62 147.24,68.2 146.32,68.2 145.94,68.58 144.67,68.58 v7(144.18,69.08)
  BOTTOM w0.122: v7(188.32,74.33) 188.27,74.28 187.85,74.28 187.15,74.98 187.15,79.72 184.89,81.98 183.99,81.98 183.57,81.56 v7(183.57,81.43)
USBCHG_DET_EC#: length 22.5
  TOP w0.076: 138.23,57.82 138.25,57.82 138.55,58.13 138.55,58.25 138.9,58.6 U34.N8
  TOP w0.122: D83.3 137.92,69.28 136.3,67.66 v1(136.29,67.66) 136.29,67.39 134.12,65.21 134.12,62.78 132.48,61.14 132.48,57.12 v2(133,56.6) ; 138.23,57.82 137.86,57.82 137.7,57.66 v2(137.28,57.66)
  GND1 w0.104: v2(137.28,57.66) 137.08,57.66 v3(136.85,57.43) ; v2(133,56.6) v3(133.43,56.6)
  IN1 w0.071: v3(133.43,56.6) 136.02,56.6 v3(136.85,57.43)
USBCHG_DET_PWR_EN#: length 7.4
  TOP w0.122: D83.2 137.24,70.59 136.81,71.02 v1(136.81,71.18) 136.81,71.35 137.18,71.72 R939.2 138.3,71.21 139.19,71.21 R941.2 140.06,71.35 140.06,71.03 140.5,70.59 Q321.2
USBRBIAS: length 4.4
  TOP w0.122: v7(117.11,69.74) 116.68,69.3 RH163.1
  BOTTOM w0.122: UH1.C33 UH1.A33 116.75,69.35 117.11,69.72 v7(117.11,69.74) 117.95,69.74 118.45,69.24 v1(119.04,69.24)
V_DDR_REFA_R: length 24.4
  TOP w0.122: v1(89.87,44.44) 89.87,44.89 v7(90.2,45.23)
  IN3 w0.381: v7(90.2,45.23) 90.25,45.28 90.25,45.45 90.3,45.5 90.3,45.94 79.28,56.96 v4(79.28,57.7)
  IN4 w0.254: v5(79.79,57.98) 79.56,57.98 v4(79.28,57.7)
  GND5 w0.254: v5(79.79,57.98) 79.79,58.08 v6(79.53,58.33)
  BOTTOM w0.254: UCPU1.BE7 79.45,58.24 v6(79.53,58.33)
  BOTTOM w0.381: RD29.1 90.67,46.43 90.25,46.01 90.25,45.28 v7(90.2,45.23) ; RD29.1 92.26,46.43 92.56,46.12 QD1.3 ; RD29.1 RD27.2
V_DDR_REFB_R: length 31.5
  TOP w0.381: QD2.3 94.06,45.66 92.89,46.82 92.23,46.82 91.4,46 RD32.1 RD30.2
  TOP w0.508: QD2.3 94.5,43.83 93.23,42.56 v9(90.99,42.56) 89.67,42.56 v7(89.06,43.17)
  IN3 w0.508: v7(89.06,43.17) 88.68,43.17 86.77,45.07 86.77,47.61 v7(79.69,54.7)
  BOTTOM w0.254: 79.66,56.96 79.46,57.16 UCPU1.BG7
  BOTTOM w0.381: v7(79.69,54.7) 79.66,54.72 79.66,56.96
VCIN0_PH: length 220
  TOP w0.122: R925.1 149.05,63.39 149.05,65.41 148.72,65.74 148.19,65.74 147.91,66.01 147.91,67.81 149.4,69.29 149.4,70.37 v7(149.26,70.51) ; v2(71.38,70.12) 71.94,70.12 PH901.1 ; v2(89.78,55.35) 89.64,55.21 87.85,55.21 82.05,49.4 79.06,49.4 78.33,50.13 74,50.13 73.92,50.05 73.34,50.05 73,49.71 63.62,49.71 62.7,50.63 56.54,50.63 55.89,49.97 55.52,49.97 54.11,51.38 54.11,55.51 v1(50.63,58.99) 48.09,61.53 v7(47.81,61.53)
  GND1 w0.104: v3(90.47,55.42) 90.39,55.35 v2(89.78,55.35) ; v3(70.95,70.12) v2(71.38,70.12)
  IN1 w0.071: v4(153.08,44.6) 151.85,45.83 148.67,45.83 147.12,47.38 146.27,47.38 146.09,47.57 146.09,48.01 144.63,49.47 133.51,49.47 130.89,52.09 127.56,52.09 127.19,51.72 125.57,51.72 125.01,51.15 114.08,51.15 113.87,50.94 111.24,50.94 110.88,51.31 106.67,51.31 105.7,52.29 102.99,52.29 102.7,52.58 102,52.58 101.66,52.92 96.92,52.92 96.41,52.41 95.71,52.41 95.4,52.72 93.59,52.72 91.97,54.34 91.97,54.68 91.24,55.41 90.48,55.41 v3(90.47,55.42) ; v3(70.95,70.12) 70.95,69.33 69.6,67.98 54.01,67.98 53.68,68.31 52.81,68.31 47.81,63.31 v7(47.81,61.53)
  IN2 w0.094: v7(47.81,61.53) 47.81,58.85 45.12,56.16 41.35,56.16 34.63,49.44 v7(34.11,49.44)
  IN4 w0.071: v5(153.09,45.58) 153.08,45.57 v4(153.08,44.6)
  GND5 w0.104: v5(153.09,45.58) v6(153.09,46.01)
  BOTTOM w0.122: v6(153.09,46.01) 153.28,46.2 153.28,47.26 153.08,47.46 149.45,47.46 149.12,47.8 149.12,56.64 152.6,60.12 152.6,68.64 152.15,69.09 151.23,69.09 149.8,70.51 v7(149.26,70.51) ; v7(34.11,49.44) 33.81,49.15 32.23,49.15 30.84,47.76 PR935.1
VCIN0_PH_R: length 7.8
  TOP w0.076: v2(144.55,61.24) 144.42,61.38 U34.C2
  TOP w0.122: R925.2 147.52,62.95 v2(147.14,63.33) 147.09,63.33 v1(146.78,63.03)
  GND1 w0.104: v2(147.14,63.33) v3(147.14,63.78) ; v3(144.16,62.04) 144.55,61.65 v2(144.55,61.24)
  IN1 w0.071: v3(147.14,63.78) 146.98,63.93 144.69,63.93 144.38,63.63 144.38,63.49 143.99,63.1 143.99,62.21 v3(144.16,62.04)
VCIN1_PH: length 4.7
  TOP w0.254: v1(122.65,28.89) 123.25,28.29 PC911.1 PR937.2 PR936.1 R926.1
VCIN1_PH_R: length 128.2
  TOP w0.076: U34.D2 144.17,61.85 144.17,62.79 v2(144.27,62.89)
  TOP w0.122: v2(122.8,25.96) 122.35,26.41 R926.2
  GND1 w0.104: v2(122.8,25.96) 122.8,25.58 v3(122.74,25.51) ; v3(143.94,63.47) 144.27,63.14 v2(144.27,62.89)
  IN1 w0.071: v3(143.94,63.47) 144.58,64.11 149.71,64.11 149.94,63.89 149.94,63.33 150.67,62.6 152.25,62.6 154.03,60.82 154.03,59.5 154.5,59.02 156.19,59.02 156.79,58.43 162.7,58.43 163.6,57.53 164.77,57.53 166.03,56.27 168.44,56.27 168.89,56.72 170.44,56.72 171.91,55.26 171.91,54.29 172.68,53.53 175.2,53.53 180.12,48.6 180.12,38.71 180.38,38.45 180.38,34.05 180.7,33.73 180.7,33.08 176.99,29.38 176.99,29.04 173.86,25.91 169.62,25.91 168.94,25.23 145.54,25.23 144.43,24.12 142.91,24.12 140.79,22 136.14,22 134.13,24.01 130.85,24.01 130.61,24.24 124.01,24.24 v3(122.74,25.51)
VCOMP: length 2.3
  BOTTOM w0.254: PC33.1 150.98,40.79 150.1,39.9 149.61,39.9 149.52,39.81 PU2.7
VCOMP1: length 38.7
  IN1 w0.254: v7(119.95,35.95) 125.86,35.95 128.33,38.42 132.77,38.42 135.81,41.45 141.6,41.45 144.05,43.9 149.56,43.9 150.37,43.9 152.51,41.77 v7(152.51,41.35)
  BOTTOM w0.254: PC36.2 152.7,40.55 152.51,40.74 v7(152.51,41.35)
  vias: v7(118.5,35.95) v7(118.47,35.29) v7(119.18,35.93) v7(119.16,35.27) v7(119.92,35.29) v9(122.94,38.39)
VCOUT0_PH#: length 65.7
  TOP w0.122: v7(184.09,57.1) 184.09,57.39 v1(184.33,57.63) ; PR971.1 v7(186.71,69.34)
  TOP w0.254: U34.E4 143.58,60.76 143.58,61.19 v2(143.68,61.29) ; v2(147.08,61.71) 147.08,61.81 147.34,62.06 R922.1 ; v7(184.09,57.1) 184.02,57.02 PR211.1
  GND1 w0.254: v3(143.71,61.96) 143.71,61.32 v2(143.68,61.29) ; v2(147.08,61.71) 147.07,61.71 146.77,62.01 v3(146.74,62.01)
  IN1 w0.254: v4(147.31,62.28) 147.24,62.28 146.97,62.01 v3(146.74,62.01) 146.72,62.04 146.72,62.17 146.49,62.39 145.88,62.39 145.74,62.54 145.02,62.54 144.55,62.07 144.55,61.84 144.37,61.66 144,61.66 143.71,61.95 v3(143.71,61.96) ; v7(186.71,69.34) 186.71,67.15 185.53,65.97 185.53,61.3 184.92,60.69 184.92,59.65 185.35,59.22 185.35,58.19 184.65,57.49 184.49,57.49 v7(184.09,57.1)
  IN2 w0.254: v4(147.31,62.28) 147.31,60.61 148.41,59.51 150.14,59.51 150.62,59.03 151.19,59.03 151.84,58.38 152.74,58.38 153.03,58.67 153.57,58.67 154.03,59.14 156.02,59.14 156.43,58.72 161.39,58.72 162.64,57.47 167.58,57.47 168.65,58.53 170.93,58.53 172.04,59.65 180.78,59.65 182.94,57.49 183.7,57.49 v7(184.09,57.1)
VFB: length 3.2
  BOTTOM w0.254: PU2.8 150.49,38.71 150.68,38.9 150.68,39.31 151.34,39.97 PR37.1 151.87,40.2 PR36.2
VGATE: length 173.6
  TOP w0.076: v2(138.89,57.1) 139.03,57.1 139.29,57.35 139.67,57.35 U34.M10
  TOP w0.254: RH273.1 113.79,51.43 114.21,51.85 v2(114.21,51.88)
  GND1 w0.254: v3(113.77,51.78) 113.88,51.88 v2(114.21,51.88) ; v3(138.54,56.83) 138.59,56.83 138.86,57.1 v2(138.89,57.1)
  IN1 w0.254: v7(29.67,76.39) 30.21,76.39 33.95,80.14 34.32,80.14 36.51,82.32 v4(37.62,82.32) ; v3(138.54,56.83) 138.54,56.44 138.47,56.37 138.47,54.2 136.15,51.88 134.02,51.88 132.9,53 125.94,53 124.74,51.79 113.79,51.79 v3(113.77,51.78) 113.58,51.58 111.51,51.58 111.14,51.95 106.95,51.95 105.9,52.99 105.58,52.99 104.99,53.59 103.26,53.59 102.89,53.23 102.26,53.23 101.92,53.56 96.25,53.56 95.87,53.17 93.78,53.17 93.33,53.63 93.33,54.42 92.82,54.93 v4(92.82,55.03)
  IN2 w0.254: v4(95.49,78.6) 95.31,78.42 95.31,75.53 94.67,74.89 94.67,73.86 95.73,72.81 96.86,72.81 100.13,69.53 100.13,68.47 102.85,65.75 102.85,65.32 103.26,64.91 103.26,62.45 104.75,60.95 104.75,59.72 102.83,57.8 96.62,57.8 93.85,55.03 v4(92.82,55.03)
  IN4 w0.254: v4(95.49,78.6) 94.93,78.04 93.89,78.04 93.49,77.65 93.49,77.37 92.69,76.57 91.54,76.57 90.4,75.43 87.05,75.43 79.42,83.05 75.66,83.05 73.91,84.81 46.82,84.81 46.25,84.24 41.62,84.24 40.8,83.43 40.32,83.43 39.74,82.84 38.79,82.84 38.27,82.32 v4(37.62,82.32)
  BOTTOM w0.254: PU700.19 26.62,79.14 27.13,78.63 28.25,78.63 28.81,78.07 PR728.1 28.89,77.18 v9(29.06,77) v7(29.67,76.39)
VLDOIN_1.35V:
  vias: v1(34.58,23.76)
VOLUME_DOWN_SW#: length 168.8
  TOP w0.122: v2(93.28,54.44) 93.28,54.32 91.06,52.1 89,52.1 83.31,46.41 80.51,46.41 80.13,46.02 61.14,46.02 60.36,46.81 58.24,46.81 57.3,45.87 56,45.87 55.29,46.58 36.84,46.58 36.12,45.86 32.68,45.86 32.1,46.44 28.09,46.44 27.44,47.1 v1(22.75,47.1) 22.08,47.1 v7(21.7,46.72) ; R954.1 142.08,64.26 141.6,63.78 141.29,63.78 141.23,63.72 v2(141.23,62.85) 141.42,62.66 U34.J1 ; v7(26.6,21.68) 26.47,21.81 R955.2 25.9,22.28 25.93,22.32 C1124.1
  GND1 w0.104: v3(140.79,62.81) 141.19,62.81 v2(141.23,62.85) ; v2(93.28,54.44) 93.3,54.47 v3(93.3,55.04)
  IN1 w0.071: v3(140.79,62.81) 140.79,63.04 140.42,63.41 139.76,63.41 139.3,62.95 139.3,62.59 139,62.28 137.54,62.28 137.05,62.76 136.36,62.76 136.02,62.43 135.54,62.43 134.51,61.4 133.88,61.4 132.47,59.99 132.01,59.99 131.22,59.2 131.22,59.07 127.6,55.46 125.67,55.46 124.72,54.51 121.55,54.51 121.31,54.27 117.3,54.27 116.97,53.93 111.84,53.93 111.74,54.04 108.67,54.04 108.49,54.22 108.09,54.22 108.03,54.16 106.45,54.16 106.23,54.38 93.96,54.38 v3(93.3,55.04)
  IN2 w0.094: v7(21.7,46.72) 21.99,47.01 23.55,47.01 24.14,46.42 24.14,45.53 24.09,45.48 24.09,44.49 19.91,40.31 19.91,35.31 20.86,34.35 20.86,27.36 20.85,27.35 20.85,26.53 21.5,25.88 21.5,24.92 22.11,24.32 23.9,24.32 25.79,22.42 25.86,22.42 v7(26.6,21.68)
VOLUME_DOWN_SW#_C: length 4.4
  TOP w0.122: R955.1 24.09,20.92 v1(22.87,20.92) v7(21.98,20.92)
  BOTTOM w0.122: v7(21.98,20.92) 22.1,20.8 JIOL1.33
VOLUME_UP_SW#: length 204
  TOP w0.122: v2(26.73,43.09) 27.34,43.71 30.97,43.71 31.55,43.13 37.26,43.13 37.88,43.75 44.14,43.75 44.61,43.27 44.61,42.33 45.05,41.89 45.71,41.89 45.93,42.11 48.87,42.11 49.67,42.91 52.64,42.91 52.95,42.61 53.9,42.61 54.47,42.03 64.06,42.03 64.26,42.24 75.57,42.24 77.15,40.66 83.17,40.66 v1(84.36,41.84) v7(86.47,43.95) ; U34.A9 145.69,58.37 146.29,58.37 146.45,58.2 146.45,57.51 146.63,57.32 146.63,56.97 146.95,56.66 146.95,55.95 147.19,55.71 147.19,55.37 147.39,55.17 149.07,55.17 149.88,54.36 149.88,53.26 149.47,52.86 149.47,48.64 149.35,48.51 149.35,48.51 v2(147.33,46.49) ; C1123.1 24.98,20.45 24.98,20.44 R953.2 24.51,19.96 24.47,19.99 21.02,19.99 20.78,20.23 16.31,20.23 14.26,22.29 13.94,22.29 12.4,23.83 12.4,25.26 11.46,26.2 v7(11.46,27.17)
  GND1 w0.104: v3(146.74,46.2) 147.04,46.49 v2(147.33,46.49) ; v2(26.73,43.09) v3(26.3,43.09)
  IN1 w0.071: v4(142.16,47.27) 142.93,46.5 145.11,46.5 145.41,46.2 v3(146.74,46.2) ; v3(26.3,43.09) 26.11,43.28 26.11,44.75 25.1,45.76 24.65,45.76 24.11,45.22 22.21,45.22 21.4,46.04 20.86,46.04 20.02,45.2 19.02,45.2 18.74,45.48 18.12,45.48 17.53,44.89 16.39,44.89 15.22,43.73 15.22,42.16 14.79,41.73 14.79,41.04 13.68,39.93 13.68,34.39 14.29,33.78 14.29,30.52 13.9,30.13 13.9,29.88 11.46,27.44 v7(11.46,27.17)
  IN2 w0.094: v7(86.47,43.95) 86.47,44.84 93.78,52.16 94.52,52.16 95.88,53.52 101.51,53.52 103.2,51.83 105.4,51.83 105.74,51.48 118.55,51.48 118.74,51.3 122.63,51.3 123.12,51.78 125.18,51.78 125.9,51.06 127,51.06 127.55,51.61 131.64,51.61 132.03,51.22 132.75,51.22 133.72,50.24 137.95,50.24 140.56,47.63 141.8,47.63 v4(142.16,47.27)
  BOTTOM w0.122: R952.1 11.28,26.98 v7(11.46,27.17)
VOLUME_UP_SW#_C: length 3.3
  TOP w0.122: v7(22.66,18.96) 22.75,19.04 v1(23.63,19.04) R953.1
  BOTTOM w0.122: JIOL1.35 22.6,19.03 v7(22.66,18.96)
VR_HOT#: length 29
  TOP w0.122: R265.2 46.12,83.68 v1(44.88,84.92)
  TOP w0.254: PC717.1 25.71,83.99 v7(25.36,84.34) ; R265.2 46.18,83.05 v7(46.21,83.02)
  IN1 w0.254: v7(25.36,84.34) 28.33,84.34 28.86,83.81 31.48,83.81 33.79,81.5 v4(34.4,81.5)
  IN4 w0.254: v4(34.4,81.5) 34.74,81.15 38.66,81.15 39.29,81.78 40.18,81.78 40.77,82.36 41.24,82.36 41.98,83.1 46.13,83.1 v7(46.21,83.02)
  BOTTOM w0.254: PU700.8 24.58,83.64 25.28,84.34 v7(25.36,84.34) 25.97,84.95 PR725.2
VR_ON: length 135.1
  TOP w0.122: v2(142.2,59.76) 142.2,59.83 U34.H5
  GND1 w0.104: v3(142.46,59.34) 142.2,59.61 v2(142.2,59.76)
  IN1 w0.071: v4(142.01,59.16) 142.19,59.34 v3(142.46,59.34)
  IN1 w0.254: v4(92.54,77.15) 92.84,76.85 92.84,76.37 93.91,75.3 93.91,74.49 96.12,72.28 96.12,71.79 97.19,70.73 100.77,70.73 101.19,71.15 101.92,71.15 102.92,70.15 103.57,70.15 104.26,69.46 107.3,69.46 107.93,68.82 108.79,68.82 109.91,67.7 111.02,67.7 111.29,67.98 112.51,67.98 112.53,67.95 112.55,67.97 v4(112.56,67.97)
  IN2 w0.094: v4(112.56,67.97) 112.56,68 112.66,68.1 113.66,68.1 114.13,67.63 116.95,67.63 117.77,66.8 117.95,66.8 119.51,65.24 125.15,65.24 126.96,63.43 126.96,62.45 127.15,62.27 127.15,60.84 127.37,60.62 129.76,60.62 130.48,59.9 134.71,59.9 134.98,59.63 137.09,59.63 137.32,59.4 138.69,59.4 139.2,58.89 140.31,58.89 140.58,59.16 v4(142.01,59.16)
  IN4 w0.254: v7(27.57,85.92) 27.66,85.92 27.67,85.93 28.72,85.93 29.37,86.58 29.89,86.58 30.3,86.17 30.3,85.23 31.3,84.23 33.4,84.23 34.72,82.91 38.35,82.91 38.65,83.2 39.59,83.2 40.18,83.78 40.66,83.78 41.47,84.59 46.1,84.59 46.67,85.16 74.05,85.16 75.81,83.41 79.57,83.41 87.07,75.91 90.38,75.91 91.62,77.15 v4(92.54,77.15)
  BOTTOM w0.254: v7(27.57,85.92) PR723.1
VR_SVID_ALRT#: length 46.2
  TOP w0.122: v1(24.42,83.87) 23.98,84.3 v7(23.98,84.34) ; RC94.2 RC93.2 v2(61.67,82.44)
  GND1 w0.104: v2(61.67,82.44) v3(61.22,82.44)
  IN1 w0.071: v4(32.34,80.68) 32.24,80.78 29.98,80.78 27.84,82.92 26.07,82.92 25.92,83.07 25.2,83.07 23.98,84.29 v7(23.98,84.34) ; v3(61.22,82.44) v4(60.71,82.44)
  IN4 w0.071: v4(32.34,80.68) 32.72,80.31 37.95,80.31 38.25,80 40.08,80 42.32,82.24 45.15,82.24 46.51,80.88 48.52,80.88 50.65,83.01 57.48,83.01 58.4,82.09 59.18,82.09 59.47,81.8 60.08,81.8 v4(60.71,82.44)
  BOTTOM w0.122: v7(23.98,84.34) 23.98,84.14 23.77,83.93 PU700.6
VR_SVID_CLK: length 49.1
  TOP w0.122: v7(23.37,84.24) 23.37,83.82 23.3,83.75 v1(23.3,83.17) ; RC92.2 v2(62.56,82.44)
  GND1 w0.104: v2(62.56,82.44) v3(62.56,81.99)
  IN1 w0.071: v3(62.56,81.99) v4(62.56,81.47) ; v7(23.37,84.24) 23.37,84.09 24.95,82.51 25.69,82.51 25.84,82.36 27.61,82.36 29.74,80.23 v4(31.86,80.23)
  IN4 w0.071: v4(62.56,81.47) 61.73,81.47 61.31,81.05 59.69,81.05 59.03,81.71 58.24,81.71 57.32,82.63 50.82,82.63 48.68,80.49 46.35,80.49 44.99,81.85 42.46,81.85 40.24,79.63 38.09,79.63 37.79,79.93 32.15,79.93 v4(31.86,80.23)
  BOTTOM w0.122: PR719.2 23.37,84.87 v7(23.37,84.24) PU700.5
VR_SVID_DAT: length 48.6
  TOP w0.122: v2(59.39,80.02) 59.7,79.71 RC96.2
  GND1 w0.104: v3(59.85,79.75) 59.67,79.75 v2(59.39,80.02)
  IN1 w0.071: v4(32.77,81.11) 32.54,81.34 30.21,81.34 29.52,82.03 29.52,82.38 29.65,82.51 30.92,82.51 31.05,82.64 31.05,82.91 30.92,83.03 28.52,83.03 27.69,83.86 25.12,83.86 v7(24.61,84.37) ; v3(59.85,79.75) 59.85,80.1 58.38,81.57 v4(58.38,82.66)
  IN4 w0.071: v4(58.38,82.66) 57.66,83.38 50.48,83.38 48.36,81.27 46.67,81.27 45.31,82.63 42.18,82.63 39.93,80.38 38.41,80.38 38.1,80.68 33.2,80.68 v4(32.77,81.11)
  BOTTOM w0.122: PR717.2 25.08,84.83 v7(24.61,84.37) 24.61,84.25 24.17,83.82 PU700.7
VSB_N_001: length 5.7
  TOP w0.122: PC908.2 185.54,83.63 v1(184.61,83.63) PR908.2 182.56,82.77 PR909.2 182.43,82.84 PQ903.2
VSB_N_002: length 4.4
  TOP w0.122: v1(185.78,78.79) 185.78,78.42 185.4,78.04 PC910.1 184.79,78.22 184.08,78.93 184.08,79.69 183.9,79.87 PQ904.2
VSB_N_003: length 1.9
  TOP w0.122: PQ904.1 184.55,82.94 184.33,83.16 183.81,83.16 PR909.1
VSMB: length 19.5
  TOP w0.254: PR33.1 148.69,41.21 147.96,41.94 v7(147.96,42.22) ; PC37.2 150.7,37.46 v7(151.34,36.83) 151.4,36.76 v1(151.4,36.28) 151.06,35.95 151.06,35.18 151.53,34.71 151.53,34.05 PD9.1
  IN1 w0.254: v7(151.34,36.83) 151.35,36.83 152.84,38.32 152.84,39.36 151.88,40.32 151.09,40.32 149.19,42.22 v7(147.96,42.22)
  BOTTOM w0.254: v7(151.34,36.83) 151.05,37.11 PU2.12 ; v7(147.96,42.22) 148.32,41.86 148.88,41.86 PR31.1
VSUM+: length 10.2
  TOP w0.254: v7(27.24,81.85) 27.26,81.85 27.29,81.88 PC742.1 PC741.1 27.87,82.82 PR741.1 27.92,83.65 PR744.1 28.82,83.67 PR747.1
  BOTTOM w0.254: PU700.14 26.58,81.14 27.24,81.8 27.24,81.83 27.24,81.83 v7(27.24,81.85) v1(27.24,82.47) 27.64,82.87 27.64,83.78 28.41,84.54 PC743.1
VSUM-: length 40.1
  TOP w0.254: PR749.2 30.61,83.65 PR744.2 29.75,83.63 28.89,82.77 PC741.2 PC742.2 30.51,81.88 v7(30.54,81.85)
  IN2 w0.254: v7(30.54,81.85) 29.19,80.51 29.19,75.85 29.7,75.34 29.7,58.9 29.32,58.52 25.01,58.52 24.67,58.86 24.67,59.13 v8(24.39,59.41)
  BOTTOM w0.254: PH703.1 v8(24.39,59.41) ; PC743.2 29.6,84.52 28.56,83.48 PR748.1 29.29,82.69 PC745.1 PR750.1 v7(30.54,81.85)
VSUMG+: length 8.6
  TOP w0.254: v7(21.52,84.11) 21.62,84.11 22.49,84.98 PC711.2 PR706.2
  BOTTOM w0.254: v7(21.52,84.11) 21.77,83.86 PU700.1 ; v7(21.52,84.11) 21.68,84.27 PC710.2 21.68,85.77 PR709.2 ; v7(21.52,84.11) 21.29,83.88 21.29,83.55 21.01,83.27 20.56,83.27 20.43,83.4 v1(19.92,83.4) 19.17,83.4 PR714.1
VSUMG-: length 26.1
  TOP w0.254: PR707.2 20.78,84.98 v8(20.78,83.78) ; PR707.2 PC714.1 ; PR707.2 PC711.1
  IN2 w0.254: v8(20.78,83.78) 19.92,83.78 18.79,82.65 18.79,75.29 17.94,74.44 17.94,70.47 18.63,69.79 v7(18.63,69.74)
  BOTTOM w0.254: PR715.2 20.02,84.14 20.38,83.78 v8(20.78,83.78) 20.77,83.8 PC710.1 20.78,84.92 PR709.1 20.69,85.88 PR712.1 ; v7(18.63,69.74) 18.63,70.62 PH701.2
VTTREF_1.35V: length 3
  TOP w0.254: v7(30.79,24.37) 30.97,24.19 PU300.4
  BOTTOM w0.122: v1(32.63,23.85) 31.92,23.85 PC309.1
  BOTTOM w0.254: PC309.1 30.94,24.22 v7(30.79,24.37)
WAKE#: length 12.3
  TOP w0.122: v1(118.42,50.44) 118.42,50.57 118.98,51.13 RH128.2 RH146.1 118.07,51.47 117.62,51.91 117.62,54.72 116.92,55.42 116.92,55.7 115.72,56.91 115.72,57.68 v2(115.5,57.9)
  GND1 w0.104: v3(115.83,58.33) 115.83,58.23 v2(115.5,57.9)
  IN1 w0.071: v4(116.31,58.61) 116.03,58.33 v3(115.83,58.33)
  IN4 w0.071: v5(115.79,58.72) 116.21,58.72 v4(116.31,58.61)
  GND5 w0.104: v5(115.79,58.72) 115.38,58.72 v6(115.37,58.72)
  BOTTOM w0.122: UH1.D8 115.37,59.06 v6(115.37,58.72)
WAKE_PCH#: length 27.2
  TOP w0.122: U34.N11 138.9,56.58 138.26,56.58 137.78,56.1 137.78,55.9 137.85,55.83 137.85,55.49 137.32,54.95 v2(137.28,54.95) ; v2(118.93,53.05) 118.93,52.38 RH128.1 RH310.1 119.9,52.38 120.62,51.66 120.62,51.17 v1(120.83,50.95)
  GND1 w0.104: v2(118.93,53.05) 118.93,52.84 v3(119.26,52.51) ; v2(137.28,54.95) v3(136.72,54.95)
  IN1 w0.071: v3(136.72,54.95) 134.12,54.95 133.42,54.25 133.42,53.72 133.15,53.45 125.75,53.45 124.57,52.27 119.5,52.27 v3(119.26,52.51)
WIN8_BTN_SW#: length 53.1
  TOP w0.076: v2(143.24,62.45) 143.17,62.38 143.17,61.85 U34.F2
  TOP w0.122: R981.1 v2(147.66,64.41) ; R977.1 C1142.1 177.15,78.09 v7(177.64,78.59) 176.27,79.96 175.85,79.96 R978.2
  GND1 w0.104: v3(142.81,62.4) 143.19,62.4 v2(143.24,62.45) ; v2(147.66,64.41) v3(147.66,64.91)
  IN1 w0.071: v4(149.89,64.81) 148.06,64.81 147.95,64.91 v3(147.66,64.91) 147.06,64.3 144.34,64.3 143.61,63.56 143.61,62.81 143.19,62.4 143.1,62.4 v3(142.81,62.4)
  IN2 w0.094: v7(177.64,78.59) 177.02,77.97 176.49,77.97 175.95,77.43 175.95,76.99 174.16,75.2 172.98,75.2 170.05,72.26 168.15,72.26 166.63,70.74 166.63,68.54 166.05,67.96 166.05,67.13 164.3,65.38 159.03,65.38 158.71,65.06 157.05,65.06 156.9,64.9 155,64.9 154.13,64.04 152.88,64.04 152.12,64.81 v4(149.89,64.81)
  BOTTOM w0.122: v7(177.64,78.59) 177.3,78.24 v1(177.05,78.24)
WIN8_BTN_SW#_C: length 3.8
  TOP w0.122: R978.1 175.13,79.02 v7(175.19,78.96) 175.5,78.96 v1(176.08,79.54)
  BOTTOM w0.122: JLVDS2.19 176.24,79.12 175.95,78.83 175.32,78.83 v7(175.19,78.96)
WL_OFF#: length 104.2
  TOP w0.122: v2(116.06,73.75) 116.06,74.76 116.56,75.27 117.84,75.27 118.36,75.79 v1(118.87,75.79) 122.19,75.79 RH325.2 122.43,76.46 122.39,76.49 v2(122.39,76.95) ; Q328.3 176.95,34.24 177.24,34.52 179.98,34.52 180.18,34.72 v2(180.18,35.12)
  GND1 w0.104: v2(122.39,76.95) 123.05,76.29 v3(123.05,76.3) ; v3(180.69,35.22) 180.59,35.12 v2(180.18,35.12) ; v2(116.06,73.75) 115.91,73.6 v3(115.68,73.6)
  IN1 w0.071: v3(180.69,35.22) 180.56,35.35 180.56,38.52 180.29,38.78 180.29,49.62 176.2,53.71 172.75,53.71 172.09,54.37 172.09,55.33 170.52,56.9 168.81,56.9 168.38,56.47 166.17,56.47 164.04,58.6 156.86,58.6 156.27,59.19 154.58,59.19 154.21,59.56 154.21,60.89 152.32,62.78 150.73,62.78 150.29,63.23 150.29,65.02 149.5,65.81 148.69,65.81 v4(147.76,66.74) ; v4(115.2,73.6) v3(115.68,73.6) ; v3(123.05,76.3) 123.07,76.29 v4(124.04,76.29)
  IN2 w0.094: v4(124.04,76.29) 124.47,76.72 131.73,76.72 132.99,75.46 132.99,74.02 136.16,70.84 136.69,70.84 139.89,67.65 142.1,67.65 142.26,67.81 145.86,67.81 146.06,67.61 146.89,67.61 v4(147.76,66.74)
  IN4 w0.071: v5(115.91,73.35) 115.44,73.35 v4(115.2,73.6)
  GND5 w0.104: v5(115.91,73.35) 115.91,73.35 115.45,73.35 v6(115.45,73.36)
  BOTTOM w0.122: UH1.D44 v6(115.45,73.36)
WL_OFF#_R: length 8.9
  TOP w0.508: R1020.2 176.99,31.05 177.6,31.66 Q328.1 178,32.3 180.07,32.3 180.99,33.22 v1(180.99,33.95) 180.99,34.52 181.83,35.35 JWLAN1.20
WLAN_EN: length 7.2
  TOP w0.122: Q333.1 169.65,48.73 169.25,49.14 169.25,52.41 R1030.2 169.84,52.99 v1(170.72,52.99) U655.3
WLAN_EN#: length 40.7
  TOP w0.122: R1031.1 v1(164.62,47.97) 164.14,47.97 163.33,48.78 163.33,51.63 163.81,52.11 163.81,53.62 162.86,54.57 v7(162.64,54.57) ; R1021.1 138.25,64.12 138.63,63.74 139.1,63.74 139.44,63.4 139.44,62.9 v2(139.81,62.53) 139.92,62.42 U34.M1
  GND1 w0.104: v3(139.83,62.98) 139.81,62.95 v2(139.81,62.53)
  IN1 w0.071: v4(139.66,62.5) 139.83,62.67 v3(139.83,62.98)
  IN2 w0.094: v7(162.64,54.57) 161.14,56.07 161.14,56.27 160.69,56.73 160.01,56.73 159.74,57 156.56,57 156.35,56.79 154.28,56.79 153.86,57.21 150.12,57.21 149.67,57.66 146.01,57.66 145.24,58.43 145.24,58.96 142.23,61.96 140.82,61.96 140.67,62.12 140.04,62.12 v4(139.66,62.5)
XCLK_RCOMP: length 4.6
  TOP w0.254: v2(108.06,75.92) v9(108.06,74.87) 108.06,74.53 RH113.1
  GND1 w0.254: v3(108.06,76.33) v2(108.06,75.92)
  IN1 w0.254: v4(108.06,75.84) v3(108.06,76.33)
  IN4 w0.254: v5(108.06,76.33) v4(108.06,75.84)
  GND5 w0.254: v6(108.06,75.9) v5(108.06,76.33)
  BOTTOM w0.254: UH1.AC49 v6(108.06,75.9)
XDP_DBRESET#: length 97.4
  IN1 w0.071: v4(91.68,75.12) 92.32,75.12 92.79,74.64 92.79,73.47 92.81,73.45 92.81,73.45 93.77,72.49 94.89,72.49 97.01,70.37 99.45,70.37 100.36,69.46 100.36,68.35 101.87,66.84 101.87,66.49 102.1,66.26 102.49,66.26 104.3,64.45 104.45,64.45 105.65,63.26 105.65,62.62 105.82,62.45 105.82,62.04 104.86,61.07 v4(103.84,61.07) ; v7(112.73,55.64) 112.24,55.64 111.04,56.83 109.66,56.83 109.42,57.07 107.14,57.07 v4(107.08,57.12)
  IN4 w0.071: v5(48.22,81.67) 50.3,83.76 72.51,83.76 74.89,81.38 77.29,81.38 80.75,77.92 82.24,77.92 86.61,73.55 89.6,73.55 90.32,74.27 90.76,74.27 91.62,75.12 v4(91.68,75.12) ; v4(107.08,57.12) 106.29,57.12 105.52,57.9 105.52,58.23 103.78,59.97 103.78,60.45 103.84,60.52 v4(103.84,61.07)
  GND5 w0.104: v5(48.22,81.67) 48.22,81.22 v6(48.17,81.17)
  BOTTOM w0.122: RC42.1 113.37,52.73 113.29,52.81 113.29,55.08 v7(112.73,55.64) 112.53,55.84 UH1.L1 ; RC56.2 47.38,75.53 v1(47,75.91) 47,76.5 47.73,77.24 47.73,79.57 48.24,80.07 48.24,80.46 48.23,80.47 48.23,80.76 48.17,80.83 v6(48.17,81.17)
XDP_DBRESET#_R: length 6
  BOTTOM w0.122: RC56.1 49.31,75.53 49.78,75.06 49.78,74.64 v1(50.31,74.1) 52.99,74.1 53.85,74.96 UCPU1.K58
XDP_PRDY#: length 3.3
  TOP w0.122: v2(56.07,74.31) 55.46,73.69 T241.1
  GND1 w0.104: v2(56.07,74.31) v3(56.52,74.31)
  IN1 w0.071: v3(56.52,74.31) 56.52,73.93 v4(56.65,73.8)
  IN4 w0.071: v5(56.14,73.88) 56.22,73.8 v4(56.65,73.8)
  GND5 w0.104: v6(56.14,74.31) v5(56.14,73.88)
  BOTTOM w0.122: UCPU1.N53 56.07,74.24 v6(56.14,74.31)
XDP_PREQ#: length 7.5
  TOP w0.122: RC47.1 50.7,77.13 51.34,76.49 52.66,76.49 v1(53.25,75.91) 54.29,74.87 v2(54.44,74.87)
  GND1 w0.104: v2(54.44,74.87) v3(53.96,74.87)
  IN1 w0.071: v4(54.44,74.31) 53.96,74.79 v3(53.96,74.87)
  IN4 w0.071: v5(54.92,74.31) v4(54.44,74.31)
  GND5 w0.104: v6(55.42,74.31) v5(54.92,74.31)
  BOTTOM w0.122: UCPU1.N55 v6(55.42,74.31)
XDP_TCK: length 8.9
  TOP w0.122: v7(51.52,75.17) 51.52,75.88 v1(51.8,76.16)
  BOTTOM w0.122: RC52.1 49.89,77.48 49.89,76.35 50.12,76.12 50.33,76.12 50.73,75.72 50.73,75.67 51.23,75.17 v7(51.52,75.17) 51.68,75.34 53.61,75.34 53.72,75.44 54.28,75.44 UCPU1.L56
XDP_TDI: length 8
  TOP w0.122: v9(47.31,76.33) 48.67,76.33 49.58,75.43 v7(50.05,75.43)
  BOTTOM w0.122: RC46.1 49.17,76.36 50.05,75.49 v7(50.05,75.43) 50.05,74.89 50.55,74.38 52.78,74.38 UCPU1.M60
XDP_TDO: length 7.4
  TOP w0.122: v9(49.68,75.93) 50.2,75.93 50.71,75.43 v7(50.71,75.07)
  BOTTOM w0.122: RC48.1 49.64,76.84 49.64,76.24 50.02,75.87 50.23,75.87 50.49,75.61 50.49,75.34 50.71,75.12 v7(50.71,75.07) 51.07,74.7 52.61,74.7 52.93,75.02 UCPU1.L59
XDP_TMS: length 8.3
  TOP w0.122: v2(54.95,75) 54.79,75 v1(54.46,75.32) 52.99,76.8 51.43,76.8 51.17,77.06 51.17,77.72 RC45.1
  GND1 w0.104: v5(55.38,75) v2(54.95,75)
  IN1 w0.071: v4(55.38,74.51) v5(55.38,75)
  IN4 w0.071: v5(55.38,75) v4(55.38,74.51)
  GND5 w0.104: v5(55.38,75) 55.37,75.01 v6(55.37,75.45)
  BOTTOM w0.122: UCPU1.L55 v6(55.37,75.45)
XDP_TRST#: length 12.4
  TOP w0.122: v9(48.55,77.84) 48.55,77.13 49.28,76.39 50.68,76.39 v2(50.76,76.31)
  GND1 w0.104: v3(51.19,76.31) v2(50.76,76.31)
  IN1 w0.071: v4(51.19,76.8) v3(51.19,76.31)
  IN4 w0.071: v4(51.19,76.8) 51.16,76.77 v5(50.63,76.77)
  GND5 w0.104: v5(50.63,76.77) 50.6,76.77 v6(50.3,76.47)
  BOTTOM w0.122: RC54.1 50.14,78.12 50.14,76.63 v6(50.3,76.47) 50.36,76.47 51.21,75.62 52.19,75.62 52.24,75.56 53.47,75.56 53.69,75.78 UCPU1.J58
XTAL25_IN: length 12.7
  TOP w0.122: YH2.3 115.72,78.75 RH117.2 113.52,78.59 CH23.1 112.35,78.59 111.89,78.14 111.89,77.72 111.02,76.85 111.02,76.23 110.42,75.63 v1(109.93,75.63) 109.8,75.63 109.38,76.05 v2(109.38,76.47)
  GND1 w0.104: v3(109.79,76.47) v2(109.38,76.47)
  IN1 w0.071: v4(109.79,75.98) v3(109.79,76.47)
  IN4 w0.071: v4(109.79,75.98) 109.38,75.98 v5(109.28,75.88)
  GND5 w0.104: v6(109.28,75.48) v5(109.28,75.88)
  BOTTOM w0.122: UH1.W49 v6(109.28,75.48)
XTAL25_OUT: length 9.9
  TOP w0.122: v2(109.61,77.15) 109.96,76.8 110.55,76.8 111.56,77.81 111.56,78.91 v1(111.86,79.2) 112.44,79.2 CH24.1 112.89,79.66 RH117.1 115.02,79.66 YH2.1
  GND1 w0.104: v3(110.04,77.15) v2(109.61,77.15)
  IN1 w0.071: v4(109.56,77.15) v3(110.04,77.15)
  IN4 w0.071: v5(109.56,76.67) v4(109.56,77.15)
  GND5 w0.104: v6(109.56,77.1) v5(109.56,76.67)
  BOTTOM w0.122: v6(109.56,77.1) 109.53,77.08 109.53,77.02 UH1.W51
N3514555: length 7.1
  TOP w0.254: PC220.1 PR200.1 188.68,58.22 188.2,57.73 186.7,57.73 185.27,59.16 v9(185.27,59.55) 185.27,60.34 v7(185.4,60.46)
N6573945: length 2
  TOP w0.122: PC18.1 133.89,42.89 134.64,43.63 134.97,43.63 v9(135.36,44.03)
N6638747: length 40.2
  IN2 w0.254: v7(120.61,41.14) 123.73,38.01 131.33,38.01 132.52,39.2 141.15,39.2 146.79,33.57 149.41,33.57 v7(149.89,34.05)
  BOTTOM w0.122: PC29.1 151.88,32.66 153.13,33.91 v9(153.26,33.91)
  BOTTOM w0.254: PC29.1 150.74,32.66 PR46.2 150.28,32.69 149.89,33.08 v7(149.89,34.05) ; PQ103.4 v7(120.61,41.14)
N16905977: length 88.7
  IN1 w0.071: v7(181.64,33.87) 181.03,34.48 181.03,35.79 180.73,36.09 180.73,38.59 180.46,38.85 180.46,48.31 180.74,48.59 180.51,48.82 180.51,50.3 178.75,52.06 178.75,52.59 178.34,53 177.17,53 176.27,53.9 173.43,53.9 173.03,54.29 173.03,55.26 172.54,55.75 171.93,55.75 170.6,57.09 168.74,57.09 168.29,56.64 166.24,56.64 164.11,58.78 156.93,58.78 156.34,59.37 154.65,59.37 154.4,59.62 154.4,60.97 152.4,62.97 150.79,62.97 150.46,63.3 150.46,65.11 149.57,66 149.03,66 147.84,67.2 v4(146.3,67.2)
  IN2 w0.094: v7(128.58,76.24) 130.54,76.24 130.97,75.81 132.21,75.81 132.66,75.36 132.66,74 136.02,70.65 136.61,70.65 139.81,67.45 142.18,67.45 142.34,67.62 145.51,67.62 145.93,67.2 v4(146.3,67.2)
  BOTTOM w0.122: v7(181.64,33.87) 181.36,34.15 JWLAN1.17 ; R1017.2 126.57,77.63 127.24,76.96 127.71,76.96 v1(127.95,76.72) 128.43,76.24 v7(128.58,76.24)
N16920025: length 2.8
  TOP w0.122: R1013.1 181.48,28.28 181.62,28.15 JWLAN1.10
N16920097: length 3.7
  TOP w0.122: JWLAN1.16 182.45,31.08 181.83,31.7 v1(181.54,31.7) 181.15,31.7 180.78,31.33 R1016.1
N16920180: length 2.9
  TOP w0.122: R1014.1 v1(180.86,29.3) 181.28,29.3 181.63,28.95 JWLAN1.12
N16920200: length 3
  TOP w0.122: R1015.1 181.15,30.31 181.71,29.75 JWLAN1.14
N16920204: length 2.9
  TOP w0.122: JWLAN1.8 181.66,27.35 181.49,27.52 v1(180.86,27.52) 179.98,27.52 R1012.1
N16935361: length 4.9
  TOP w0.122: T244.1 177.2,48.91 v2(177.22,48.91)
  GND1 w0.104: v2(177.22,48.91) v3(177.65,48.91)
  IN1 w0.071: v3(177.65,48.91) v4(178.14,48.91)
  IN4 w0.071: v4(178.14,48.91) 177.65,48.42 v5(177.6,48.42)
  GND5 w0.104: v6(178.04,48.42) v5(177.6,48.42)
  BOTTOM w0.122: v6(178.04,48.42) JSATA1.45
N16935447: length 2.7
  TOP w0.122: v7(177.71,47.84) 177.22,47.84 T245.1
  BOTTOM w0.122: v7(177.71,47.84) 177.49,47.62 JSATA1.47
N16935449: length 3.6
  TOP w0.122: T246.1 177.3,47.21 v7(177.71,47.21)
  BOTTOM w0.122: v7(177.71,47.21) 177.32,46.82 JSATA1.49
N16940180: length 3.9
  TOP w0.122: v2(168.26,50.38) 168.51,50.63 T243.1
  GND1 w0.104: v3(167.93,50.66) 168.21,50.38 v2(168.26,50.38)
  IN1 w0.071: v4(168.49,50.63) 167.95,50.63 v3(167.93,50.66)
  IN4 w0.071: v5(168.99,50.74) 168.59,50.74 v4(168.49,50.63)
  GND5 w0.104: v5(168.99,50.74) 168.99,50.99 v6(168.84,51.14)
  BOTTOM w0.122: JSATA1.38 168.76,51.22 v6(168.84,51.14)
N16940198: length 5.7
  TOP w0.122: T242.1 167.39,50.66 v2(167.39,51.02)
  GND1 w0.104: v2(167.39,51.02) v3(167.39,50.58)
  IN1 w0.071: v3(167.39,50.58) 167.39,51.07 v4(167.01,51.45)
  IN4 w0.071: v4(167.01,51.45) 167.04,51.42 168.69,51.42 v5(168.84,51.57)
  GND5 w0.104: v6(168.84,52.02) v5(168.84,51.57)
  BOTTOM w0.122: JSATA1.36 v6(168.84,52.02)
N17565538: length 3.4
  TOP w0.122: C1169.1 176.37,53.76 v1(176.04,54.09)
  TOP w0.203: U655.12 174.94,52.99 175.12,53.17 C1169.1
N17599718: length 3.8
  TOP w0.122: T81.1 107.25,76.09 v2(107.25,74.86)
  GND1 w0.104: v3(107.65,74.86) v2(107.25,74.86)
  IN1 w0.071: v4(107.14,74.86) v3(107.65,74.86)
  IN4 w0.071: v5(107.64,74.86) v4(107.14,74.86)
  GND5 w0.104: v5(107.64,74.86) 107.64,75.45 v6(107.65,75.47)
  BOTTOM w0.122: v6(107.65,75.47) UH1.AD48
N17599720: length 3.5
  TOP w0.122: v2(107.55,76.62) 107.63,76.7 T82.1
  GND1 w0.104: v3(107.55,76.21) v2(107.55,76.62)
  IN1 w0.071: v4(107.07,76.21) v3(107.55,76.21)
  IN4 w0.071: v5(107.58,76.21) v4(107.07,76.21)
  GND5 w0.104: v5(107.58,76.21) v3(107.55,76.21) v6(107.24,75.91)
  BOTTOM w0.122: UH1.AD50 v6(107.24,75.91)
N17638789: length 3
  TOP w0.122: Q329.1 171.86,30.76 R943.1 171.86,28.91 v1(171.56,28.61)
N17654244: length 11.5
  TOP w0.122: Q329.2 172.32,32.35 170.39,32.35 168.59,34.15 v1(168.59,34.89) v7(168.08,35.39) 167,36.47 Q326.1
  BOTTOM w0.122: R989.1 167.32,34.54 C1160.1 168.05,35.43 v7(168.08,35.39)
N17824335: length 14.7
  TOP w0.122: PQ908.1 40.48,82.03 v1(42.09,83.64) 43.59,85.14 43.59,86.25 44,86.65 45.19,86.65 45.5,86.35 45.5,85.03 46.08,84.44 48.19,84.44 PC124.2
N18675747: length 0.9
  TOP w0.122: C284.1 136.38,60.46 R226.2
N18675794: length 2.8
  TOP w0.076: 138.23,57.46 v1(138.25,57.47) 138.31,57.47 138.48,57.64 138.48,57.75 138.73,58 138.88,58 138.89,58 139.13,58 139.13,58 139.16,58 139.26,58.1 U34.N9
  TOP w0.122: 138.23,57.46 137.54,56.77 R250.2
N18675796: length 5.8
  TOP w0.076: 138.23,59.59 138.39,59.59 v2(138.43,59.63)
  TOP w0.122: R249.2 138.23,59.59 ; v2(141.79,59.74) U34.J5
  GND1 w0.104: v3(138.97,59.12) 138.89,59.12 138.53,59.49 138.53,59.52 138.45,59.6 138.45,59.61 v2(138.43,59.63) ; v2(141.79,59.74) 141.79,59.78 v3(141.46,60.1)
  IN1 w0.071: v3(141.46,60.1) 140.55,60.1 140.43,59.98 140.06,59.98 139.64,59.56 139.47,59.56 139.03,59.12 v3(138.97,59.12)
N18684481: length 5.9
  TOP w0.254: PC219.1 198.03,57.67 PR201.1 196.81,57.67 196.49,57.99 v7(196.46,57.99) 195.82,58.64 v1(195.76,58.64) 195.52,58.64 195.1,58.22 194.46,58.22 194.34,58.1 PU501.1
  BOTTOM w0.254: v7(196.46,57.99) 196.43,57.95 PR203.1
