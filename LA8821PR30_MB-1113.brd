# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA13: length 186.2
  TOP w0.076: UD10.N3 56.75,28.96 56.59,28.96 56.32,28.68 56.32,27.08 57.13,26.27 58.09,26.27 58.21,26.14 58.21,25.66 v10(58.11,25.56) ; UD16.N3 23.6,28.96 23.44,28.96 23.17,28.68 23.17,27.08 23.98,26.27 24.94,26.27 25.07,26.14 25.07,25.66 v10(24.97,25.56) ; UD12.N3 45.7,28.96 45.54,28.96 45.27,28.68 45.27,27.08 46.08,26.27 47.04,26.27 47.16,26.14 47.16,25.66 v10(47.06,25.56) ; v10(36.01,25.56) 36.12,25.66 36.12,26.14 35.99,26.27 35.03,26.27 34.22,27.08 34.22,28.68 34.49,28.96 34.65,28.96 UD14.N3
  IN2 w0.122: v4(59.72,58.6) 59.33,58.2 56.65,58.2 56.01,58.84 50.71,58.84 44.38,52.51 44.38,51.18 40.79,47.59 39.9,47.59 38.34,46.02 38.34,43.64 39.12,42.86 39.12,41.67 40.32,40.47 43.09,40.47 43.26,40.3 54.77,40.3 55.56,41.08 57.26,41.08 57.56,40.78 61.55,40.78 62.16,40.17 62.16,39.69 63.54,38.31 63.54,32.42 66.1,29.86 66.1,26.54 66.29,26.35 v4(66.29,25.73)
  IN3 w0.122: v7(18.47,28.54) 18.55,28.46 19.49,28.46 21.41,26.54 23.48,26.54 23.96,26.05 24.47,26.05 v10(24.97,25.56) 25.74,24.78 26.47,24.78 27.42,25.73 30.95,25.73 31.33,25.35 33.56,25.35 33.69,25.48 33.69,26.39 33.81,26.52 34.04,26.52 34.17,26.39 34.17,25.71 34.3,25.58 34.77,25.58 34.9,25.45 34.9,24.49 35.02,24.36 35.35,24.36 35.48,24.49 35.48,25.45 35.61,25.58 35.99,25.58 v10(36.01,25.56) 36.01,24.9 36.14,24.78 38.42,24.78 38.54,24.9 38.54,26.18 38.66,26.3 38.91,26.3 39.03,26.18 39.03,24.8 39.16,24.68 39.39,24.68 39.52,24.8 39.52,26.18 39.64,26.3 39.88,26.3 40,26.18 40,24.78 40.13,24.65 40.36,24.65 40.49,24.78 40.49,26.18 40.61,26.3 40.86,26.3 40.98,26.18 40.98,24.9 41.1,24.78 45.85,24.78 46.63,25.56 v10(47.06,25.56) 47.79,24.83 48.62,24.83 49.16,25.37 49.16,25.54 49.56,25.95 51.21,25.95 51.33,26.07 51.33,26.4 51.46,26.53 51.69,26.53 51.82,26.4 51.82,26.07 51.94,25.95 52.23,25.95 52.35,26.07 52.35,26.4 52.48,26.53 52.71,26.53 52.84,26.4 52.84,26.07 52.96,25.95 53.21,25.95 53.33,26.07 53.33,26.4 53.46,26.53 53.69,26.53 53.82,26.4 53.82,26.07 53.94,25.95 54.18,25.95 54.3,26.07 54.3,26.38 54.43,26.5 54.66,26.5 54.79,26.38 54.79,26.07 54.91,25.95 55.25,25.95 55.38,26.07 55.38,26.38 55.51,26.5 55.86,26.5 55.99,26.38 55.99,26.07 56.12,25.95 56.83,25.95 57.22,25.56 v10(58.11,25.56) 58.84,24.83 59.74,24.83 60.53,25.62 66.17,25.62 v4(66.29,25.73)
  IN4 w0.091: v5(59.66,58.1) 59.65,58.12 59.65,58.52 v4(59.72,58.6)
  GND5 w0.102: v5(59.66,58.1) 59.67,58.1 59.79,58.22 v6(60.11,58.22)
  BOTTOM w0.076: v10(36.01,25.56) 36.01,25.63 36.65,26.27 37.93,26.27 38.3,26.64 38.3,28.51 UD13.N3 ; UD15.N3 27.25,28.51 27.25,26.64 26.88,26.27 25.6,26.27 24.97,25.63 v10(24.97,25.56) ; v10(47.06,25.56) 47.06,25.63 47.7,26.27 48.98,26.27 49.35,26.64 49.35,28.51 UD11.N3 ; UD9.N3 60.4,28.51 60.4,26.64 60.03,26.27 58.75,26.27 58.11,25.63 v10(58.11,25.56)
  BOTTOM w0.16: UCPU1.BD46 v6(60.11,58.22) ; v7(18.47,28.54) 18.35,28.66 R1057.1
DDR_B_MA14: length 177.3
  TOP w0.076: UD10.N7 60.03,28.88 60.03,26.78 59.76,26.52 59,26.52 58.75,26.77 v10(58.75,26.95) ; UD14.N7 37.93,28.88 37.93,26.78 37.67,26.52 36.9,26.52 36.65,26.77 v10(36.65,26.95) ; v10(47.7,26.95) 47.7,26.77 47.95,26.52 48.71,26.52 48.98,26.78 48.98,28.88 UD12.N7 ; UD16.N7 26.88,28.88 26.88,26.78 26.62,26.52 25.85,26.52 25.6,26.77 v10(25.6,26.95)
  IN1 w0.091: v4(69.69,39.07) 69.72,39.03 69.72,35.82 68.54,34.63 68.54,30.2 69.55,29.18 69.55,28.12 68.69,27.26 68.69,26.16 67.84,25.31 62.24,25.31 61.21,26.34 59,26.34 58.75,26.6 v10(58.75,26.95) 59.06,27.27 59.06,27.47 59,27.54 56.94,27.54 56.82,27.41 56.82,25.76 56.69,25.63 56.33,25.63 56.21,25.76 56.21,26.06 56,26.27 48.62,26.27 48.38,26.02 47.56,26.02 47.33,26.25 47.33,26.5 47.7,26.88 v10(47.7,26.95) 47.11,27.54 46.12,27.54 45.77,27.18 45.77,24.51 45.64,24.39 40.33,24.39 39.85,23.9 35.99,23.9 35.89,24.01 35.89,24.92 36.01,25.05 37.64,25.05 37.77,25.17 37.77,25.89 37.64,26.01 36.78,26.01 36.65,26.14 v10(36.65,26.95) 36.06,27.54 34.85,27.54 34.72,27.41 34.72,25.76 34.59,25.63 34.24,25.63 34.11,25.76 34.11,26.06 33.98,26.19 33.73,26.19 33.6,26.06 33.6,25.76 33.47,25.63 31.89,25.63 31.3,26.23 30.37,26.23 29.78,25.63 27.12,25.63 26.74,26.01 25.73,26.01 25.6,26.14 v10(25.6,26.95) 25.02,27.54 21.08,27.54 19.74,26.2 18.88,26.2 v8(18.8,26.28)
  IN2 w0.122: v4(69.69,39.07) 69.89,39.07 71.21,40.4 72.83,40.4 73.01,40.58 73.01,41.05 72.78,41.29 72.78,41.92 72.91,42.05 73.49,42.05 73.67,41.87 73.67,41.67 73.87,41.47 74.61,41.47 74.76,41.62 74.76,41.85 74.61,42 74.61,42.35 74.86,42.61 75.55,42.61 75.75,42.41 75.75,41.54 76.16,41.13 77.22,41.13 77.35,41.26 77.35,41.59 77.22,41.72 76.46,41.72 76.33,41.85 76.33,42.18 76.46,42.3 77.23,42.3 77.36,42.43 77.36,42.73 77.22,42.86 76.11,42.86 75.98,42.99 75.98,43.29 76.11,43.42 77.32,43.42 77.55,43.65 77.55,43.88 77.43,44.01 76.28,44.01 76.16,44.13 76.16,44.49 76.28,44.62 78.08,44.62 78.94,45.47 78.94,46.57 78.66,46.84 78.44,46.84 78.32,46.72 78.32,45.68 78.19,45.55 77.83,45.55 77.73,45.66 77.73,47.77 77.42,48.08 77.42,51.54 76.91,52.06 76.91,55.83 78.11,57.03 78.11,58.13 77.99,58.25 77.5,58.25 77.38,58.13 77.38,57.14 77.25,57.01 76.94,57.01 76.82,57.14 76.82,57.8 76.69,57.92 76.36,57.92 76.23,57.8 76.23,57.11 76.11,56.98 75.78,56.98 75.65,57.11 75.65,58.59 75.52,58.71 75.14,58.71 75.01,58.59 75.01,57.29 74.89,57.16 74.56,57.16 74.43,57.29 74.43,58.59 74.3,58.71 73.39,58.71 73.08,59.02 72.47,59.02 72.07,59.42 72.07,60.44 70.97,61.53 70.47,61.53 70.03,61.96 70.03,62.2 v4(69.57,62.67)
  IN4 w0.091: v4(69.57,62.67) 69.52,62.72 69.5,62.72 v5(69.2,63.03)
  GND5 w0.102: v6(69.05,62.64) 69.05,62.88 v5(69.2,63.03)
  BOTTOM w0.076: UD9.N7 56.82,28.88 56.82,27.43 56.97,27.28 57.65,27.28 57.73,27.36 58.58,27.36 58.75,27.19 v10(58.75,26.95) ; v10(36.65,26.95) 36.65,27.19 36.48,27.36 35.63,27.36 35.56,27.28 34.87,27.28 34.73,27.43 34.73,28.88 UD13.N7 ; v10(25.6,26.95) 25.6,27.19 25.43,27.36 24.58,27.36 24.51,27.28 23.82,27.28 23.68,27.43 UD15.N7 ; v10(47.7,26.95) 47.7,27.19 47.53,27.36 46.68,27.36 46.61,27.28 45.92,27.28 45.78,27.43 UD11.N7
  BOTTOM w0.16: v8(18.8,26.28) 18.41,26.28 R1045.1 ; UCPU1.AT26 v6(69.05,62.64)
DDR_B_MA15: length 170.8
  TOP w0.076: UD10.J7 59.92,32.19 59.88,32.19 59.87,32.19 58.53,32.19 58.53,32.19 58.27,32.19 57.62,31.54 v10(57.62,31.53) ; v10(46.58,31.53) 46.58,31.54 47.22,32.19 47.48,32.19 48.83,32.19 48.83,32.19 48.87,32.19 UD12.J7 ; UD14.J7 37.82,32.19 37.78,32.19 37.78,32.19 36.43,32.19 36.43,32.19 36.17,32.19 35.53,31.54 v10(35.53,31.53) ; v10(24.48,31.53) 24.48,31.54 25.12,32.19 25.38,32.19 26.73,32.19 26.73,32.19 26.77,32.19 UD16.J7
  TOP w0.16: R1039.1 17.8,30.6 v2(17.47,30.26)
  GND1 w0.102: v2(17.47,30.26) 17.47,30.37 17.8,30.7 v3(17.8,30.72)
  IN1 w0.091: v4(67.04,37.23) 67.01,37.23 67.01,37.25 67.06,37.2 67.06,35.53 66.86,35.33 66.86,31.66 66.68,31.48 66.02,31.48 65.89,31.36 65.89,30.9 66.07,30.72 66.07,30.34 65.82,30.09 65.82,29.43 66.07,29.17 66.07,28.48 65.65,28.05 65.21,28.05 65.08,28.18 65.08,31.28 64.95,31.41 64.55,31.41 64.42,31.28 64.42,28.18 64.29,28.05 63.87,28.05 63.72,28.2 63.72,30.11 63.65,30.19 63.23,30.19 63.1,30.31 63.1,30.7 63.23,30.82 63.71,30.82 63.84,30.95 63.84,31.3 63.71,31.42 62.54,31.42 62.41,31.55 62.41,32.11 62.29,32.23 61.84,32.23 61.7,32.09 61.7,31.25 61.55,31.1 61.55,30.37 61.4,30.21 61.09,30.21 60.97,30.34 60.97,31.38 60.81,31.53 60.81,32.07 60.69,32.19 60.18,32.19 59.87,31.89 59.87,31.61 60.38,31.1 60.38,30.34 60.26,30.21 60.03,30.21 59.82,30.42 59.82,30.75 59.67,30.9 59.34,30.9 59.15,31.09 58.06,31.09 v10(57.62,31.53) 57.43,31.53 56.49,30.58 54.48,30.58 54.35,30.46 54.35,30.18 54.23,30.05 53.16,30.05 53.04,29.93 53.04,29.67 53.17,29.54 54.01,29.54 54.13,29.42 54.13,29.11 54.01,28.98 52.96,28.98 52.27,29.67 50.75,29.67 49.97,30.45 48.71,30.45 48.07,31.09 46.98,31.09 46.58,31.5 v10(46.58,31.53) 46.38,31.53 45.44,30.58 43.43,30.58 43.3,30.46 43.3,30.2 43.15,30.05 42.21,30.05 42.08,29.92 42.08,29.67 42.21,29.54 43.18,29.54 43.3,29.42 43.3,29.11 43.18,28.98 42.92,28.98 42.82,28.88 42.82,28.35 42.69,28.22 42.39,28.22 42.26,28.35 42.26,28.48 42.14,28.6 41.86,28.6 41.73,28.48 41.73,27.21 41.65,27.13 41.07,27.13 40.97,27.23 40.97,27.74 40.84,27.87 39.65,27.87 39.52,27.99 39.52,28.63 39.7,28.81 39.7,29.67 39.44,29.92 39.44,30.33 39.32,30.45 37.67,30.45 37.03,31.09 35.96,31.09 v10(35.53,31.53) 35.34,31.53 34.39,30.58 32.38,30.58 32.25,30.46 32.25,30.18 32.13,30.05 31.06,30.05 30.94,29.93 30.94,29.67 31.07,29.54 31.91,29.54 32.04,29.42 32.04,29.11 31.91,28.98 30.86,28.98 30.17,29.67 28.65,29.67 27.87,30.45 26.62,30.45 26.02,31.04 24.93,31.04 24.48,31.5 v10(24.48,31.53) 24.29,31.53 23.56,30.8 19.08,30.8 18.73,30.44 18.08,30.44 v3(17.8,30.72)
  IN2 w0.122: v4(67.04,37.23) 68.11,37.23 68.36,37.48 68.36,38.08 68.84,38.56 68.85,38.56 68.86,38.57 68.86,38.57 68.87,38.57 69.78,38.57 70.38,39.17 70.67,39.17 70.8,39.3 70.8,39.59 70.92,39.71 71.23,39.71 71.36,39.59 71.36,39.3 71.48,39.17 71.79,39.17 71.91,39.3 71.91,39.97 72.04,40.09 72.35,40.09 72.47,39.97 72.47,39.31 72.6,39.18 72.91,39.18 73.04,39.31 73.04,39.98 73.29,40.23 73.29,40.96 73.41,41.08 74.05,41.08 74.18,40.96 74.18,40.39 74.3,40.27 74.89,40.27 75.01,40.39 75.01,41.01 75.14,41.14 75.72,41.14 75.85,41.01 75.85,39.99 75.98,39.87 76.36,39.87 76.49,39.99 76.49,40.73 76.61,40.86 77.2,40.86 77.4,40.65 77.4,40.35 77.53,40.22 78.14,40.22 78.32,40.4 78.32,40.66 77.63,41.35 77.63,43.33 77.97,43.67 78.16,43.67 78.34,43.85 78.34,44.49 79.48,45.63 79.48,45.9 79.21,46.18 79.21,46.68 77.7,48.19 77.7,51.65 77.18,52.17 77.18,55.71 78.44,56.97 78.44,58.41 78.19,58.66 77.07,58.66 76.59,59.14 73.59,59.14 72.93,59.8 72.93,60.29 71.89,61.33 71.89,61.64 v4(71.7,61.83)
  IN4 w0.091: v4(71.7,61.83) 71.38,61.51 v5(71.33,61.51)
  GND5 w0.102: v6(70.94,61.74) 71.17,61.51 v5(71.33,61.51)
  BOTTOM w0.076: v10(35.53,31.53) 35.64,31.53 35.76,31.65 35.76,31.81 35.64,31.93 35.23,31.93 35.1,32.06 35.1,32.44 34.97,32.57 34.67,32.57 34.53,32.43 34.53,32.17 34.61,32.08 UD13.J7 ; v10(46.58,31.53) 46.69,31.53 46.81,31.65 46.81,31.81 46.69,31.93 46.28,31.93 46.15,32.06 46.15,32.44 46.02,32.57 45.72,32.57 45.57,32.43 45.57,32.17 45.66,32.08 UD11.J7 ; UD15.J7 23.57,32.08 23.48,32.17 23.48,32.43 23.62,32.57 23.92,32.57 24.05,32.44 24.05,32.06 24.18,31.93 24.59,31.93 24.71,31.81 24.71,31.65 24.59,31.53 v10(24.48,31.53) ; UD9.J7 56.71,32.08 56.62,32.17 56.62,32.43 56.77,32.57 57.07,32.57 57.2,32.44 57.2,32.06 57.32,31.93 57.74,31.93 57.86,31.81 57.86,31.65 57.74,31.53 v10(57.62,31.53)
  BOTTOM w0.16: UCPU1.AU22 v6(70.94,61.74)
DDR_B_RAS#: length 176
  TOP w0.076: v10(48.08,36.06) 47.7,36.44 46.74,36.44 46.51,36.21 46.51,35.88 46.57,35.83 46.57,35.56 46.56,35.55 46.56,35.54 46.33,35.32 46.32,35.32 45.78,34.77 UD12.F3 ; v10(25.98,36.06) 25.6,36.44 24.65,36.44 24.42,36.21 24.42,35.88 24.47,35.83 24.47,35.56 24.46,35.55 24.46,35.54 24.23,35.32 24.23,35.32 23.68,34.77 UD16.F3 ; UD14.F3 34.73,34.77 35.28,35.32 35.28,35.32 35.51,35.54 35.51,35.55 35.52,35.56 35.52,35.83 35.47,35.88 35.47,36.21 35.69,36.44 36.65,36.44 v10(37.03,36.06) ; UD10.F3 56.82,34.77 57.37,35.32 57.38,35.32 57.6,35.54 57.6,35.55 57.61,35.56 57.61,35.83 57.56,35.88 57.56,36.21 57.79,36.44 58.75,36.44 v10(59.13,36.06)
  TOP w0.16: v8(18.8,39.88) 18.7,39.88 18.07,40.51 R1075.1
  IN2 w0.122: v4(64.97,41.67) 64.98,41.67 64.96,41.69 64.96,41.92 63.32,43.56 50.62,43.56 50.25,43.19 49.84,43.19 49.47,43.56 49.26,43.56 49.13,43.44 49.13,43.07 49,42.94 48.67,42.94 48.55,43.07 48.55,44.41 48.42,44.54 48.06,44.54 47.94,44.41 47.94,43.09 47.81,42.96 47.41,42.96 47.28,43.09 47.28,44.33 47.07,44.54 40.93,44.54 40.8,44.67 40.8,45 40.93,45.12 48.67,45.12 48.8,45.25 48.8,47.2 49.15,47.55 49.15,49.91 49.33,50.1 50.38,50.1 50.5,50.22 50.5,50.56 50.38,50.69 49.61,50.69 49.49,50.81 49.49,51.7 49.61,51.82 50.38,51.82 50.5,51.95 50.5,52.26 50.38,52.39 49.78,52.39 49.49,52.68 49.49,53.85 49.78,54.14 50.47,54.14 51.23,54.89 61.46,54.89 61.58,55 61.58,55.21 61.86,55.49 62.01,55.49 62.14,55.36 62.14,55.03 62.26,54.9 62.57,54.9 62.69,55.03 62.69,56.22 62.82,56.35 63.15,56.35 63.28,56.22 63.28,55.05 63.41,54.93 63.99,54.93 64.27,55.21 64.27,55.38 64.14,55.51 63.94,55.51 63.81,55.64 v4(63.81,55.92)
  IN3 w0.122: v8(18.8,39.88) 19.35,39.33 24.13,39.33 25.27,38.19 25.63,38.19 25.89,37.93 25.89,37.81 25.95,37.75 25.95,36.09 v10(25.98,36.06) 26.45,36.52 26.45,37.27 26.91,37.73 26.91,38.25 27.14,38.48 27.76,38.48 28.51,37.73 29.45,37.73 29.73,38.01 30.89,38.01 31.91,39.03 32.6,39.03 33.02,38.61 33.02,37.82 33.19,37.66 33.84,37.66 33.88,37.7 34.73,37.7 34.76,37.67 35.32,37.67 35.52,37.48 35.52,37.22 35.9,36.84 36.25,36.84 v10(37.03,36.06) 37.13,35.96 38.93,35.96 38.99,36.02 38.99,39.96 40.01,40.98 42.78,40.98 42.91,40.86 42.91,39.71 43.04,39.59 43.32,39.59 43.44,39.71 43.44,40.35 43.57,40.47 43.94,40.47 44.07,40.35 44.07,37.82 44.19,37.7 45.03,37.7 45.88,38.54 46.92,38.54 47.28,38.19 47.37,38.19 47.37,38.19 47.72,38.19 47.73,38.19 47.81,38.19 48.08,37.92 48.08,36.06 v10(48.08,36.06) 48.55,36.52 48.55,37.27 48.95,37.67 51.46,37.67 51.8,38.01 51.8,38.47 51.9,38.57 52.48,38.57 52.61,38.44 52.61,38.14 52.74,38.01 53.32,38.01 53.45,38.14 53.45,38.9 53.58,39.03 54.91,39.03 55.11,38.82 55.11,37.82 55.24,37.7 56.08,37.7 56.19,37.81 56.75,37.81 56.88,37.68 57.41,37.68 57.64,37.45 57.64,37.02 57.82,36.84 58.34,36.84 58.49,36.69 58.5,36.69 v10(59.13,36.06) 59.62,36.54 59.62,37.27 60.05,37.71 60.05,39.05 60.18,39.18 60.84,39.18 60.97,39.05 60.97,37.76 61.09,37.63 61.73,37.63 61.86,37.76 61.86,39.05 61.98,39.18 62.55,39.18 63.09,39.72 63.09,40.13 62.82,40.4 62.82,41.29 63.78,42.25 64.26,42.25 64.26,42.25 64.7,42.25 64.96,41.99 64.96,41.69 64.98,41.67 v4(64.97,41.67)
  IN4 w0.091: v5(63.2,56.68) 63.2,56.17 63.45,55.92 v4(63.81,55.92)
  GND5 w0.102: v6(63.08,57.1) 63.08,56.8 v5(63.2,56.68)
  BOTTOM w0.076: UD13.F3 37.93,34.8 37.62,35.12 37.62,35.48 37.04,36.06 v10(37.03,36.06) ; UD11.F3 48.98,34.8 48.66,35.12 48.66,35.48 48.09,36.06 v10(48.08,36.06) ; v10(25.98,36.06) 25.99,36.06 26.57,35.48 26.57,35.12 26.88,34.8 UD15.F3 ; v10(59.13,36.06) 59.14,36.06 59.71,35.48 59.71,34.55 59.79,34.48 UD9.F3
  BOTTOM w0.16: UCPU1.BF40 v6(63.08,57.1)
DDR_B_WE#: length 168.6
  TOP w0.076: UD12.H3 45.96,32.88 46.35,33.28 47.78,33.28 v10(48.03,33.53) ; v10(59.08,33.53) 58.83,33.28 57.4,33.28 57.01,32.88 UD10.H3 ; v10(36.98,33.53) 36.73,33.28 35.3,33.28 34.91,32.88 UD14.H3 ; v10(25.93,33.53) 25.68,33.28 24.25,33.28 23.86,32.88 UD16.H3
  TOP w0.16: R1083.1 17.96,36.13 v7(18.47,36.13)
  IN2 w0.122: v4(64.82,39.38) 64.85,39.38 64.82,39.35 63.85,39.35 62.77,40.43 62.29,40.43 61.67,41.05 57.68,41.05 57.37,41.36 55.44,41.36 54.66,40.57 43.38,40.57 43.2,40.75 40.43,40.75 39.4,41.78 39.4,42.97 38.61,43.76 38.61,45.9 40.02,47.31 41.24,47.31 42.42,48.49 42.74,48.49 42.96,48.71 42.96,49.37 43.25,49.66 44.46,49.66 44.67,49.87 44.67,52.39 44.79,52.51 45.09,52.51 45.22,52.39 45.22,52.13 45.35,52.01 45.65,52.01 45.78,52.13 45.78,53.43 45.9,53.56 46.83,53.56 46.96,53.68 46.96,54.7 49.37,57.11 50.22,57.11 50.34,57.23 50.34,57.68 50.47,57.8 50.71,57.8 50.83,57.68 50.83,57.23 50.95,57.11 51.2,57.11 51.32,57.23 51.32,57.68 51.44,57.8 51.68,57.8 51.81,57.68 51.81,57.23 51.93,57.11 52.17,57.11 52.29,57.23 52.29,57.68 52.42,57.8 52.66,57.8 52.78,57.68 52.78,57.23 52.9,57.11 53.15,57.11 53.27,57.23 53.27,57.68 53.39,57.8 53.64,57.8 53.76,57.68 53.76,57.23 53.88,57.11 54.12,57.11 54.25,57.23 54.25,57.68 54.37,57.8 54.61,57.8 54.73,57.68 54.73,57.23 54.85,57.11 58.96,57.11 v4(60.28,58.43)
  IN3 w0.122: v4(64.82,39.38) 64.85,39.35 64.85,39.34 64.82,39.31 64.2,39.31 63.46,38.57 63.46,37.48 63.25,37.27 62.82,37.27 62.69,37.14 62.69,36.74 62.57,36.61 61.75,36.61 61.53,36.39 61.53,34.58 61.65,34.46 62.14,34.46 62.26,34.33 62.26,34.02 62.14,33.9 61.73,33.9 61.6,33.77 61.6,33.49 61.73,33.36 62.14,33.36 62.27,33.24 62.27,32.25 62.14,32.12 61.81,32.12 61.68,32.25 61.68,32.73 61.55,32.85 61.22,32.85 61.09,32.73 61.09,32.25 60.97,32.12 60.69,32.12 59.28,33.53 v10(59.08,33.53) 59.08,34.24 58.63,34.69 57.07,34.69 55.96,33.59 55.41,33.59 54.58,34.42 54.58,34.42 53.8,35.2 52.41,35.2 51.04,33.82 50.74,33.82 50.38,34.18 50.38,34.74 49.89,35.23 49.09,35.23 48.22,34.36 48.22,33.72 v10(48.03,33.53) 47.86,33.7 47.86,34.47 47.64,34.69 46.71,34.69 46.57,34.83 46.19,34.83 45.83,35.19 45.37,35.19 45.01,34.83 44.36,34.83 44.05,35.14 44.05,36.18 43.77,36.46 43.24,36.46 42.04,37.66 40.7,37.66 40.57,37.53 40.57,35.9 41.02,35.46 41.02,34.6 40.79,34.37 38.67,34.37 38.54,34.5 38.54,34.71 38.41,34.84 38.1,34.84 37.97,34.71 37.97,33.78 37.85,33.66 37.61,33.66 37.48,33.78 37.48,34.32 37.36,34.45 37.11,34.45 36.98,34.32 v10(36.98,33.53) 36.74,33.77 36.74,34.49 36.53,34.69 35.68,34.69 35.55,34.83 33.69,34.83 33.28,34.42 32.48,34.42 31.71,35.2 30.32,35.2 29.57,34.46 28.68,34.46 27.85,35.29 27.56,35.29 27.44,35.17 27.44,34.35 27.31,34.23 27.07,34.23 26.95,34.35 26.95,35.17 26.83,35.29 26.52,35.29 26.12,34.89 26.12,33.72 v10(25.93,33.53) 25.71,33.75 25.71,34.42 25.44,34.7 25.31,34.7 25.3,34.69 22.51,34.69 22.21,34.39 21.41,34.39 19.68,36.13 v7(18.47,36.13)
  IN4 w0.091: v4(60.28,58.43) 60.41,58.43 v5(60.84,58.86)
  GND5 w0.102: v6(60.23,59.03) 60.67,59.03 v5(60.84,58.86)
  BOTTOM w0.076: v10(59.08,33.53) 59.02,33.58 58.82,33.58 58.74,33.5 58.74,33.22 58.87,33.09 59.34,33.09 59.38,33.05 59.38,32.74 59.51,32.62 59.76,32.62 UD9.H3 ; UD13.H3 37.66,32.62 37.41,32.62 37.28,32.74 37.28,33.05 37.24,33.09 36.77,33.09 36.65,33.22 36.65,33.5 36.73,33.58 36.93,33.58 v10(36.98,33.53) ; v10(48.03,33.53) 47.98,33.58 47.77,33.58 47.7,33.5 47.7,33.22 47.82,33.09 48.29,33.09 48.33,33.05 48.33,32.74 48.46,32.62 48.71,32.62 UD11.H3 ; v10(25.93,33.53) 25.88,33.58 25.68,33.58 25.6,33.5 25.6,33.22 25.72,33.09 26.19,33.09 26.24,33.05 26.24,32.74 26.36,32.62 26.61,32.62 UD15.H3
  BOTTOM w0.16: UCPU1.BD45 60.42,58.56 60.42,58.84 v6(60.23,59.03)
DH_1.35V: length 13.9
  IN2 w1.016: 47.73,21.37 46.31,21.37 44.5,23.18 41.2,23.18 39.34,21.32 35.36,21.32
  vias: v7(33.76,21.5) v7(33.76,20.87) v7(48.01,23.05) v7(47.99,22.42)
DISP_CEC: length 8.5
  BOTTOM w0.122: JMDP1.6 217.69,72.8 v1(217.18,72.29) 216.2,71.31 214.59,71.31 213.65,72.25 RV4.1
DISP_CLK_AUXP_CONN: length 75.1
  TOP w0.122: v1(174.84,55.71) RV3.1 173.89,56.89 173.48,57.3 v2(173.48,57.78) ; v2(172.22,59.22) 171.97,59.47 UV1.4
  GND1 w0.104: v2(172.22,59.22) v3(172.57,58.86) ; v2(173.48,57.78) v3(173.48,58.25)
  IN1 w0.071: v3(173.48,58.25) 173.19,58.25 v3(172.57,58.86) 172.57,61.71 v4(172.75,61.89)
  IN2 w0.094: v4(217.18,69.78) 217.03,69.63 216.9,69.63 216.72,69.81 216.72,72 214.65,74.08 214.45,74.08 211.63,76.9 210,76.9 209.7,77.2 202.33,77.2 200.04,79.49 198.47,79.49 196.88,81.08 190.21,81.08 185.25,76.13 185.25,75.09 182.14,71.97 178.32,71.97 174.96,68.62 174.96,64.48 173.46,62.98 173.46,62.67 173.27,62.48 172.97,62.48 172.75,62.27 v4(172.75,61.89)
  IN4 w0.071: v5(218.71,69.78) v4(217.18,69.78)
  GND5 w0.104: v5(218.71,69.78) 218.74,69.81 v6(219.27,69.81)
  BOTTOM w0.122: JMDP1.16 219.28,69.8 v6(219.27,69.81)
DISP_DAT_AUXN_CONN: length 72.9
  TOP w0.122: RV2.1 169.59,58.51 170.58,57.52 UV1.7 172.46,57.52 174.11,59.17 174.11,61.94 v7(174.04,62.01)
  IN2 w0.094: v4(217.18,69.08) 216.53,69.72 216.53,71.88 214.54,73.88 214.14,73.88 211.45,76.57 210.05,76.57 209.62,77 202.08,77 199.79,79.29 198.37,79.29 196.79,80.86 190.27,80.86 185.45,76.04 185.45,75.01 182.1,71.66 180.58,71.66 180.07,71.15 179.61,71.15 175.34,66.88 175.34,62.78 174.58,62.01 v7(174.04,62.01)
  IN4 w0.071: v4(217.18,69.08) 218.6,69.08 v5(218.73,69.2)
  GND5 w0.104: v6(219.36,69.2) v5(218.73,69.2)
  BOTTOM w0.122: JMDP1.18 v6(219.36,69.2)
DISP_HPD_SINK: length 19.1
  TOP w0.122: v1(212.54,73.06) 212.24,73.06 211.69,73.61 211.69,74.05 211.39,74.36 211.39,75.63 QV1.1 212.61,76.03 212.76,76.19 213.85,76.19 214.32,75.72 214.58,75.72 214.59,75.72 214.94,75.72 215.08,75.63 215.11,75.62 215.58,75.15 216.85,75.15 v7(217.15,74.84)
  BOTTOM w0.122: RV10.1 212.77,75.58 213.27,76.07 214.04,76.07 214.43,75.68 214.98,75.68 215.53,75.13 216.86,75.13 v7(217.15,74.84) 217.99,74 JMDP1.2
DISPOFF#: length 9.6
  TOP w0.122: v7(160.41,78.63) 160.41,77.99 160.52,77.88 161.74,77.88 162.01,78.14 162.01,78.6 162.24,78.83 162.52,78.83 162.83,78.51 162.83,78.48 163.08,78.23 163.11,78.23 163.89,77.46 163.9,77.46 v1(164.14,77.22) R540.1 164.14,75.02 D72.1
  BOTTOM w0.122: JLVDS1.13 160.25,78.79 v7(160.41,78.63)
DL_1.35V: length 20.8
  TOP w0.122: PT10.1 v7(32.24,18.96)
  IN4 w1.016: 54.29,20.82 50.78,20.82 49.21,19.24 47.88,19.24 47.81,19.18 46.46,19.18 46.45,19.19 45.83,19.19 45.78,19.24 34.75,19.24 34.73,19.27
  vias: v7(32.24,19.6) v7(54.79,19.8) v7(54.79,19.14)
DMI_CRX_PTX_N0: length 27
  IN2 w0.094: v4(98.71,64.05) 98.53,64.23 98.53,66.43 97.33,67.63 97.33,68.32 96.82,68.83 96.82,69.77 95.97,70.62 94.42,70.62 91.62,73.42 87.56,73.42 85.64,75.34 83.82,75.34 82.63,74.15 81.98,74.15 81.86,74.26 81.86,74.45 81.96,74.55 v7(82.25,74.55)
  IN4 w0.071: v4(98.71,64.05) 98.64,64.12 v5(98.64,64.53)
  GND5 w0.076: v6(98.86,64.1) 98.64,64.33 v5(98.64,64.53)
  BOTTOM w0.114: v7(82.25,74.55) 82.13,74.43 81.84,74.43 UCPU1.M2 ; UH1.BD22 98.86,64.51 v6(98.86,64.1)
DMI_CRX_PTX_N1: length 34.3
  IN2 w0.094: v7(79.59,72.81) 79.42,72.81 78.97,73.26 78.97,73.88 78.28,74.57 78.28,74.91 78.64,75.27 82.61,75.27 83.43,76.09 85.65,76.09 87.51,74.24 91.54,74.24 94.5,71.29 95.95,71.29 98.48,68.75 98.48,68.07 99.75,66.79 99.75,65.7 100.24,65.21 100.24,64.45 v4(99.87,64.08)
  IN4 w0.071: v5(99.95,64.57) 99.96,64.57 100.08,64.45 100.08,64.28 v4(99.87,64.08)
  GND5 w0.076: v6(99.71,65) 99.95,64.77 v5(99.95,64.57)
  BOTTOM w0.114: UH1.BB22 99.74,64.98 v6(99.71,65) ; v7(79.59,72.81) 79.59,73.11 79.75,73.27 UCPU1.P6
DMI_CRX_PTX_N2: length 30.7
  IN2 w0.094: v4(99.89,63.1) 100.1,63.31 100.1,63.4 100.01,63.49 99.44,63.49 99.33,63.39 99.33,62.78 99.04,62.49 98.43,62.49 98.43,62.49 97.7,62.49 97.17,63.02 97.17,64.73 96.86,65.03 96.86,65.52 97.19,65.85 97.19,66.71 96.13,67.77 96.13,69.45 95.87,69.71 93.4,69.71 90.69,72.43 87.28,72.43 85.48,74.23 84.54,74.23 84.24,73.93 83.91,73.93 v8(83.47,73.49)
  IN4 w0.071: v4(99.89,63.1) 100.1,63.31 100.1,63.47 99.99,63.58 v5(99.97,63.58)
  GND5 w0.076: v6(99.74,64.02) 99.74,63.82 v5(99.97,63.58)
  BOTTOM w0.114: UCPU1.P1 81.75,73.13 81.69,73.19 81.69,73.29 81.86,73.46 82.89,73.46 83.15,73.72 83.24,73.72 v8(83.47,73.49) ; UH1.BB19 v6(99.74,64.02)
DMI_CRX_PTX_N3: length 40
  IN2 w0.094: v7(77.71,72.76) 77.57,72.62 77.39,72.62 77.24,72.77 77.24,74.93 79.51,77.21 86.26,77.21 87.94,75.53 92.1,75.53 93.78,73.86 93.78,73.1 94.85,72.02 95.99,72.02 99.4,68.61 99.4,67.7 100.95,66.15 100.95,63.94 100.81,63.8 100.81,63.25 100.85,63.2 100.85,62.86 100.7,62.71 100.36,62.71 100.18,62.53 100.18,62.42 v4(99.89,62.13)
  IN4 w0.071: v4(99.89,62.13) 100.1,62.35 100.1,62.5 99.99,62.61 v5(99.97,62.61)
  GND5 w0.076: v5(99.97,62.61) 99.97,62.62 99.97,62.84 99.75,63.06 99.74,63.05 v6(99.74,63.06)
  BOTTOM w0.114: v7(77.71,72.76) 77.58,72.89 77.58,73 UCPU1.P10 ; UH1.BB17 99.74,63.06 v6(99.74,63.06)
DMI_CRX_PTX_P0: length 27.1
  IN2 w0.094: v4(98.15,64.05) 98.33,64.23 98.33,66.35 97.14,67.55 97.14,68.24 96.63,68.75 96.63,69.68 95.89,70.42 94.34,70.42 91.54,73.22 87.48,73.22 85.56,75.15 83.9,75.15 82.71,73.95 81.9,73.95 81.67,74.18 81.67,74.49 81.59,74.56 v8(81.21,74.56)
  IN4 w0.071: v4(98.15,64.05) 98.23,64.12 v5(98.23,64.53)
  GND5 w0.076: v5(98.23,64.53) 98.23,64.32 v6(98.01,64.1)
  BOTTOM w0.114: v8(81.21,74.56) 81.38,74.4 UCPU1.N3 ; UH1.BF22 v6(98.01,64.1)
DMI_CRX_PTX_P1: length 34.3
  IN2 w0.094: v7(78.77,72.83) 78.77,73.8 78.09,74.49 78.09,74.99 78.56,75.47 82.52,75.47 83.34,76.29 85.73,76.29 87.59,74.43 91.62,74.43 94.58,71.48 96.03,71.48 98.67,68.84 98.67,68.15 99.95,66.87 99.95,65.78 100.44,65.29 v4(100.44,64.08)
  IN4 w0.071: v5(100.35,64.57) 100.24,64.45 100.24,64.27 v4(100.44,64.08)
  GND5 w0.076: v5(100.35,64.57) 100.35,64.75 v6(100.58,64.98)
  BOTTOM w0.114: v6(100.58,64.98) 100.6,64.95 UH1.AY22 ; UCPU1.P7 79.15,73.21 v7(78.77,72.83)
DMI_CRX_PTX_P2: length 30.7
  IN2 w0.094: v4(100.46,63.1) 100.3,63.26 100.3,63.48 100.09,63.69 99.35,63.69 99.13,63.47 99.13,62.87 98.96,62.69 98.35,62.69 98.35,62.69 97.78,62.69 97.37,63.1 97.37,64.81 97.06,65.11 97.06,65.44 97.38,65.77 97.38,66.79 96.32,67.85 96.32,69.53 95.95,69.91 93.48,69.91 90.77,72.62 87.36,72.62 85.56,74.43 84.46,74.43 84.16,74.13 v7(83.5,74.13)
  IN4 w0.071: v5(100.38,63.58) 100.27,63.47 100.27,63.29 v4(100.46,63.1)
  GND5 w0.076: v6(100.6,63.99) 100.6,63.81 v5(100.38,63.58)
  BOTTOM w0.114: UH1.AY19 v6(100.6,63.99) ; v7(83.5,74.13) 83.35,73.98 83.05,73.98 82.75,73.69 81.72,73.69 81.43,73.4 81.43,73.19 UCPU1.P3
DMI_CRX_PTX_P3: length 40.1
  IN2 w0.094: v4(100.46,62.13) 100.38,62.21 100.38,62.45 100.44,62.51 100.78,62.51 101.05,62.78 101.05,63.28 101,63.33 101,63.72 101.14,63.86 101.14,66.24 99.6,67.78 99.6,68.69 96.07,72.22 94.93,72.22 93.97,73.18 93.97,73.94 92.18,75.73 88.02,75.73 86.34,77.41 79.43,77.41 77.04,75.01 77.04,73.01 v8(76.79,72.76)
  IN4 w0.071: v4(100.46,62.13) 100.27,62.32 100.27,62.5 v5(100.38,62.61)
  GND5 w0.076: v6(100.6,63.06) 100.6,63.06 100.38,62.84 100.38,62.62 v5(100.38,62.61)
  BOTTOM w0.114: v8(76.79,72.76) 77.2,73.17 UCPU1.P11 ; v6(100.6,63.06) 100.6,63.06 UH1.AY17
DMI_CTX_PRX_N0: length 32.2
  IN2 w0.094: v4(95.79,64.79) 96.03,64.79 96.16,64.92 96.16,65.04 96.03,65.17 95.24,65.17 94.86,65.55 94.86,67.18 94.51,67.53 92.92,67.53 90.82,69.63 90.21,69.63 90.01,69.84 90.01,70.23 89.91,70.33 89.63,70.33 89.54,70.23 89.54,69.57 89.29,69.32 88.92,69.32 88.67,69.57 88.67,70.23 88.58,70.33 88.3,70.33 88.21,70.23 88.21,69.61 87.96,69.36 87.59,69.36 87.34,69.61 87.34,70.23 87.25,70.33 86.97,70.33 86.87,70.23 86.87,69.67 86.57,69.36 85.25,69.36 84.87,69.74 84.87,70.06 85.59,70.78 85.59,70.95 85.35,71.19 85.17,71.19 84.44,70.47 84.15,70.47 83.84,70.77 83.84,71.67 84.08,71.9 84.08,72.2 v7(83.88,72.4)
  IN4 w0.071: v5(96.1,64.41) 96.1,64.49 v4(95.79,64.79)
  GND5 w0.076: v6(95.68,64.41) v5(96.1,64.41)
  BOTTOM w0.114: v7(83.88,72.4) 84.13,72.65 84.13,73.04 84.02,73.16 v7(84.02,73.83) 84.02,74.52 83.34,75.19 82.8,75.19 82.71,75.28 82.51,75.28 82.35,75.44 81.79,75.44 81.69,75.34 81.69,74.92 81.74,74.87 81.97,74.87 82.1,75 UCPU1.K1 ; UH1.BL21 v6(95.68,64.41)
DMI_CTX_PRX_N1: length 26.6
  IN2 w0.094: v4(95.75,65.74) 95.97,65.74 96.1,65.87 96.1,66.92 95.07,67.94 95.07,68.23 95.26,68.42 95.4,68.56 95.4,68.74 95.25,68.89 95.07,68.89 94.74,68.57 94.08,68.57 93.7,68.95 92.54,68.95 90.35,71.14 86.54,71.14 85.84,71.84 85.84,72.78 85.17,73.45 84.67,73.45 84.11,72.89 83.21,72.89 82.63,73.48 81.43,73.48 80.62,74.29 80.14,74.29 79.93,74.09 79.3,74.09 79.05,74.34 79.05,74.61 v7(78.87,74.79)
  IN4 w0.071: v4(95.75,65.74) 95.75,65.59 v5(96.11,65.23)
  GND5 w0.076: v6(95.7,65.23) v5(96.11,65.23)
  BOTTOM w0.114: UH1.BL23 v6(95.7,65.23) ; UCPU1.M8 78.87,74.58 v7(78.87,74.79)
DMI_CTX_PRX_N2: length 26.6
  IN2 w0.094: v4(96.55,63.84) 96.55,63.84 96.37,63.84 96.3,63.91 96.3,64.19 96.08,64.41 95.32,64.41 91.02,68.72 90.13,68.72 89.93,68.51 89.93,68.27 89.83,68.17 89.55,68.17 89.46,68.27 89.46,68.51 89.25,68.72 88.77,68.72 88.6,68.89 87.74,68.89 87.54,68.68 87.54,68.27 87.44,68.17 87.16,68.17 87.07,68.27 87.07,68.68 86.86,68.89 86.41,68.89 86.2,68.68 86.2,68.27 86.11,68.17 85.83,68.17 85.73,68.27 85.73,68.68 85.53,68.89 85.05,68.89 83.12,70.82 83.12,71.91 82.9,72.14 82.9,72.87 82.51,73.27 81.16,73.27 81.03,73.39 80.47,73.39 v7(80.19,73.67)
  IN4 w0.071: v4(96.55,63.84) 96.55,63.84 96.79,63.6 v5(96.98,63.6)
  GND5 w0.076: v6(96.55,63.6) v5(96.98,63.6)
  BOTTOM w0.114: v5(96.98,63.6) v6(96.55,63.6) ; UCPU1.N4 80.51,73.67 v7(80.19,73.67)
DMI_CTX_PRX_N3: length 26.9
  IN2 w0.094: v7(82.26,72.58) 81.79,72.58 81.39,72.18 81.39,71.85 81.26,71.72 81.26,70.34 81.54,70.06 81.67,70.06 82.13,70.52 82.47,70.52 82.74,70.25 82.74,69.91 82.28,69.46 82.28,69.32 82.64,68.97 82.77,68.97 83.22,69.42 83.57,69.42 83.83,69.16 83.83,68.81 83.38,68.36 83.38,68.23 84.1,67.5 91.19,67.5 93.87,64.82 93.87,64.39 95.22,63.04 95.46,62.8 95.89,62.8 96,62.91 96,63.05 95.87,63.18 v4(95.66,63.18)
  IN4 w0.071: v4(95.66,63.18) 96.06,62.79 v5(96.12,62.79)
  GND5 w0.076: v6(96.12,63.2) v5(96.12,62.79)
  BOTTOM w0.114: v7(82.26,72.58) 82.07,72.39 81.91,72.39 UCPU1.R2 ; v5(96.12,62.79) v6(96.12,63.2)
DMI_CTX_PRX_P0: length 32.2
  IN2 w0.094: v4(96.56,64.79) 96.45,64.79 96.35,64.89 96.35,65.12 96.11,65.36 95.32,65.36 95.05,65.63 95.05,67.26 94.59,67.72 93,67.72 90.9,69.83 90.3,69.83 90.2,69.92 90.2,70.31 89.99,70.52 89.55,70.52 89.34,70.31 89.34,69.65 89.21,69.52 89,69.52 88.87,69.65 88.87,70.31 88.66,70.52 88.22,70.52 88.01,70.31 88.01,69.69 87.88,69.56 87.67,69.56 87.54,69.69 87.54,70.31 87.33,70.52 86.89,70.52 86.68,70.31 86.68,69.75 86.49,69.56 85.33,69.56 85.06,69.83 85.06,69.98 85.78,70.7 85.78,71.03 85.43,71.38 85.09,71.38 84.36,70.66 84.23,70.66 84.04,70.85 84.04,71.59 84.27,71.82 84.27,72.16 v8(84.51,72.4)
  IN4 w0.071: v5(96.98,64.41) 96.95,64.41 96.57,64.79 v4(96.56,64.79)
  GND5 w0.076: v6(96.56,64.41) v5(96.98,64.41)
  BOTTOM w0.114: UCPU1.K3 81.38,75.39 81.64,75.65 82.5,75.65 82.61,75.54 82.82,75.54 82.91,75.45 83.45,75.45 84.27,74.63 84.27,73.26 84.39,73.15 84.39,72.53 v8(84.51,72.4) ; UH1.BJ21 v6(96.56,64.41)
DMI_CTX_PRX_P1: length 26.6
  IN2 w0.094: v4(96.53,65.71) 96.29,65.95 96.29,67 95.27,68.02 95.27,68.15 95.4,68.28 95.6,68.48 95.6,68.82 95.4,69.02 95.33,69.09 94.99,69.09 94.66,68.76 94.16,68.76 93.78,69.14 92.62,69.14 90.43,71.34 86.62,71.34 86.03,71.92 86.03,72.87 85.25,73.65 84.59,73.65 84.03,73.09 83.29,73.09 82.71,73.67 81.52,73.67 80.7,74.49 80.06,74.49 79.85,74.28 79.38,74.28 79.25,74.42 79.25,74.63 79.41,74.79 v8(79.51,74.79)
  IN4 w0.071: v5(96.96,65.23) 96.53,65.66 v4(96.53,65.71)
  GND5 w0.076: v6(96.54,65.23) v5(96.96,65.23)
  BOTTOM w0.114: UH1.BJ23 v6(96.54,65.23) ; UCPU1.M7 79.21,74.49 v8(79.51,74.79)
DMI_CTX_PRX_P2: length 26.6
  IN2 w0.094: v8(80.22,72.86) 80.22,73.06 80.35,73.2 80.95,73.2 81.08,73.07 82.43,73.07 82.7,72.79 82.7,72.05 82.93,71.83 82.93,70.74 82.99,70.68 84.97,68.69 85.44,68.69 85.54,68.6 85.54,68.18 85.75,67.98 86.19,67.98 86.4,68.18 86.4,68.6 86.49,68.69 86.78,68.69 86.87,68.6 86.87,68.18 87.08,67.98 87.52,67.98 87.73,68.18 87.73,68.6 87.82,68.69 88.52,68.69 88.69,68.52 89.17,68.52 89.26,68.43 89.26,68.18 89.47,67.98 89.91,67.98 90.12,68.18 90.12,68.43 90.22,68.52 90.93,68.52 95.24,64.22 96,64.22 96.11,64.11 96.11,63.95 96,63.84 v4(95.69,63.84)
  IN4 w0.071: v4(95.69,63.84) 95.88,63.84 v5(96.12,63.6)
  GND5 w0.076: v6(95.66,63.64) 96.08,63.64 v5(96.12,63.6)
  BOTTOM w0.114: v5(96.12,63.6) 95.7,63.6 v6(95.66,63.64) ; UCPU1.P4 80.6,73.24 v8(80.22,72.86)
DMI_CTX_PRX_P3: length 26.9
  IN2 w0.094: v7(81.21,72.58) 81.2,72.57 81.2,71.93 81.07,71.8 81.07,70.26 81.46,69.87 81.75,69.87 82.21,70.32 82.39,70.32 82.54,70.17 82.54,69.99 82.09,69.54 82.09,69.24 82.56,68.77 82.85,68.77 83.31,69.23 83.48,69.23 83.64,69.07 83.64,68.89 83.18,68.44 83.18,68.15 84.02,67.3 91.11,67.3 93.68,64.74 93.68,64.31 94.86,63.12 95.08,62.9 95.38,62.61 95.98,62.61 96.2,62.83 96.2,63.08 96.3,63.18 v4(96.55,63.18)
  IN4 w0.071: v5(96.98,62.79) 96.9,62.79 96.55,63.13 v4(96.55,63.18)
  GND5 w0.076: v6(96.98,63.2) v5(96.98,62.79)
  BOTTOM w0.114: UCPU1.T3 81.38,72.42 v7(81.21,72.58) ; v5(96.98,62.79) v6(96.98,63.2)
DMI_IRCOMP: length 6.9
  TOP w0.102: RH124.2 95.44,64.43 v1(98.08,64.43)
  TOP w0.122: v1(98.08,64.43) 98.08,63.71 v2(97.95,63.58)
  GND1 w0.102: v2(97.95,63.58) 97.99,63.54 v3(98.43,63.54)
  IN1 w0.071: v3(98.43,63.54) 98.41,63.54 98.71,63.23 v4(98.71,63.08)
  IN4 w0.071: v4(98.71,63.08) 98.71,63.41 v5(98.85,63.55)
  GND5 w0.102: v6(98.43,63.55) v5(98.85,63.55)
  BOTTOM w0.122: UH1.BD19 v6(98.43,63.55) UH1.BF19
DMIC0: length 222.5
  TOP w0.122: v7(21.07,44.96) 21.64,45.53 22.46,45.53 22.74,45.81 23.9,45.81 24.44,46.35 27.13,46.35 27.78,45.7 31.79,45.7 32.37,45.12 36.43,45.12 37.14,45.83 54.98,45.83 55.69,45.12 57.61,45.12 57.72,45.24 80.4,45.24 80.7,45.53 83.49,45.53 89.31,51.35 91.37,51.35 94.3,54.29 94.3,54.65 v9(94.9,55.25) 95.16,55.51 95.22,55.51 v2(95.47,55.76)
  GND1 w0.104: v3(95.94,55.74) 95.92,55.76 v2(95.47,55.76)
  IN1 w0.071: v4(133.91,64.13) 134.42,63.62 134.42,62.36 134.21,62.15 133.58,62.15 132.16,60.73 131.7,60.73 130.53,59.55 130.53,59.43 127.32,56.22 125.38,56.22 124.41,55.25 121.31,55.25 121.02,54.96 116.94,54.96 116.66,54.68 112.15,54.68 112.04,54.78 108.98,54.78 108.8,54.96 107.78,54.96 107.72,54.9 106.76,54.9 106.59,55.07 100.35,55.07 99.54,55.88 96.11,55.88 95.94,55.71 v3(95.94,55.74)
  IN2 w0.094: v7(21.07,44.96) 21.07,44.94 21.47,44.54 21.47,42.2 19.71,40.44 19.71,35.13 20.66,34.18 20.66,25.21 v7(22.05,23.81) ; v4(133.91,64.13) 133.95,64.13 135.73,65.92 139.76,65.92 140.32,66.47 142.58,66.47 142.75,66.64 144.92,66.64 145.53,66.03 146.75,66.03 148.35,64.43 152.08,64.43 152.66,63.85 154.22,63.85 154.94,64.57 155.89,64.57 156.19,64.27 157.4,64.27 157.74,64.6 159.9,64.6 160.48,65.19 164.39,65.19 166.25,67.05 166.25,67.88 166.82,68.46 166.82,70.66 168.2,72.03 170.16,72.03 173.12,74.99 178.21,74.99 v7(178.37,75.15)
  BOTTOM w0.122: v7(22.05,23.81) 22.1,23.86 JIOL1.34 ; JLVDS2.5 183.24,80.63 183.6,80.99 184.94,80.99 185.68,80.25 185.68,78.49 185.05,77.85 183.71,77.85 182.99,77.13 182.99,75.81 182.38,75.2 D50.4 182.38,72.75 182.09,72.45 179.57,72.45 179.12,72.91 179.12,73.75 C1206.1 178.44,75.07 v7(178.37,75.15)
DMIC_CLK: length 209
  TOP w0.122: R537.2 180.98,77.3 180.98,75.98 v7(180.02,75.02) ; v7(21.06,44.32) 21.99,45.25 22.54,45.25 22.74,45.45 23.9,45.45 24.55,46.11 26.37,46.11 v9(26.71,45.76) 27.03,45.45 31.69,45.45 32.27,44.87 36.54,44.87 37.25,45.58 54.88,45.58 55.59,44.87 57.71,44.87 57.82,44.99 80.51,44.99 80.8,45.28 83.59,45.28 89.42,51.1 91.64,51.1 94.65,54.11 v2(94.65,54.47)
  GND1 w0.104: v2(94.65,54.47) 95,54.83 v3(95.03,54.83)
  IN1 w0.071: v4(134.55,64.15) 134.61,64.09 134.61,62.28 134.28,61.96 133.65,61.96 132.24,60.55 131.78,60.55 130.7,59.46 130.7,59.34 127.39,56.03 125.45,56.03 124.49,55.07 121.37,55.07 121.09,54.79 117.03,54.79 116.74,54.49 112.07,54.49 111.97,54.59 108.9,54.59 108.72,54.77 107.86,54.77 107.8,54.71 106.68,54.71 106.5,54.89 100.26,54.89 99.47,55.69 96.34,55.69 95.94,55.29 95.49,55.29 v3(95.03,54.83)
  IN2 w0.094: v4(134.55,64.15) 136.12,65.72 139.84,65.72 140.4,66.28 142.66,66.28 142.83,66.44 144.84,66.44 145.45,65.83 146.67,65.83 148.27,64.23 152,64.23 152.58,63.65 154.3,63.65 155.02,64.37 155.81,64.37 156.11,64.07 157.48,64.07 157.81,64.4 160.04,64.4 160.63,64.99 164.47,64.99 166.44,66.97 166.44,67.8 167.02,68.38 167.02,70.58 168.22,71.78 170.26,71.78 173.22,74.74 179.74,74.74 v7(180.02,75.02) ; v7(21.06,44.32) 21.06,42.07 19.51,40.52 19.51,34.97 20.43,34.05 20.43,24.8 v7(22.05,23.18)
  BOTTOM w0.122: v7(180.02,75.02) 180.48,74.56 D50.6 ; JIOL1.32 21.6,23.63 v7(22.05,23.18)
DMIC_CLK_R: length 9.3
  TOP w0.122: v7(182.1,81.19) 182.1,80.77 181.81,80.48 181.81,78.84 C1133.1 181.31,78.5 R537.1 180.42,79.39 v9(178.07,79.39)
  BOTTOM w0.122: v7(182.1,81.19) 182.18,81.11 182.33,81.11 182.74,80.7 JLVDS2.6
DP_CBL_DET: length 134.9
  TOP w0.122: v7(169.98,61.13) 170.28,61.42 UV1.1
  IN1 w0.071: v7(169.98,61.13) 169.98,62.83 166.94,65.87 166.94,67.65 165.5,69.09 v4(165.5,69.52)
  IN2 w0.094: v4(115.91,74.65) 116.61,75.35 120.25,75.35 124.92,80.02 126.14,80.02 126.35,79.82 126.35,79.16 126.55,78.96 127.85,78.96 128.58,78.23 129.68,78.23 130.31,77.6 132.07,77.6 133.84,75.83 133.84,74.41 134.51,73.74 135.54,73.74 136.23,73.05 136.23,72.33 136.77,71.78 137.34,71.78 137.97,71.16 137.97,70.7 139.75,68.91 142.02,68.91 142.92,68.01 145.94,68.01 146.14,67.81 147.07,67.81 147.66,67.23 149.84,67.23 150.37,66.69 153.25,66.69 154.44,67.89 156.85,67.89 157.42,67.32 159.92,67.32 160.41,67.81 164.89,67.81 165.36,68.29 165.36,69.38 v4(165.5,69.52) 165.36,69.66 165.36,70.88 165.59,71.11 166.17,71.11 169.41,74.35 169.41,74.8 174.04,79.43 182.9,79.43 184.72,81.24 184.72,81.65 185.68,82.61 189.52,82.61 189.87,82.97 190.81,82.97 191,82.78 196.68,82.78 197.19,82.27 197.19,81.91 198.8,80.3 200.42,80.3 202.67,78.05 211.03,78.05 212.15,76.94 213.23,76.94 213.52,76.64 v8(213.52,75.62)
  IN4 w0.071: v5(115.42,74.57) 115.5,74.65 v4(115.91,74.65)
  GND5 w0.104: v5(115.42,74.57) 115.34,74.48 v6(115.34,74.17)
  BOTTOM w0.122: v8(213.52,75.62) 212.9,75 RV8.1 ; UH1.F45 v6(115.34,74.17)
DRAMRST_CNTRL: length 68.4
  TOP w0.122: QD2.2 v1(92.56,43.6) 93.35,43.6 v7(93.76,44.01) ; v2(91.66,56.7) 91.39,56.43 91.06,56.43 90.18,55.55 90.18,55.26 89.78,54.86 87.86,54.86 82.15,49.15 77.73,49.15 77.55,48.97 63.29,48.97 62.27,50 56.8,50 56.15,49.34 55.26,49.34 54.57,50.03 v7(52.97,50.03) 52.55,50.44 RC72.2 52,51.18 R1035.1 CC69.1 50.86,50.57 RC145.2
  GND1 w0.104: v3(92.11,56.73) 92.07,56.7 v2(91.66,56.7)
  IN1 w0.071: v4(92.59,56.71) 92.13,56.71 v3(92.11,56.73)
  IN4 w0.071: v4(92.59,56.71) 92.59,55.54 91.79,54.73 91.79,45.98 v7(93.76,44.01)
  BOTTOM w0.122: QC2.2 52.64,50.36 v7(52.97,50.03) ; v7(93.76,44.01) 93.76,44.12 94.5,44.86 QD1.2
DRAMRST_CNTRL_EC: length 111.6
  TOP w0.122: U34.A1 145.42,62.42 v2(145.5,62.5) 145.5,62.69 146.92,64.11 146.92,64.73 147,64.81 R987.1 ; RC145.1 51.45,49.06 52.33,49.06 52.6,49.33 54.57,49.33 55.05,48.84 56.35,48.84 56.57,49.06 57.45,49.06 v1(57.65,49.26) 57.89,49.5 60.93,49.5 61.96,48.47 77.75,48.47 77.93,48.65 82.36,48.65 88.05,54.34 89.97,54.34 90.71,55.08 90.71,55.16 v2(90.95,55.4)
  GND1 w0.104: v3(145.39,62.95) 145.39,62.61 v2(145.5,62.5) ; v2(90.95,55.4) 91.29,55.74 v3(91.5,55.74)
  IN1 w0.071: v4(129.13,61.05) 129.13,60.65 127.35,58.87 127.24,58.87 124.91,56.53 121.54,56.53 121.06,56.06 121.06,55.73 120.81,55.48 118.6,55.48 117.63,56.44 115.26,56.44 114.05,55.23 112.38,55.23 112.28,55.33 110.17,55.33 109.63,55.87 109.63,56.1 109.03,56.7 107.45,56.7 107.25,56.5 106.59,56.5 106.38,56.3 105.54,56.3 105.31,56.54 95.78,56.54 94.75,55.5 92.53,55.5 92.18,55.16 91.76,55.16 91.5,55.42 v3(91.5,55.74) ; v4(144.94,63.08) 145.07,62.95 v3(145.39,62.95)
  IN4 w0.071: v4(129.13,61.05) 129.14,61.05 129.44,61.35 136.53,61.35 137.6,62.42 138.97,62.42 139.67,63.12 141.22,63.12 141.79,62.55 144.51,62.55 144.94,62.98 v4(144.94,63.08)
DRAMRST_CNTRL_PCH: length 102.5
  TOP w0.122: v2(91.21,56.08) 90.97,55.84 90.86,55.84 90.44,55.42 90.44,55.17 89.89,54.62 87.97,54.62 82.25,48.9 77.83,48.9 77.64,48.71 62.79,48.71 v1(62.29,49.21) 61.75,49.75 56.91,49.75 56.25,49.09 55.16,49.09 54.67,49.58 52.05,49.58 RC72.1 ; v2(117.36,62.73) 117.11,62.97 116.59,62.97 RH75.1 115.63,63.44 v2(115.58,63.39)
  GND1 w0.104: v3(91.65,56.22) 91.51,56.08 v2(91.21,56.08) ; v2(117.36,62.73) v3(117.79,62.73) ; v2(115.58,63.39) 115.45,63.51 v3(115.17,63.51)
  IN1 w0.071: v3(115.17,63.51) 115.17,63.87 v4(115.04,64) ; v3(117.79,62.73) 119.6,60.91 122.45,60.91 v4(122.81,60.54) ; v3(91.65,56.22) v4(92.18,56.22)
  IN2 w0.094: v4(96.17,52.03) 97.11,52.97 101.51,52.97 103.04,51.44 105.23,51.44 105.58,51.09 118.39,51.09 118.59,50.89 120.66,50.89 v4(120.94,50.61)
  IN4 w0.071: v4(96.17,52.03) 96.17,52.95 93,56.12 93,56.83 92.74,57.09 92.44,57.09 92.18,56.83 v4(92.18,56.22) ; v4(115.04,64) 114.54,64 v5(114.51,64.02) ; v5(123.32,60.29) 123.07,60.54 v4(122.81,60.54) ; v4(120.94,50.61) v5(121.42,50.61)
  GND5 w0.104: v6(123.12,59.91) 123.12,60.08 v5(123.32,60.29) ; v5(114.51,64.02) 114.46,64.07 v6(113.99,64.07) ; v5(121.42,50.61) v6(121.42,51.04)
  BOTTOM w0.122: v6(123.12,59.91) 122.82,59.61 122.82,57.34 123.5,56.66 123.62,56.66 124.26,56.01 124.26,55.69 123.95,55.37 123.11,55.37 122.12,54.38 122.12,51.74 v6(121.42,51.04) ; UH1.H22 v6(113.99,64.07)
DSWODVREN: length 7.7
  TOP w0.122: RH151.2 RH147.2 117.18,67.14 116.85,66.81 116.85,65.44 116.62,65.21 v2(115.62,65.21)
  GND1 w0.104: v2(115.62,65.21) 115.63,65.21 115.9,64.94 v3(115.93,64.94)
  IN1 w0.071: v4(116.16,64.02) 116.16,64.71 v3(115.93,64.94)
  IN4 w0.071: v5(115.63,64.1) 116.09,64.1 v4(116.16,64.02)
  GND5 w0.104: v6(115.27,64.45) v5(115.63,64.1)
  BOTTOM w0.122: UH1.F22 115.21,64.52 v6(115.27,64.45)
EAPD#: length 172.2
  TOP w0.122: v2(95.7,52.69) 95.08,52.07 94.38,52.07 91.36,49.05 89.14,49.05 84.13,44.04 81.31,44.04 81.02,43.74 63.66,43.74 63.44,43.53 55.13,43.53 54.35,44.31 37.74,44.31 37.05,43.62 31.75,43.62 31.17,44.2 26.03,44.2 25.43,43.6 v1(23.58,43.6) 22.74,43.6 22.37,43.23 20.95,43.23 v7(20.63,42.91) ; v2(146.96,47.69) 147.4,47.69 149.16,49.44 149.16,53.15 149.63,53.62 149.63,54 148.93,54.7 R228.1
  GND1 w0.104: v2(95.7,52.69) 95.73,52.72 v3(96.27,52.72) ; v3(146.41,47.69) v2(146.96,47.69)
  IN1 w0.071: v3(146.41,47.69) 146.41,47.94 144.58,49.77 133.59,49.77 131,52.36 127.44,52.36 126.99,51.9 125.49,51.9 124.93,51.34 114,51.34 113.79,51.13 111.32,51.13 110.95,51.49 106.74,51.49 105.77,52.46 103.08,52.46 102.78,52.76 102.08,52.76 101.73,53.1 96.66,53.1 v3(96.27,52.72)
  IN2 w0.094: v7(20.63,42.91) 20.63,41.92 19.03,40.31 18.62,40.31 18.2,39.89 18.2,39.36 17.98,39.14 17.98,30.73 18.27,30.44 19.34,30.44 20.18,29.6 20.18,20.71 19.96,20.49 18.85,20.49 v7(18.45,20.89)
  BOTTOM w0.122: JIOL1.19 18.6,20.74 v7(18.45,20.89)
EAPD_R#: length 9.7
  TOP w0.076: U34.D6 143.67,59.35 142.95,59.35 v2(142.93,59.33)
  TOP w0.122: R241.1 147.66,54.21 147.7,54.25 R228.2 147.4,54.7 146.94,55.16 146.94,55.61 146.68,55.87 146.68,56.57 146.41,56.84 146.41,57.17 145.98,57.59 v2(145.98,57.62)
  GND1 w0.104: v3(143.54,59.16) 143.36,59.33 v2(142.93,59.33) ; v3(145.69,57.94) 145.98,57.65 v2(145.98,57.62)
  IN1 w0.071: v3(145.69,57.94) 145.34,57.94 144.03,59.26 143.64,59.26 v3(143.54,59.16)
EC_BATT_PRS: length 283.9
  TOP w0.122: PQ908.2 39.82,82.68 v7(42.68,85.53)
  TOP w0.254: PR915.2 PR916.1 v7(123.32,25.51) ; U34.B13 144.94,56.08 144.94,55.18 144.62,54.86 144.62,54.16 C286.2 143.03,54.06 141.73,52.76 141.73,52.15 141.6,52.02 140.99,52.02 140.29,51.32 140.29,51.12 140.32,51.09 v7(140.32,51.04)
  IN2 w0.254: v7(152.76,82.21) 151.75,82.21 150.9,83.06 142.95,83.06 141.79,81.9 137.94,81.9 137.1,82.75 136.18,82.75 134.84,84.09 134.84,85.15 133.91,86.08 129.64,86.08 129.42,85.86 125.46,85.86 124.98,85.38 124.98,84.68 123.3,83.01 120.04,83.01 118.89,81.86 114.79,81.86 114.5,81.57 108.6,81.57 105.98,78.94 98.5,78.94 97.47,79.97 97.47,81.5 93.66,85.31 85.15,85.31 84.11,84.26 80.42,84.26 79.48,83.32 74.68,83.32 72.47,85.53 46.1,85.53 45.61,85.05 43.16,85.05 v7(42.68,85.53) ; v7(123.32,25.51) 123.5,25.69 126.75,25.69 126.82,25.63 140.63,25.63 143.54,28.54 147.39,28.54 147.59,28.33 156.46,28.33 157.06,28.93 169.9,28.93 172.53,31.56 172.53,32.46 174.81,34.73 174.81,40.11 171.76,43.17 170.57,43.17 169.3,44.44 167.68,44.44 167.24,44.01 165.01,44.01 163.77,45.24 159.34,45.24 159.06,45.52 v7(154.99,45.52) 154.79,45.71 146.35,45.71 145.03,47.03 143.91,47.03 142.41,48.53 140.94,48.53 140.32,49.15 v7(140.32,51.04)
  BOTTOM w0.254: v7(152.76,82.21) 152.76,81.14 152.99,80.91 v1(152.99,78.96) 153.52,78.42 153.52,76.02 153.14,75.64 153.14,73.93 151.95,72.73 151.95,71.63 153.02,70.57 153.02,69.51 153.31,69.22 153.31,66.1 154.39,65.02 154.39,60.38 158.17,56.59 158.17,54.16 158.83,53.51 158.83,52.6 158.02,51.79 158.02,48.2 155.34,45.52 v7(154.99,45.52)
EC_CRY2: length 5.8
  TOP w0.122: R253.2 139.92,65.69 139.92,64.76 R607.2 140.43,64.26 C654.1 140.63,63.61 140.63,63.6 140.54,63.51 140.54,63.11 140.66,62.99 140.66,62.51 140.92,62.24 U34.K1
EC_ENVDD: length 26.8
  TOP w0.122: D93.3 166.68,64.53 v1(166.68,63.14) v7(166.68,62.24)
  TOP w0.203: v2(146.13,58.04) 145.87,58.04 145.43,57.6 U34.A10
  GND1 w0.203: v3(146.67,58.05) 146.66,58.04 v2(146.13,58.04)
  IN1 w0.203: v3(146.67,58.05) 146.92,58.3 147.7,58.3 148.49,59.09 150.02,59.09 v4(151.04,60.11)
  IN2 w0.203: v7(166.68,62.24) 166.68,62.24 166.21,61.77 164.19,61.77 162.8,60.38 156.94,60.38 155.62,61.69 153.6,61.69 152.04,60.13 151.06,60.13 v4(151.04,60.11)
EC_INV_PWM: length 45.5
  TOP w0.076: v11(140.66,58.36) 140.91,58.6 U34.K8
  TOP w0.122: v2(166.86,69.91) v1(166.86,71.34) 166.86,72.46 165.49,73.84 163.77,73.84 162.97,74.64 D73.2
  GND1 w0.104: v3(167.41,69.56) 167.05,69.91 v2(166.86,69.91) ; v3(141.18,58.86) 140.67,58.36 v11(140.66,58.36)
  IN1 w0.071: v3(167.41,69.56) v4(167.41,67.39) ; v3(141.18,58.86) 141.26,58.79 142.39,58.79 142.51,58.67 144.36,58.67 145.38,57.65 146.12,57.65 146.23,57.76 146.93,57.76 147.23,58.05 147.78,58.05 148.58,58.85 150.31,58.85 151.53,60.07 151.53,61.37 v4(151.82,61.66)
  IN2 w0.094: v4(167.41,67.39) 167.41,64.97 165.52,63.08 163.81,63.08 162.38,61.64 158.38,61.64 157.73,62.29 156.43,62.29 156.19,62.53 152.7,62.53 v4(151.82,61.66)
EC_LID_OUT#: length 32.2
  TOP w0.122: v2(143.87,62.71) 143.92,62.66 U34.D1 ; v2(122.41,52.87) 122.17,52.63 122.17,52.51 121.89,52.24 v1(121.09,52.24) 120.54,52.24 120.34,52.44 120.34,53.28 119.87,53.75 RH336.2
  GND1 w0.104: v3(143.24,62.88) 143.71,62.88 v2(143.87,62.71) ; v2(122.41,52.87) v3(122.41,53.33)
  IN1 w0.071: v4(136.86,62.39) 136.72,62.24 135.61,62.24 134.57,61.2 133.94,61.2 132.55,59.8 132.09,59.8 131.39,59.11 131.39,58.98 127.67,55.27 125.74,55.27 123.8,53.33 v3(122.41,53.33) ; v3(143.24,62.88) 143.24,62.88 v4(143.24,63.39)
  IN2 w0.094: v4(143.24,63.39) 142.83,63.8 137.44,63.8 136.95,63.31 136.95,62.48 v4(136.86,62.39)
EC_ON: length 60.1
  TOP w0.122: v2(145.5,64.68) 145.07,64.26 C1117.1 144.77,64.26 144.28,63.77 143.86,63.77 143.64,63.55 143.34,63.55 142.93,63.14 142.52,63.14 142.39,63 142.39,62.69 142.51,62.57 142.51,62.31 142.42,62.21 U34.G1 ; PR969.1 183.06,70.97 184.18,72.09 184.18,74.09 183.24,75.03 v7(183.24,75.37) 183.24,75.65 PR938.1
  GND1 w0.104: v2(145.5,64.68) v3(145.5,65.19)
  IN1 w0.071: v4(146.06,65.21) 146.03,65.19 v3(145.5,65.19)
  IN2 w0.094: v4(146.06,65.21) 146.38,64.89 147.05,64.89 148.92,63.03 149.8,63.03 149.91,62.92 155.88,62.92 156.2,63.24 157.48,63.24 158.02,63.78 158.47,63.78 159.05,63.19 161.71,63.19 161.86,63.04 163.43,63.04 163.67,63.28 165.44,63.28 167.03,64.87 167.03,67.56 168.05,68.58 168.05,68.95 172.98,73.88 181.74,73.88 v7(183.24,75.37)
  BOTTOM w0.122: v9(183.6,76.76) 183.24,76.4 v7(183.24,75.37)
EC_ON_CTRL#: length 26.1
  TOP w0.076: U34.G5 142.42,59.96 v2(142.62,59.77)
  TOP w0.122: v2(133.79,58.92) D85.2 133.79,57.19 v1(134.2,56.78) ; v2(150.73,61.68) 150.93,61.68 151.47,61.14 C1118.1 R936.1 152.46,61.63 151.98,62.11 D84.2
  GND1 w0.104: v2(150.73,61.68) 150.48,61.94 v3(150.35,61.94) ; v3(142.65,60.2) 142.62,60.16 v2(142.62,59.77) ; v3(134.17,59.27) 134.14,59.27 133.83,58.96 133.83,58.96 v2(133.79,58.92)
  IN1 w0.071: v3(150.35,61.94) 149.71,61.3 148.9,61.3 148.74,61.14 148.05,61.14 147.66,60.75 146.75,60.75 146.56,60.57 145.78,60.57 145.46,60.24 144.96,60.24 144.86,60.34 142.79,60.34 v3(142.65,60.2) 142.49,60.2 142.11,59.82 141.88,59.82 141.69,59.63 141.28,59.63 141.12,59.46 140.62,59.46 140.25,59.09 139.95,59.09 139.51,58.65 138.96,58.65 138.61,58.31 v4(138.25,58.31) ; v3(134.17,59.27) 134.91,59.27 v4(134.93,59.25)
  IN2 w0.094: v4(138.25,58.31) 137.98,58.31 137.55,58.73 136.72,58.73 136.06,59.4 135.08,59.4 v4(134.93,59.25)
EC_PECI: length 10
  TOP w0.076: 141.67,63.08 141.67,62.21 141.67,62.21 141.67,61.85 U34.H2
  TOP w0.122: R240.1 139.25,68.03 139.76,67.53 140.84,67.53 141.09,67.27 141.09,66.83 141.54,66.38 142.42,66.38 142.87,65.94 142.87,64.07 142.62,63.81 142.24,63.81 v1(141.76,63.34) 141.67,63.24 141.67,63.08
EC_RST#: length 3.8
  TOP w0.122: U34.K13 140.92,55.94 140.75,55.77 140.75,55.46 140.46,55.17 140.04,55.17 v1(139.81,54.94) 139.44,54.57 139.44,54.19 C285.1 R221.1
EC_RX: length 57.1
  TOP w0.122: U34.K9 v3(140.69,57.87) v2(140.24,57.87) ; v1(180.4,53.81) 180.4,53.47 180.22,53.29 R729.1 179.77,52.81 179.46,52.49 179.46,47.99 179.01,47.54 178.47,47.54 v7(178.34,47.41)
  GND1 w0.104: v2(140.24,57.87) v3(140.69,57.87)
  IN1 w0.071: v3(140.69,57.87) 140.7,57.87 140.92,58.1 v4(140.92,58.4)
  IN2 w0.094: v7(178.34,47.41) 178.21,47.54 178.21,48.01 177.57,48.65 177.57,50.27 174.9,52.94 169.85,52.94 168.98,52.07 166.82,52.07 166.2,51.45 163.19,51.45 162.42,50.68 158.98,50.68 157.63,49.33 149.23,49.33 147.58,50.97 147.58,53.08 143.57,57.1 142.22,57.1 v4(140.92,58.4)
EC_RX_R: length 6.7
  TOP w0.122: v1(182.18,51.98) 182.12,51.92 R731.2 ; v7(180.91,48.98) 180.72,49.17 180.72,51.51 R731.2 ; R731.2 R729.2
  BOTTOM w0.122: v7(180.91,48.98) 180.05,48.13 JWLAN1.51
EC_SCI#: length 41.1
  TOP w0.122: v7(138.18,67.86) 137.82,67.86 135.27,65.31 135.27,64.36 135,64.08 135,61.77 134.94,61.72 v1(134.94,61.38) 134.94,59.92 135.74,59.12 136.83,59.12 R218.2 137.66,58.98 137.66,59.01 137.96,59.31 138.98,59.31 139.28,59.6 U34.N6
  IN2 w0.094: v4(128.89,71.44) 129,71.32 132.54,71.32 136.01,67.86 v7(138.18,67.86)
  IN4 w0.071: v4(128.89,71.44) 128.81,71.36 128.79,71.36 v5(128.48,71.06)
  GND5 w0.104: v6(128.33,71.46) 128.48,71.31 v5(128.48,71.06)
  BOTTOM w0.122: v6(128.33,71.46) 128.33,72.42 125.8,74.94 124.52,74.94 124.19,74.61 122.03,74.61 121.58,75.06 119.8,75.06 119.71,75.15 119.06,75.15 118.08,74.17 UH1.A45
EC_SMB_CK1: length 130
  TOP w0.122: R229.1 147.2,56.17 147.2,56.76 146.9,57.06 146.9,57.56 v2(146.83,57.63) 146.7,57.76 146.7,58.35 146.46,58.59 145.44,58.59 U34.A8 ; PR913.2 v7(125.99,26.56)
  GND1 w0.104: v3(147.24,57.32) 147.13,57.32 v2(146.83,57.63)
  IN1 w0.071: v7(125.99,26.56) 127.44,25.11 133.62,25.11 134.35,24.38 138.94,24.38 139.6,25.04 142.11,25.04 142.45,25.38 143.51,25.38 144.96,26.83 148.49,26.83 v7(148.9,27.24) 149.31,27.65 149.86,27.65 150.1,27.41 150.1,27.06 150.3,26.86 151.57,26.86 152.04,27.34 165.59,27.34 166.07,26.86 173.5,26.86 176.07,29.43 176.07,30.15 177.69,31.77 177.69,32.37 177.57,32.49 177.57,33.45 178.93,34.81 178.93,35.87 178.23,36.57 178.23,38.25 177.89,38.58 177.89,45.35 177.11,46.14 177.11,50.27 174.78,52.6 172.29,52.6 172.06,52.82 170.13,52.82 168.98,53.98 167.1,53.98 164.62,56.46 163.38,56.46 163.18,56.67 152.12,56.67 151.41,57.38 149.74,57.38 149.45,57.67 149.14,57.67 148.99,57.82 148.11,57.82 147.96,57.67 147.59,57.67 v3(147.24,57.32)
  BOTTOM w0.122: v7(148.9,27.24) 148.9,28.78 149.87,29.74 149.87,30.95 v1(150.44,31.53) 152.4,31.53 154.1,33.22 154.1,34.18 153.93,34.35 PR956.2
EC_SMB_DA1: length 126.4
  TOP w0.122: v2(148.12,58.03) 148.12,57.95 R230.1 147.5,57.65 147.5,57.85 147.2,58.16 147.2,58.59 146.54,59.25 146.3,59.25 146.29,59.24 146.21,59.24 146.07,59.1 U34.A7 ; PR917.2 v2(127.95,22.03)
  GND1 w0.104: v2(148.12,58.03) 148.48,58.03 v3(148.56,58.12) ; v2(127.95,22.03) v3(127.95,21.6)
  IN1 w0.071: v3(127.95,21.6) v4(129.22,22.87) ; v4(132.16,24.63) 132.6,24.19 139.02,24.19 139.68,24.85 142.19,24.85 142.53,25.2 143.59,25.2 145,26.61 149.05,26.61 v7(149.69,27.24) 149.69,27.19 150.2,26.68 151.64,26.68 152.12,27.16 165.51,27.16 166.7,25.97 168.64,25.97 169.32,26.65 173.55,26.65 176.25,29.35 176.25,29.84 179.35,32.93 179.35,33.96 179.69,34.3 179.69,38.16 179.43,38.42 179.43,48.21 174.85,52.78 172.37,52.78 172.15,53 170.22,53 169.05,54.16 167.16,54.16 164.69,56.63 163.45,56.63 163.25,56.84 152.19,56.84 150.58,58.46 148.9,58.46 v3(148.56,58.12)
  IN4 w0.071: v4(132.16,24.63) 131.55,24.63 131.35,24.42 130.77,24.42 v4(129.22,22.87)
  BOTTOM w0.122: PR955.2 154.18,35.66 154.18,34.45 154.35,34.28 154.35,33.12 152.37,31.14 151.63,31.14 149.89,29.4 v1(149.89,28.21) 149.89,27.44 v7(149.69,27.24)
