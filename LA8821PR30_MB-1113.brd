# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA1: length 170.1
  TOP w0.076: UD8.L7 75.49,25.4 74.7,24.62 74.6,24.51 74.04,24.51 v10(73.63,24.11) ; UD4.L7 97.58,25.4 96.8,24.62 96.7,24.51 96.14,24.51 v10(95.73,24.11) ; v10(84.68,24.11) 85.09,24.51 85.65,24.51 85.75,24.62 86.53,25.4 UD6.L7 ; v10(106.78,24.11) 107.19,24.51 107.75,24.51 107.85,24.62 108.63,25.4 UD2.L7
  TOP w0.16: v2(118.43,26.78) 118.42,26.77 R1048.1
  GND1 w0.102: v2(118.43,26.78) v3(118.43,27.24)
  IN1 w0.127: v3(118.43,27.24) 118.41,27.27 118.17,27.27 v4(117.91,27.01)
  IN3 w0.122: v4(73.21,41.47) 73.29,41.39 73.29,41.21 73.2,41.13 72.73,41.13 72.6,41.26 72.6,41.62 72.88,41.9 72.88,42.18 72.6,42.46 72.6,45.89 72.73,46.01 75.52,46.01 75.65,46.14 75.65,46.95 75.53,47.08 72.75,47.08 72.63,47.2 72.63,49.58 72.75,49.7 73.57,49.7 73.69,49.82 73.69,50.07 73.57,50.19 72.75,50.19 72.63,50.31 72.63,50.58 72.75,50.71 74.05,50.71 74.18,50.58 74.18,50.23 74.33,50.08 74.68,50.08 74.81,50.2 74.81,50.53 74.99,50.71 74.99,50.93 74.81,51.11 74.81,51.52 74.52,51.8 73.79,51.8 73.67,51.93 73.67,52.62 73.54,52.74 73.01,52.74 72.85,52.9 72.85,53.48 72.03,54.29 71.34,54.29 71.09,54.55 69.57,54.55 69.44,54.42 68.99,54.42 68.87,54.55 68.47,54.55 68.34,54.42 67.06,54.42 66.94,54.55 66.71,54.55 66.59,54.42 66.02,54.42 65.84,54.6 65.84,57.26 65.97,57.39 65.97,58.3 65.9,58.36 65.9,58.85 65.75,59.01 65.75,59.4 65.62,59.52 65.11,59.52 64.98,59.4 64.98,59.23 v4(65.2,59.01)
  IN4 w0.091: v4(65.2,59.01) 65.2,59.29 v5(65.02,59.46) ; v4(117.91,27.01) 117.61,26.71 113.36,26.71 110.87,24.22 109.86,24.22 109.32,23.68 106.93,23.68 106.78,23.83 106.78,24.06 106.78,24.06 v10(106.78,24.11) 106.32,24.11 104.58,22.37 104.58,22.06 104.47,21.95 100.68,21.95 100.56,22.08 100.56,22.29 100.43,22.42 100.17,22.42 100.05,22.29 100.05,22.08 99.92,21.95 99.67,21.95 99.54,22.08 99.54,22.33 99.41,22.46 99.16,22.46 99.03,22.33 99.03,22.08 98.9,21.95 98.65,21.95 98.52,22.08 98.52,22.33 98.4,22.46 98.14,22.46 98.02,22.33 98.02,22.08 97.89,21.95 97.61,21.95 97.25,22.31 97.25,23.5 97.07,23.68 95.88,23.68 95.73,23.83 95.73,24.06 v10(95.73,24.11) 95.27,24.11 93.74,22.57 93.74,20.03 93.61,19.9 93.15,19.9 93.02,20.03 93.02,20.69 92.89,20.82 92.29,20.82 92.16,20.69 92.16,19.6 92.03,19.47 90.89,19.47 90.76,19.6 90.76,20.69 90.63,20.82 90,20.82 89.87,20.69 89.87,20.49 89.35,19.97 88.53,19.97 88.39,20.1 87.31,20.1 87.19,20.23 87.19,21.32 86.2,22.31 86.2,23.44 85.96,23.68 84.83,23.68 84.68,23.83 84.68,24.06 84.68,24.06 v10(84.68,24.11) 84.22,24.11 82.48,22.37 82.48,22.06 82.37,21.95 78.58,21.95 78.46,22.08 78.46,22.29 78.33,22.42 78.08,22.42 77.95,22.29 77.95,22.08 77.82,21.95 77.57,21.95 77.44,22.08 77.44,22.33 77.31,22.46 77.06,22.46 76.93,22.33 76.93,22.08 76.81,21.95 76.55,21.95 76.43,22.08 76.43,22.33 76.3,22.46 76.04,22.46 75.92,22.33 75.92,22.08 75.79,21.95 75.51,21.95 75.15,22.31 75.15,23.45 74.92,23.68 73.78,23.68 73.63,23.83 73.63,24.06 v10(73.63,24.11) 73.34,24.11 73.21,23.98 73.21,23.61 73.08,23.48 72.83,23.48 72.7,23.61 72.7,23.98 72.57,24.11 72.36,24.11 71.19,22.94 67.39,22.94 64.45,25.89 64.45,31.82 64.57,31.95 64.85,31.95 64.98,32.08 64.98,32.33 64.85,32.46 64.57,32.46 64.45,32.58 64.45,32.84 64.57,32.96 64.85,32.96 64.98,33.09 64.98,33.35 64.85,33.47 64.57,33.47 64.45,33.6 64.45,33.88 64.92,34.35 64.92,35.49 65.06,35.62 65.74,35.62 65.87,35.75 65.87,35.83 65.91,35.88 65.91,36.23 65.87,36.27 65.87,36.61 66.05,36.79 66.05,37 66.1,37.05 66.1,39.38 66.45,39.73 66.85,39.73 66.95,39.83 67.6,39.83 67.68,39.75 68.02,39.75 68.27,40 68.27,40 68.56,40.3 68.56,40.83 68.43,40.96 68.31,40.96 68.18,41.09 68.18,41.59 68.31,41.72 68.51,41.72 68.84,41.39 69.18,41.39 69.51,41.72 70.7,41.72 70.82,41.59 70.82,40.78 70.95,40.65 71.2,40.65 71.33,40.78 71.33,41.59 71.46,41.72 71.71,41.72 71.84,41.59 71.84,40.78 71.97,40.65 72.22,40.65 72.35,40.78 72.35,41.59 72.47,41.72 73.08,41.72 73.21,41.59 v4(73.21,41.47)
  GND5 w0.102: v5(65.02,59.46) v6(65.44,59.46)
  BOTTOM w0.076: v10(73.63,24.11) 73.56,24.03 73.35,24.03 72.39,25 72.23,25 72.11,25.12 72.11,25.28 72.23,25.4 72.32,25.4 UD7.L7 ; v10(106.78,24.11) 106.7,24.03 106.5,24.03 105.53,25 105.37,25 105.25,25.12 105.25,25.28 105.37,25.4 UD1.L7 ; v10(84.68,24.11) 84.6,24.03 84.4,24.03 83.43,25 83.27,25 83.16,25.12 83.16,25.28 83.27,25.4 UD5.L7 ; UD3.L7 94.42,25.4 94.32,25.4 94.21,25.28 94.21,25.12 94.32,25 94.48,25 95.45,24.03 95.65,24.03 v10(95.73,24.11)
  BOTTOM w0.16: UCPU1.BB34 v6(65.44,59.46)
DDR_A_MA2: length 173.7
  TOP w0.076: v10(106.25,25.33) 106.25,25.1 106.4,24.95 106.64,24.95 106.83,24.76 106.83,24.57 106.75,24.49 106.41,24.49 105.81,25.09 105.81,25.27 105.69,25.4 105.47,25.4 UD2.L3 ; v10(84.15,25.33) 84.15,25.1 84.3,24.95 84.54,24.95 84.73,24.76 84.73,24.57 84.66,24.49 84.31,24.49 83.72,25.09 83.72,25.27 83.59,25.4 83.37,25.4 UD6.L3 ; v10(95.2,25.33) 95.2,25.1 95.35,24.95 95.59,24.95 95.78,24.76 95.78,24.57 95.7,24.49 95.36,24.49 94.76,25.09 94.76,25.27 94.64,25.4 94.42,25.4 UD4.L3 ; v10(73.1,25.33) 73.1,25.1 73.25,24.95 73.49,24.95 73.68,24.76 73.68,24.57 73.61,24.49 73.27,24.49 72.67,25.09 72.67,25.27 72.54,25.4 72.32,25.4 UD8.L3
  TOP w0.16: R1046.1 118.55,28.04 118.09,27.58 v2(118.09,27.55)
  GND1 w0.102: v3(117.74,27.93) 118.09,27.57 v2(118.09,27.55)
  IN1 w0.127: v3(117.74,27.93) v4(117.25,28.41)
  IN3 w0.122: v4(73.72,40.55) 73.82,40.55 73.93,40.66 73.93,41.12 73.72,41.32 73.72,41.73 72.87,42.57 72.87,45.58 73,45.71 73.28,45.71 73.4,45.59 73.4,44.84 73.52,44.72 73.76,44.72 73.89,44.84 73.89,45.59 74.01,45.71 74.25,45.71 74.37,45.59 74.37,44.84 74.5,44.72 74.69,44.72 74.86,44.89 74.86,45.59 74.98,45.71 75.68,45.71 75.92,45.95 75.92,47.32 75.85,47.39 73.06,47.39 72.93,47.52 72.93,49.3 73.06,49.43 73.69,49.43 73.97,49.15 73.97,48.58 74.09,48.46 74.38,48.46 74.51,48.58 74.51,49.4 74.75,49.64 74.91,49.64 75.01,49.54 75.25,49.54 75.58,49.21 75.78,49.21 75.92,49.36 75.92,49.92 75.8,50.05 75.24,50.05 75.11,50.18 75.11,50.41 75.24,50.53 75.8,50.53 75.92,50.66 75.92,50.79 75.62,51.09 75.21,51.09 75.08,51.22 75.08,51.63 74.64,52.08 74.07,52.08 73.94,52.21 73.94,52.73 73.65,53.02 73.29,53.02 73.12,53.19 73.12,53.59 71.89,54.82 71.74,54.82 71.56,54.65 71.37,54.65 71.2,54.82 68.35,54.82 68.23,54.69 67.88,54.69 67.75,54.82 67.54,54.82 67.41,54.69 67.2,54.69 67.09,54.8 67.09,55.18 66.83,55.44 66.71,55.44 66.61,55.33 66.61,54.83 66.48,54.7 66.24,54.7 66.12,54.83 66.12,56.91 v4(66.3,57.09)
  IN4 w0.091: v4(66.3,57.09) 65.92,57.09 v5(65.82,57.19) ; v4(117.25,28.41) 113.08,28.41 111.25,26.58 110.88,26.58 109.12,24.82 106.68,24.82 106.25,25.25 v10(106.25,25.33) 105.93,25.33 105.8,25.2 105.8,24.64 105.67,24.51 105.18,24.51 105.03,24.36 105.03,23.7 104.57,23.24 100.81,23.24 100.76,23.3 100.76,23.63 100.53,23.85 99.36,23.85 99.18,23.68 99.18,23.32 99.08,23.22 98.04,23.22 97.91,23.35 97.91,24.57 97.79,24.69 97.43,24.69 97.3,24.57 97.3,24.44 97.18,24.31 96.85,24.31 96.72,24.44 96.66,24.44 96.26,24.84 95.3,24.84 95.2,24.95 v10(95.2,25.33) 94.38,24.51 94.15,24.51 93.98,24.34 93.98,23.7 92.96,22.69 92.96,21.52 92.83,21.39 92.58,21.39 92.45,21.52 92.45,22.24 92.33,22.36 92.07,22.36 91.94,22.24 91.94,21.52 91.82,21.39 91.56,21.39 91.44,21.52 91.44,22.36 91.31,22.48 91.06,22.48 90.93,22.36 90.93,21.52 90.8,21.39 89.37,21.39 88.66,22.1 87.32,22.1 86.86,22.56 86.86,24.57 86.74,24.69 86.38,24.69 86.26,24.57 86.26,24.44 86.13,24.31 85.72,24.31 85.18,24.84 84.25,24.84 84.15,24.95 v10(84.15,25.33) 83.83,25.33 83.7,25.2 83.7,24.64 83.57,24.51 83.08,24.51 82.93,24.36 82.93,23.7 82.47,23.24 78.71,23.24 78.66,23.3 78.66,23.63 78.43,23.85 77.26,23.85 77.09,23.68 77.09,23.32 76.98,23.22 75.94,23.22 75.82,23.35 75.82,24.57 75.69,24.69 75.33,24.69 75.21,24.57 75.21,24.44 75.08,24.31 74.75,24.31 74.62,24.44 74.62,24.44 74.21,24.84 73.2,24.84 73.1,24.95 v10(73.1,25.33) 72.74,25.33 70.91,23.5 69.7,23.5 69.58,23.63 69.58,24.42 69.45,24.55 69.2,24.55 69.07,24.42 69.07,23.63 68.94,23.51 68.69,23.51 68.56,23.63 68.56,24.42 68.43,24.55 68.36,24.55 68.36,24.55 68.18,24.55 68.05,24.42 68.05,23.63 67.93,23.5 67.63,23.5 67.09,24.04 67.09,24.28 67.58,24.77 67.58,24.95 67.38,25.15 67.2,25.15 66.83,24.78 66.61,24.78 66.44,24.94 66.44,25.2 66.8,25.56 66.8,25.88 66.02,26.66 65.46,26.66 65.34,26.78 65.34,31.31 66.22,32.19 66.22,35.09 67.62,36.49 67.62,36.87 67.62,37.33 67.92,37.63 67.92,38.33 68.66,39.07 68.84,39.07 68.97,39.2 68.97,39.48 69.26,39.77 70.41,39.77 70.57,39.61 70.57,39.46 70.7,39.33 70.95,39.33 71.07,39.46 71.07,39.94 71.2,40.07 71.45,40.07 71.58,39.94 71.58,39.46 71.71,39.33 71.96,39.33 72.09,39.46 72.09,39.94 72.22,40.07 72.47,40.07 72.6,39.94 72.6,39.46 72.72,39.33 73.02,39.33 73.14,39.46 73.16,39.46 73.16,40.42 73.34,40.6 73.67,40.6 v4(73.72,40.55)
  GND5 w0.102: v5(65.82,57.19) 65.92,57.29 v6(65.92,57.58)
  BOTTOM w0.076: UD3.L3 97.01,24.79 95.47,24.79 95.2,25.07 v10(95.2,25.33) ; UD7.L3 74.91,24.79 73.37,24.79 73.1,25.07 v10(73.1,25.33) ; v10(106.25,25.33) 106.25,25.07 106.52,24.79 108.06,24.79 UD1.L3 ; v10(84.15,25.33) 84.15,25.07 84.42,24.79 85.96,24.79 UD5.L3
  BOTTOM w0.16: UCPU1.BE35 65.61,57.89 v6(65.92,57.58)
DDR_A_MA3: length 172.8
  TOP w0.076: UD6.K2 82.57,26.2 82.89,26.2 83.36,25.73 85.19,25.73 85.42,25.5 v10(85.42,25.25) ; v10(107.52,25.25) 107.52,25.5 107.29,25.73 105.46,25.73 104.99,26.2 104.67,26.2 UD2.K2 ; v10(96.47,25.25) 96.47,25.5 96.24,25.73 94.41,25.73 93.94,26.2 93.62,26.2 UD4.K2 ; v10(74.37,25.25) 74.37,25.5 74.14,25.73 72.31,25.73 71.84,26.2 71.52,26.2 UD8.K2
  TOP w0.16: R1052.1 v2(114.1,28)
  GND1 w0.102: v2(114.1,28) 114.13,28.03 v3(114.54,28.03)
  IN1 w0.127: v4(114.15,27.57) 114.54,27.95 v3(114.54,28.03)
  IN2 w0.122: v4(69.28,34.09) 68.38,33.2 68.38,32.92 68.51,32.8 68.67,32.8 68.8,32.68 68.8,32.44 68.67,32.31 68.51,32.31 68.38,32.19 68.38,31.95 68.51,31.83 68.67,31.83 68.8,31.71 68.8,31.46 68.67,31.34 68.51,31.34 68.38,31.22 68.38,30.97 68.51,30.85 68.67,30.85 68.8,30.73 68.8,30.49 68.67,30.36 68.51,30.36 68.38,30.24 68.38,27.27 69.86,25.79 70.72,25.79 70.95,26.02 71.46,26.02 71.58,25.9 71.58,25.62 71.71,25.49 72.52,25.49 72.65,25.36 72.65,25.08 72.52,24.96 72.02,24.96 71.89,24.83 71.89,24.45 72.02,24.32 72.73,24.32 73.3,24.9 74.01,24.9 v10(74.37,25.25) 74.95,25.25 75.08,25.13 75.08,24.53 75.2,24.41 75.44,24.41 75.56,24.53 75.56,25.13 75.68,25.25 76.96,25.25 77.04,25.17 77.04,24.64 77.19,24.49 78,24.49 78.13,24.62 78.13,25.2 78.84,25.91 79.14,25.91 79.26,25.79 79.26,25.15 79.39,25.02 79.62,25.02 79.75,25.15 79.75,25.63 79.88,25.76 80.19,25.76 80.36,25.58 83.21,25.58 83.89,24.9 85.06,24.9 v10(85.42,25.25) 86,25.25 86.12,25.13 86.12,24.53 86.25,24.41 86.49,24.41 86.61,24.53 86.61,25.13 86.73,25.25 88.01,25.25 88.08,25.17 88.08,24.46 88.21,24.33 88.86,24.33 88.98,24.46 88.98,25.28 89.11,25.4 89.31,25.4 89.44,25.28 89.44,24.55 89.57,24.42 89.8,24.42 89.92,24.55 89.92,26.05 90.05,26.17 92.89,26.17 93.02,26.3 93.02,26.81 93.15,26.94 93.5,26.94 93.63,26.81 93.63,24.71 93.76,24.58 94.05,24.58 94.18,24.71 94.18,25.43 94.31,25.56 94.59,25.56 94.71,25.43 94.71,25.02 94.84,24.9 96.11,24.9 v10(96.47,25.25) 97.05,25.25 97.17,25.13 97.17,24.53 97.3,24.41 97.54,24.41 97.66,24.53 97.66,25.13 97.78,25.25 99.06,25.25 99.13,25.17 99.13,24.64 99.29,24.49 100.1,24.49 100.23,24.62 100.23,25.2 100.94,25.91 101.24,25.91 101.36,25.79 101.36,25.15 101.49,25.02 101.72,25.02 101.85,25.15 101.85,25.63 101.97,25.76 102.29,25.76 102.46,25.58 105.31,25.58 105.99,24.9 107.16,24.9 v10(107.52,25.25) 108.39,24.38 110.63,24.38 112.17,25.93 112.17,26.38 113.06,27.26 113.84,27.26 v4(114.15,27.57)
  IN3 w0.122: v4(69.28,34.09) 69.17,34.2 69.17,34.4 70.28,35.52 70.28,35.87 70.44,36.03 71.48,36.03 72.54,37.1 72.54,37.55 72.54,38.29 72.67,38.42 72.94,38.42 73.07,38.29 73.07,37.83 73.19,37.71 73.43,37.71 73.55,37.83 73.55,38.29 73.68,38.42 74.23,38.42 74.35,38.54 74.35,38.78 74.23,38.9 72.68,38.9 72.55,39.03 72.55,39.26 72.68,39.39 73.16,39.39 73.29,39.51 73.29,39.76 73.16,39.88 72.7,39.88 72.57,40.01 72.57,40.24 72.7,40.37 73.16,40.37 73.29,40.49 73.29,40.73 73.16,40.85 72.43,40.85 72.33,40.96 72.33,41.73 72.52,41.93 72.52,42.14 72.33,42.34 72.33,46.2 72.42,46.29 75.19,46.29 75.32,46.42 75.32,46.65 75.19,46.78 72.42,46.78 72.33,46.88 72.33,50.89 72.43,50.99 74.4,50.99 74.53,51.12 74.53,51.35 74.4,51.48 72.47,51.48 72.35,51.61 72.35,51.84 72.47,51.97 73.26,51.97 73.39,52.09 73.39,52.34 73.26,52.46 71.86,52.46 71.74,52.59 71.74,52.84 71.86,52.97 72.45,52.97 72.57,53.1 72.57,53.36 71.95,53.99 71.76,53.99 71.64,53.86 71.64,53.58 71.51,53.45 71.23,53.45 71.1,53.58 71.1,54.14 70.97,54.27 70.69,54.27 70.56,54.15 70.56,53.71 70.44,53.58 70.2,53.58 70.08,53.71 70.08,54.15 69.95,54.27 69.68,54.27 69.55,54.14 69.55,53.63 69.43,53.51 67.34,53.51 67.22,53.38 67.22,52.57 67.1,52.45 66.69,52.45 66.58,52.57 66.58,52.72 66.45,52.84 66.12,52.84 65.99,52.72 65.99,52.58 65.87,52.45 65.63,52.45 65.5,52.58 65.5,52.72 65.38,52.84 65.11,52.84 64.98,52.72 64.98,52.59 64.85,52.46 64.51,52.46 64.38,52.59 64.38,53.47 64.52,53.61 64.52,53.84 64.37,53.99 64.37,54.19 64.57,54.39 65.44,54.39 65.56,54.52 65.56,54.8 65.34,55.03 65.34,55.19 65.56,55.42 65.56,56.55 65.59,56.58 65.59,57.4 65.75,57.56 65.75,57.82 65.62,57.95 65.23,57.95 65.11,58.08 65.11,58.4 65.23,58.52 v4(65.51,58.52)
  IN4 w0.091: v5(66.02,58.61) 65.6,58.61 v4(65.51,58.52)
  GND5 w0.102: v6(65.72,58.98) 66.02,58.68 v5(66.02,58.61)
  BOTTOM w0.076: UD1.K2 109.47,26.2 109.78,26.2 109.9,26.07 109.9,25.84 109.78,25.72 107.9,25.72 107.52,25.33 v10(107.52,25.25) ; UD5.K2 87.37,26.2 87.68,26.2 87.8,26.07 87.8,25.84 87.68,25.72 85.81,25.72 85.42,25.33 v10(85.42,25.25) ; UD7.K2 76.63,26.2 76.76,26.07 76.76,25.84 76.64,25.72 74.76,25.72 74.37,25.33 v10(74.37,25.25) ; v10(96.47,25.25) 96.47,25.33 96.85,25.72 98.73,25.72 98.85,25.84 98.85,26.07 98.73,26.2 UD3.K2
  BOTTOM w0.16: UCPU1.BD35 v6(65.72,58.98)
DDR_A_MA4: length 184.8
  TOP w0.076: UD6.L8 87.54,25.4 87.65,25.51 87.65,25.67 87.54,25.78 87.14,25.78 86.94,25.58 86.94,25.04 86.83,24.93 86.44,24.93 85.62,24.11 v10(85.29,24.11) ; UD2.L8 109.64,25.4 109.75,25.51 109.75,25.67 109.64,25.78 109.24,25.78 109.04,25.58 109.04,25.04 108.93,24.93 108.54,24.93 107.72,24.11 v10(107.39,24.11) ; v10(74.24,24.11) 74.57,24.11 75.39,24.93 75.78,24.93 75.89,25.04 75.89,25.58 76.1,25.78 76.49,25.78 76.6,25.67 76.6,25.51 76.49,25.4 UD8.L8 ; v10(96.34,24.11) 96.67,24.11 97.49,24.93 97.88,24.93 97.99,25.04 97.99,25.58 98.19,25.78 98.59,25.78 98.7,25.67 98.7,25.51 98.59,25.4 UD4.L8
  TOP w0.16: R1044.1 v2(117.66,27.5)
  GND1 w0.102: v2(117.66,27.5) 117.63,27.47 v3(117.23,27.47)
  IN1 w0.127: v3(117.23,27.47) 117.23,27.6 v4(116.9,27.93)
  IN3 w0.122: v4(65.96,62.77) 65.42,62.77 65.29,62.9 65.29,63.23 65.41,63.36 66.37,63.36 66.49,63.23 66.49,61.96 66.25,61.72 66.25,59.22 66.42,59.05 66.42,58.71 67,58.13 67,57.63 67.27,57.35 67.27,56.16 67.79,55.64 72.23,55.64 76.75,51.13 76.75,49.64 77.64,48.75 77.64,47.74 77.51,47.61 76.87,47.61 76.75,47.49 76.75,47.21 76.87,47.09 79.01,47.09 79.13,46.97 79.13,46.72 79.01,46.6 76.87,46.6 76.75,46.48 76.75,45.61 75.03,43.89 74.84,43.89 74.72,43.77 74.72,43.32 74.6,43.2 74.36,43.2 74.23,43.32 74.23,43.77 74.11,43.89 73.79,43.89 73.7,43.8 73.7,42.91 74.54,42.07 74.54,41.68 74.66,41.57 v4(75.29,41.57)
  IN4 w0.091: v4(75.29,41.57) 75.17,41.69 74.87,41.69 74.74,41.57 74.74,41.28 74.99,41.03 74.99,40.78 74.74,40.53 74.74,40.25 74.5,40.02 74.35,40.02 74.23,40.14 74.23,41.59 74.1,41.72 73.77,41.72 73.64,41.59 73.64,41.1 73.51,40.97 73.11,40.97 72.94,41.15 72.69,41.15 72.63,41.08 72.63,40.47 72.5,40.35 70.49,40.35 70.39,40.45 70.39,40.78 69.93,41.24 69.43,41.24 68.94,40.75 68.94,39.99 68.82,39.87 68.74,39.87 68.13,39.26 68.13,38.95 67.7,38.52 67.25,38.52 66.98,38.79 66.64,38.79 66.38,38.53 66.38,37.12 66.95,36.55 66.95,36.22 65.94,35.2 65.94,32.33 65.6,32 65.3,32 65.03,31.73 65.03,31.45 64.9,31.32 64.85,31.32 64.73,31.2 64.73,30.94 64.85,30.82 64.9,30.82 65.03,30.69 65.03,30.44 64.9,30.31 64.85,30.31 64.73,30.18 64.73,29.93 64.85,29.8 64.9,29.8 65.03,29.67 65.03,29.42 64.9,29.29 64.85,29.29 64.73,29.17 64.73,28.91 64.85,28.78 64.9,28.78 65.03,28.66 65.03,28.4 64.9,28.28 64.85,28.28 64.73,28.15 64.73,27.9 64.85,27.77 64.9,27.77 65.03,27.64 65.03,27.39 64.9,27.26 64.85,27.26 64.73,27.13 64.73,26.88 64.85,26.75 64.9,26.75 65.03,26.63 65.03,26.38 64.9,26.25 64.85,26.25 64.73,26.12 64.73,26 65.18,25.55 65.36,25.55 65.52,25.71 65.7,25.71 65.88,25.53 65.88,25.35 65.72,25.19 65.72,25.01 66.26,24.47 66.68,24.47 66.81,24.35 66.81,23.92 67.51,23.22 68.04,23.22 68.12,23.3 68.5,23.3 68.57,23.23 69.06,23.23 69.19,23.36 69.45,23.36 69.59,23.22 71.04,23.22 72.39,24.57 72.61,24.57 72.8,24.37 73.07,24.37 73.26,24.57 74.06,24.57 74.24,24.38 v10(74.24,24.11) 74.34,24.01 75.35,24.01 75.47,23.89 75.47,23 75.56,22.91 78.71,22.91 78.81,22.81 78.81,22.46 78.94,22.33 79.24,22.33 79.37,22.46 79.37,22.84 79.5,22.96 79.75,22.96 79.88,22.84 79.88,22.46 80.01,22.33 80.24,22.33 80.36,22.46 80.36,22.84 80.49,22.96 80.74,22.96 80.87,22.84 80.87,22.43 81,22.3 81.33,22.3 81.45,22.43 81.45,22.81 81.56,22.91 82.57,22.91 84.21,24.55 84.98,24.55 85.29,24.23 v10(85.29,24.11) 85.39,24.01 86.03,24.01 86.52,23.51 86.52,22.39 87.2,21.72 87.48,21.72 87.61,21.59 87.61,20.59 87.74,20.46 88.09,20.46 88.22,20.59 88.22,21.58 88.35,21.71 88.62,21.71 88.74,21.58 88.74,20.4 88.87,20.27 89.18,20.27 89.3,20.4 89.3,20.93 89.47,21.09 90.96,21.09 91.09,20.97 91.09,19.88 91.22,19.75 91.62,19.75 91.75,19.88 91.75,20.97 91.88,21.09 93.19,21.09 93.37,21.27 93.37,22.66 95.26,24.55 96.02,24.55 96.34,24.23 v10(96.34,24.11) 96.44,24.01 97.45,24.01 97.57,23.89 97.57,23 97.66,22.91 100.8,22.91 100.91,22.81 100.91,22.46 101.04,22.33 101.34,22.33 101.47,22.46 101.47,22.84 101.6,22.96 101.85,22.96 101.98,22.84 101.98,22.46 102.1,22.33 102.33,22.33 102.46,22.46 102.46,22.84 102.59,22.96 102.84,22.96 102.97,22.84 102.97,22.43 103.1,22.3 103.43,22.3 103.55,22.43 103.55,22.81 103.65,22.91 104.67,22.91 106.3,24.54 107.08,24.54 107.39,24.23 v10(107.39,24.11) 109.27,24.11 109.68,24.52 110.78,24.52 112.17,25.92 112.17,26.94 113.37,28.13 116.69,28.13 v4(116.9,27.93) ; v5(66.3,63.16) 65.96,62.82 v4(65.96,62.77)
  GND5 w0.102: v5(66.3,63.16) 66.3,63.07 66.44,62.92 v6(66.44,62.77)
  BOTTOM w0.076: UD1.L8 104.67,25.58 104.85,25.76 105.55,25.76 105.8,25.51 105.8,25.1 106.39,24.51 106.98,24.51 v10(107.39,24.11) ; UD7.L8 71.52,25.58 71.52,25.58 71.7,25.76 72.41,25.76 72.65,25.51 72.65,25.1 73.24,24.51 73.84,24.51 v10(74.24,24.11) ; v10(85.29,24.11) 84.88,24.51 84.29,24.51 83.7,25.1 83.7,25.51 83.46,25.76 82.75,25.76 82.57,25.58 UD5.L8 ; v10(96.34,24.11) 95.93,24.51 95.34,24.51 94.75,25.1 94.75,25.51 94.5,25.76 93.8,25.76 93.62,25.58 93.62,25.58 UD3.L8
  BOTTOM w0.16: UCPU1.AT34 66.05,62.77 v6(66.44,62.77)
DDR_A_MA5: length 182.5
  TOP w0.076: UD6.L2 82.52,25.45 82.52,25.68 82.65,25.81 82.8,25.81 83,25.61 83,25.05 83.13,24.92 83.51,24.92 84.24,24.19 84.24,23.93 84.24,23.48 v10(84.48,23.24) ; UD8.L2 71.47,25.45 71.47,25.68 71.6,25.81 71.75,25.81 71.96,25.61 71.96,25.05 72.08,24.92 72.46,24.92 73.19,24.19 73.19,23.93 73.19,23.48 v10(73.43,23.24) ; UD4.L2 93.57,25.45 93.57,25.68 93.7,25.81 93.85,25.81 94.05,25.61 94.05,25.05 94.18,24.92 94.56,24.92 95.29,24.19 95.29,23.93 95.29,23.48 v10(95.53,23.24) ; UD2.L2 104.62,25.45 104.62,25.68 104.75,25.81 104.9,25.81 105.1,25.61 105.1,25.05 105.23,24.92 105.6,24.92 106.34,24.19 106.34,23.93 106.34,23.48 v10(106.58,23.24)
  TOP w0.16: R1058.1 v2(116.77,28)
  GND1 w0.102: v3(116.44,27.67) v2(116.77,28)
  IN1 w0.127: v3(116.44,27.67) v4(116.06,27.29)
  IN2 w0.122: v4(68.78,25.25) 69.63,24.4 69.63,23.93 70.21,23.35 73.33,23.35 v10(73.43,23.24) 74.29,22.38 75.34,22.38 75.46,22.26 75.46,21.92 75.59,21.8 75.82,21.8 75.95,21.92 75.95,22.35 76.08,22.48 76.31,22.48 76.44,22.35 76.44,21.97 76.56,21.85 76.8,21.85 76.93,21.97 76.93,22.26 77.05,22.38 79.07,22.38 79.19,22.51 79.19,23.02 79.32,23.14 80.41,23.14 80.57,22.98 80.57,22.51 80.69,22.38 82.55,22.38 82.67,22.51 82.67,23.22 82.8,23.35 83.08,23.35 83.2,23.47 83.2,23.63 83.32,23.75 83.56,23.75 83.68,23.63 83.68,23.47 83.81,23.35 84.38,23.35 v10(84.48,23.24) 85.18,22.54 86.16,22.54 86.3,22.67 87.03,22.67 87.15,22.55 87.15,21.5 87.28,21.37 88.07,21.37 88.2,21.5 88.2,22.41 88.32,22.54 90.63,22.54 90.76,22.67 90.76,25.21 90.89,25.34 91.32,25.34 91.45,25.21 91.45,22.67 91.57,22.54 92.13,22.54 92.26,22.41 92.26,21.53 92.39,21.4 92.62,21.4 92.74,21.53 92.74,22.41 92.87,22.54 93.27,22.54 93.5,22.77 95.32,22.77 95.53,22.97 v10(95.53,23.24) 96.39,22.38 97.44,22.38 97.56,22.26 97.56,21.92 97.69,21.8 97.92,21.8 98.05,21.92 98.05,22.35 98.18,22.48 98.41,22.48 98.54,22.35 98.54,21.97 98.66,21.85 98.9,21.85 99.02,21.97 99.02,22.26 99.15,22.38 101.17,22.38 101.29,22.51 101.29,23.02 101.42,23.14 102.5,23.14 102.66,22.98 102.66,22.51 102.79,22.38 104.64,22.38 104.77,22.51 104.77,23.22 104.9,23.35 105.17,23.35 105.3,23.47 105.3,23.63 105.42,23.75 105.66,23.75 105.78,23.63 105.78,23.47 105.9,23.35 106.47,23.35 v10(106.58,23.24) 107.44,22.38 110.61,22.38 113.04,24.8 113.04,26.02 113.45,26.44 115.21,26.44 v4(116.06,27.29)
  IN3 w0.122: v4(66.04,62.07) 65.97,62 65.97,59.1 66.16,58.92 66.16,58.59 66.77,57.97 66.77,57.51 67,57.28 67,56.05 67.68,55.37 72.12,55.37 76.47,51.02 76.47,49.53 77.36,48.63 77.36,48.02 77.24,47.89 76.6,47.89 76.47,47.76 76.47,45.72 74.91,44.16 73.5,44.16 73.42,44.08 73.42,42.8 74.27,41.95 74.27,41.55 74.48,41.34 74.48,40.23 75.52,39.18 75.52,38.06 75.37,37.91 74.02,37.91 73.55,37.43 72.98,37.43 72.82,37.27 72.82,36.98 71.58,35.75 70.92,35.75 69.7,34.53 69.7,33.93 69.58,33.8 69.58,33.8 69.45,33.68 69.32,33.68 69.1,33.45 69.1,30.06 69.92,29.24 69.92,25.97 70.05,25.84 71.76,25.84 71.89,25.72 71.89,24.45 72.02,24.32 72.42,24.32 72.65,24.55 74.65,24.55 74.77,24.43 74.77,24.06 74.89,23.94 75.13,23.94 75.26,24.06 75.26,24.43 75.38,24.55 76.72,24.55 76.84,24.42 76.84,22.42 76.72,22.29 71.97,22.29 71.84,22.42 71.84,23.01 71.71,23.14 68.99,23.14 68.87,23.26 68.87,24.1 68.74,24.22 68.26,24.22 68.13,24.35 68.13,24.59 68.26,24.71 68.74,24.71 68.87,24.83 68.87,25.16 v4(68.78,25.25)
  IN4 w0.091: v5(65.56,62.49) 65.99,62.07 v4(66.04,62.07)
  GND5 w0.102: v5(65.56,62.49) 65.56,62.44 65.55,62.44 v6(65.55,62.07)
  BOTTOM w0.076: UD3.L2 98.01,25 97.56,25 96.75,24.18 96.75,23.73 96.67,23.65 95.83,23.65 95.53,23.35 v10(95.53,23.24) ; UD5.L2 86.96,25 86.51,25 85.7,24.18 85.7,23.73 85.62,23.65 84.78,23.65 84.48,23.35 v10(84.48,23.24) ; v10(73.43,23.24) 73.43,23.35 73.73,23.65 74.57,23.65 74.65,23.73 74.65,24.18 75.46,25 75.92,25 UD7.L2 ; v10(106.58,23.24) 106.58,23.35 106.88,23.65 107.72,23.65 107.8,23.73 107.8,24.18 108.61,25 109.06,25 UD1.L2
  BOTTOM w0.16: UCPU1.AU34 v6(65.55,62.07)
DDR_A_MA6: length 189.1
  TOP w0.076: v10(85.93,21.87) 86.24,22.19 86.24,23.91 86.31,23.98 86.31,23.98 86.56,24.23 87.72,24.23 87.83,24.34 87.83,24.76 87.7,24.88 87.5,24.88 87.37,24.76 87.37,24.6 UD6.M8 ; v10(74.88,21.87) 75.19,22.19 75.19,23.91 75.26,23.98 75.26,23.98 75.51,24.23 76.67,24.23 76.78,24.34 76.78,24.76 76.65,24.88 76.45,24.88 76.32,24.76 76.32,24.6 UD8.M8 ; v10(96.97,21.87) 97.29,22.19 97.29,23.91 97.36,23.98 97.36,23.98 97.61,24.23 98.77,24.23 98.88,24.34 98.88,24.76 98.75,24.88 98.54,24.88 98.42,24.76 98.42,24.6 UD4.M8 ; UD2.M8 109.47,24.6 109.47,24.76 109.59,24.88 109.8,24.88 109.93,24.76 109.93,24.34 109.82,24.23 108.66,24.23 108.4,23.98 108.4,23.98 108.34,23.91 108.34,22.19 v10(108.02,21.87)
  TOP w0.16: R1050.1 v2(119.31,26.78)
  GND1 w0.102: v2(119.31,26.78) 118.93,26.41 v3(118.93,26.4)
  IN1 w0.127: v4(118.4,26.25) 118.78,26.25 v3(118.93,26.4)
  IN3 w0.122: v4(75.04,42.18) 75.04,42.35 75.17,42.48 75.75,42.48 75.87,42.61 75.87,43.26 75.67,43.46 75.67,43.76 77.32,45.41 77.32,45.88 77.49,46.05 79.49,46.05 79.56,45.99 80.27,45.99 80.4,46.11 80.4,46.8 80.27,46.93 79.84,46.93 79.68,47.08 79.68,47.48 79.5,47.66 78.31,47.66 78.19,47.79 78.19,48.98 77.3,49.87 77.3,51.4 72.5,56.19 72.11,56.19 69.63,56.19 69.5,56.32 69.5,56.48 69.22,56.76 68.94,56.76 68.74,56.55 68.49,56.55 68.36,56.68 68.36,57.14 68.03,57.47 68.03,58.7 67.16,59.57 v4(66.99,59.57)
  IN4 w0.091: v4(75.04,42.18) 74.86,42 67.31,42 66.71,41.4 66.71,40.78 65.82,39.89 65.82,37.17 65.72,37.07 65.72,36.99 64.64,35.92 64.64,34.47 63.96,33.79 63.96,33.61 64.3,33.27 64.3,33.09 64.12,32.91 63.94,32.91 63.6,33.25 63.42,33.25 63.24,33.07 63.24,32.89 63.85,32.28 63.85,32.1 63.67,31.92 63.49,31.92 62.88,32.53 62.7,32.53 62.27,32.09 62.27,31.43 62.39,31.31 62.6,31.31 62.85,31.56 63.1,31.56 63.23,31.43 64.07,31.43 64.17,31.33 64.17,31.05 64.04,30.92 63.15,30.92 63.02,30.8 63.02,30.54 63.15,30.42 64.04,30.42 64.17,30.29 64.17,30.04 64.04,29.91 62.97,29.91 62.85,29.78 62.85,29.53 62.97,29.4 64.04,29.4 64.17,29.27 64.17,25.77 67.28,22.66 71.61,22.66 71.74,22.79 71.74,23.05 71.86,23.18 72.14,23.18 72.27,23.05 72.27,22.79 72.4,22.66 72.67,22.66 72.75,22.75 72.75,22.86 72.87,22.97 73.12,22.97 73.24,22.86 73.24,22.79 73.36,22.66 73.67,22.66 73.84,22.82 74.18,22.82 74.34,22.66 74.75,22.66 74.88,22.53 v10(74.88,21.87) 75.82,20.93 76.24,20.93 76.37,21.06 76.37,21.31 76.49,21.44 76.75,21.44 76.87,21.31 76.87,21.06 77,20.93 77.26,20.93 77.38,21.06 77.38,21.31 77.51,21.44 77.76,21.44 77.89,21.31 77.89,21.06 78.02,20.93 78.27,20.93 78.4,21.06 78.4,21.31 78.53,21.44 78.78,21.44 78.91,21.31 78.91,21.06 79.03,20.93 79.29,20.93 79.41,21.06 79.41,21.31 79.54,21.44 79.8,21.44 79.92,21.31 79.92,21.06 80.05,20.93 80.34,20.93 80.97,21.57 82.85,21.57 83,21.72 83,22.42 83.38,22.79 85.01,22.79 v10(85.93,21.87) 85.71,21.65 85.71,21.4 85.83,21.27 86.74,21.27 86.86,21.15 86.86,19.82 86.74,19.69 85.19,19.69 85.06,19.56 85.06,19.31 85.18,19.19 93.55,19.19 94.13,19.76 94.13,22.49 94.42,22.79 96.16,22.79 96.97,21.97 v10(96.97,21.87) 97.91,20.93 98.34,20.93 98.46,21.06 98.46,21.31 98.59,21.44 98.85,21.44 98.97,21.31 98.97,21.06 99.1,20.93 99.35,20.93 99.48,21.06 99.48,21.31 99.61,21.44 99.86,21.44 99.99,21.31 99.99,21.06 100.12,20.93 100.37,20.93 100.5,21.06 100.5,21.31 100.62,21.44 100.88,21.44 101,21.31 101,21.06 101.13,20.93 101.39,20.93 101.51,21.06 101.51,21.31 101.64,21.44 101.89,21.44 102.02,21.31 102.02,21.06 102.15,20.93 102.44,20.93 103.07,21.57 104.95,21.57 105.1,21.72 105.1,22.42 105.47,22.79 107.11,22.79 v10(108.02,21.87) 108.48,21.87 110.45,23.84 110.88,23.84 113.47,26.43 117,26.43 117.18,26.25 v4(118.4,26.25) ; v4(66.99,59.57) v5(66.48,59.57)
  GND5 w0.102: v6(66.61,59.96) 66.48,59.82 v5(66.48,59.57)
  BOTTOM w0.076: UD7.M8 71.89,24.23 72.33,24.23 72.65,23.91 72.65,22.9 73,22.56 74.19,22.56 v10(74.88,21.87) ; UD1.M8 105.03,24.23 105.48,24.23 105.8,23.91 105.8,22.9 106.14,22.56 107.34,22.56 v10(108.02,21.87) ; v10(96.97,21.87) 96.29,22.56 95.09,22.56 94.75,22.9 94.75,23.91 94.43,24.23 93.98,24.23 UD3.M8 ; UD5.M8 82.93,24.23 83.38,24.23 83.7,23.91 83.7,22.9 84.05,22.56 85.24,22.56 v10(85.93,21.87)
  BOTTOM w0.16: UCPU1.BB32 66.99,59.58 v6(66.61,59.96)
DDR_A_MA7: length 195.8
  TOP w0.076: v10(73.61,21.87) 73.45,22.03 73.13,22.03 73.12,22.04 72.26,22.04 72.13,22.16 72.13,22.36 72.26,22.48 72.51,22.48 72.63,22.6 72.63,22.8 72.51,22.91 72.18,22.91 72.09,23.01 72.09,23.32 72.22,23.45 72.5,23.45 72.63,23.57 72.63,23.96 72.33,24.26 71.6,24.26 71.47,24.39 71.47,24.55 71.52,24.6 UD8.M2 ; v10(84.66,21.87) 84.5,22.03 84.18,22.03 84.17,22.04 83.3,22.04 83.18,22.16 83.18,22.36 83.3,22.48 83.56,22.48 83.68,22.6 83.68,22.8 83.56,22.91 83.23,22.91 83.14,23.01 83.14,23.32 83.27,23.45 83.55,23.45 83.68,23.57 83.68,23.96 83.38,24.26 82.65,24.26 82.52,24.39 82.52,24.55 82.57,24.6 UD6.M2 ; v10(106.75,21.87) 106.6,22.03 106.28,22.03 106.27,22.04 105.4,22.04 105.28,22.16 105.28,22.36 105.4,22.48 105.66,22.48 105.78,22.6 105.78,22.8 105.66,22.91 105.33,22.91 105.24,23.01 105.24,23.32 105.36,23.45 105.65,23.45 105.78,23.57 105.78,23.96 105.48,24.26 104.75,24.26 104.62,24.39 104.62,24.55 104.67,24.6 UD2.M2 ; v10(95.7,21.87) 95.55,22.03 95.23,22.03 95.22,22.04 94.35,22.04 94.23,22.16 94.23,22.36 94.35,22.48 94.61,22.48 94.73,22.6 94.73,22.8 94.61,22.91 94.28,22.91 94.19,23.01 94.19,23.32 94.32,23.45 94.6,23.45 94.73,23.57 94.73,23.96 94.43,24.26 93.7,24.26 93.57,24.39 93.57,24.55 93.62,24.6 UD4.M2
  TOP w0.16: R1062.1 114.66,25.95 v2(114.59,25.87)
  GND1 w0.102: v3(114.41,25.44) 114.59,25.62 v2(114.59,25.87)
  IN1 w0.127: v4(113.93,25.11) 114.08,25.11 v3(114.41,25.44)
  IN3 w0.122: v4(67.05,62.74) 67.04,62.76 67.04,63.31 66.63,63.72 66.63,64.22 66.83,64.43 67.37,64.43 67.9,63.89 68.02,63.89 68.31,63.6 68.92,63.6 69.04,63.48 69.04,62.37 68.82,62.14 66.99,62.14 66.56,61.71 66.56,59.3 66.69,59.17 66.69,58.82 67.22,58.29 67.22,57.79 67.55,57.46 67.55,56.27 67.9,55.92 72.35,55.92 77.02,51.24 77.02,49.75 77.91,48.86 77.91,47.51 78.04,47.38 79.28,47.38 79.41,47.26 79.41,46.45 79.28,46.33 77.18,46.33 77.05,46.19 77.05,45.52 77.02,45.52 77.02,45.5 75.14,43.61 75.14,43.4 75.27,43.27 75.47,43.27 75.6,43.14 75.6,42.89 75.47,42.76 75.06,42.76 74.93,42.63 74.58,42.63 v4(74.43,42.79)
  IN4 w0.091: v4(67.05,62.74) 67.05,63.07 v5(67.19,63.21) ; v4(113.93,25.11) 113.01,24.19 113.01,24.01 109.98,20.98 107.08,20.98 106.75,21.31 v10(106.75,21.87) 106.49,22.14 105.92,22.14 105.74,21.95 105.74,21.25 105.96,21.03 105.96,20.37 105.76,20.17 97.36,20.17 97.06,19.88 95.42,19.88 95.18,20.12 95.18,20.79 95.7,21.31 v10(95.7,21.87) 95.44,22.14 94.88,22.14 94.69,21.95 94.69,19.53 94.77,19.44 95.31,19.44 95.43,19.32 95.43,18.76 95.31,18.63 83.65,18.63 83.52,18.76 83.52,19.46 83.65,19.59 84.08,19.59 84.21,19.71 84.21,20.72 84.66,21.17 v10(84.66,21.87) 84.37,22.16 83.85,22.16 83.64,21.95 83.64,21.25 83.86,21.03 83.86,20.37 83.67,20.17 75.26,20.17 74.97,19.88 73.33,19.88 73.09,20.12 73.09,20.79 73.61,21.31 v10(73.61,21.87) 73.61,21.97 73.48,22.1 66.98,22.1 63.53,25.55 63.53,26.35 62.9,26.99 62.9,27.16 63.27,27.53 63.27,27.71 63.09,27.89 62.91,27.89 62.54,27.52 62.36,27.52 61.63,28.26 61.63,29.32 61.32,29.63 61.32,31.21 61.64,31.53 61.64,32.26 64.08,34.7 64.08,36.23 65.26,37.4 65.26,40.12 66.15,41.01 66.15,41.63 67.08,42.56 74.2,42.56 v4(74.43,42.79)
  GND5 w0.102: v6(66.7,63.1) 66.81,63.21 v5(67.19,63.21)
  BOTTOM w0.076: UD3.M2 97.99,24.17 97.55,24.17 97.31,23.93 97.31,23.67 97.71,23.27 97.71,21.67 97.51,21.47 96.06,21.47 95.7,21.82 v10(95.7,21.87) ; v10(73.61,21.87) 73.61,21.82 73.96,21.47 75.41,21.47 75.61,21.67 75.61,23.27 75.21,23.67 75.21,23.93 75.45,24.17 75.89,24.17 UD7.M2 ; v10(106.75,21.87) 106.75,21.82 107.11,21.47 108.56,21.47 108.76,21.67 108.76,23.27 108.35,23.67 108.35,23.93 108.6,24.17 109.04,24.17 UD1.M2 ; UD5.M2 86.94,24.17 86.5,24.17 86.26,23.93 86.26,23.67 86.66,23.27 86.66,21.67 86.46,21.47 85.01,21.47 84.66,21.82 v10(84.66,21.87)
  BOTTOM w0.16: v6(66.7,63.1) 66.99,62.8 UCPU1.AT32
DDR_A_MA8: length 189.2
  TOP w0.076: UD8.N8 76.32,23.8 76.32,23.47 76.19,23.35 76.02,23.35 75.89,23.22 75.89,22.96 76.02,22.84 76.15,22.84 76.27,22.71 76.27,22.46 76.15,22.33 76.02,22.33 75.89,22.2 75.89,21.95 76.02,21.82 76.19,21.82 76.32,21.69 76.32,21.55 76.21,21.44 76,21.44 75.89,21.33 75.89,21.19 76.02,21.06 76.15,21.06 76.27,20.93 76.27,20.6 76.15,20.48 v10(74.88,20.48) ; v10(85.93,20.48) 87.2,20.48 87.32,20.6 87.32,20.93 87.2,21.06 87.07,21.06 86.94,21.19 86.94,21.33 87.05,21.44 87.26,21.44 87.37,21.55 87.37,21.69 87.24,21.82 87.07,21.82 86.94,21.95 86.94,22.2 87.07,22.33 87.2,22.33 87.32,22.46 87.32,22.71 87.2,22.84 87.07,22.84 86.94,22.96 86.94,23.22 87.07,23.35 87.24,23.35 87.37,23.47 87.37,23.8 UD6.N8 ; UD4.N8 98.42,23.8 98.42,23.47 98.29,23.35 98.12,23.35 97.99,23.22 97.99,22.96 98.12,22.84 98.24,22.84 98.37,22.71 98.37,22.46 98.24,22.33 98.12,22.33 97.99,22.2 97.99,21.95 98.12,21.82 98.29,21.82 98.42,21.69 98.42,21.55 98.31,21.44 98.1,21.44 97.99,21.33 97.99,21.19 98.12,21.06 98.24,21.06 98.37,20.93 98.37,20.6 98.24,20.48 v10(96.97,20.48) ; UD2.N8 109.47,23.8 109.47,23.47 109.34,23.35 109.17,23.35 109.04,23.22 109.04,22.96 109.17,22.84 109.29,22.84 109.42,22.71 109.42,22.46 109.29,22.33 109.17,22.33 109.04,22.2 109.04,21.95 109.11,21.88 109.34,21.88 109.47,21.76 109.47,21.63 109.34,21.5 109.13,21.5 109.02,21.4 109.02,21.25 109.13,21.15 109.32,21.15 109.4,21.06 109.4,20.93 109.32,20.84 108.17,20.84 108.02,20.69 v10(108.02,20.48)
  TOP w0.16: v2(114.54,24.98) 114.61,25.06 R1064.1
  GND1 w0.102: v3(114.21,24.65) v2(114.54,24.98)
  IN1 w0.127: v4(113.82,24.24) 114.08,24.5 114.08,24.52 v3(114.21,24.65)
  IN2 w0.122: v4(113.82,24.24) 111.68,22.1 109.65,22.1 v10(108.02,20.48) 107.3,21.2 105.98,21.2 105.15,22.03 102.45,22.03 102.32,22.15 102.32,22.39 102.19,22.52 101.94,22.52 101.81,22.39 101.81,22.15 101.68,22.03 101.55,22.03 101.42,21.9 101.42,21.67 101.3,21.54 101.06,21.54 100.94,21.67 100.94,21.95 100.81,22.08 100.58,22.08 100.45,21.95 100.45,21.39 100.33,21.26 100.08,21.26 99.96,21.39 99.96,21.97 99.83,22.1 99.56,22.1 99.44,21.97 99.44,21.38 99.31,21.25 97.14,21.25 96.97,21.09 v10(96.97,20.48) 96.65,20.8 96.65,20.97 96.4,21.22 94.77,21.22 94.65,21.35 94.65,22.36 94.52,22.49 94.27,22.49 94.14,22.36 94.14,21.27 93.99,21.12 93.75,21.12 93.61,21.27 93.61,22.14 93.48,22.26 93.17,22.26 93.05,22.14 93.05,21.22 92.92,21.09 92.08,21.09 91.96,21.22 91.96,22.14 91.83,22.26 88.63,22.26 88.5,22.14 88.5,21.22 88.37,21.09 87,21.09 86.88,21.22 86.88,22.26 86.72,22.42 86.54,22.42 86.39,22.26 86.39,21.5 86.25,21.35 86.07,21.35 85.93,21.2 v10(85.93,20.48) 85.18,21.22 83.86,21.22 83.05,22.03 80.35,22.03 80.22,22.15 80.22,22.47 80.07,22.62 79.86,22.62 79.71,22.47 79.71,22.15 79.59,22.03 79.45,22.03 79.33,21.9 79.33,21.67 79.2,21.54 78.97,21.54 78.84,21.67 78.84,21.95 78.71,22.08 78.48,22.08 78.35,21.95 78.35,21.39 78.23,21.26 77.99,21.26 77.86,21.39 77.86,21.97 77.74,22.1 77.47,22.1 77.34,21.97 77.34,21.38 77.21,21.25 75.97,21.25 75.19,20.48 v10(74.88,20.48) 74.88,21.03 74.71,21.2 72.73,21.2 72.57,21.36 72.57,21.93 72.45,22.06 71.91,22.06 71.79,22.19 71.79,22.42 71.91,22.54 72.75,22.54 72.88,22.67 72.88,22.9 72.75,23.03 70.15,23.03 69.35,23.82 69.35,24.09 69.09,24.36 68.96,24.36 68.79,24.36 68.59,24.55 68.59,24.68 68.59,24.85 68.36,25.08 68.07,25.08 67.87,25.28 67.87,25.45 68.31,25.89 68.31,26.07 68.12,26.26 67.94,26.26 67.21,25.53 66.84,25.53 66.73,25.64 66.73,25.82 67.39,26.48 67.39,26.62 66.65,27.37 66.65,30.37 66.52,30.49 66.17,30.49 66.02,30.64 66.02,31.69 66.68,32.35 66.68,33.1 68.65,35.06 69.48,35.06 70.3,35.89 71.75,35.89 71.94,35.7 v4(71.94,35.47)
  IN3 w0.122: v4(66.97,60.63) 66.97,60.36 67.09,60.24 67.76,60.24 67.89,60.11 67.89,59.54 68.53,58.91 68.53,58.3 68.71,58.11 70.88,58.11 71.18,57.81 71.18,57.26 71.3,57.14 71.89,57.14 72.29,56.74 72.73,56.74 77.84,51.62 77.84,50.09 78.74,49.2 78.74,48.4 78.86,48.27 79.67,48.27 79.89,48.05 80.12,48.05 80.25,47.92 80.25,47.61 80.37,47.49 80.83,47.49 80.96,47.36 80.96,45.57 80.83,45.44 78.13,45.44 76.42,43.73 76.42,40.85 75.9,40.33 75.9,39.58 76.09,39.4 76.09,37.85 75.45,37.21 75.45,35.39 75.32,35.27 75.06,35.27 74.94,35.39 74.94,37.17 74.75,37.36 74.25,37.36 74.12,37.23 74.12,37.12 74.36,36.89 74.4,36.84 74.4,36.16 74.28,36.03 73.9,36.03 73.78,35.9 73.75,35.88 73.41,35.88 73.06,35.52 73.06,35.37 72.73,35.04 72.37,35.04 v4(71.94,35.47)
  IN4 w0.091: v4(66.97,60.63) 66.85,60.52 v5(66.49,60.52)
  GND5 w0.102: v6(66.49,60.94) v5(66.49,60.52)
  BOTTOM w0.076: UD5.N8 82.57,21.88 84.4,20.04 85.49,20.04 v10(85.93,20.48) ; UD1.N8 104.67,21.88 106.5,20.04 107.59,20.04 v10(108.02,20.48) ; v10(96.97,20.48) 96.54,20.04 95.45,20.04 93.62,21.88 93.62,23.8 UD3.N8 ; UD7.N8 71.52,23.8 71.52,21.88 73.35,20.04 74.44,20.04 v10(74.88,20.48)
  BOTTOM w0.16: v6(66.49,60.94) 66.62,60.81 UCPU1.AY32
DDR_A_MA9: length 183.4
  TOP w0.076: v10(107.85,23.24) 106.91,22.3 106.4,22.3 106.38,22.33 v1(106.37,22.33) 106.37,22.33 106.06,22.65 106.06,24.04 105.5,24.6 UD2.M3 ; v10(85.75,23.24) 84.81,22.3 84.3,22.3 83.96,22.65 83.96,24.04 83.4,24.6 UD6.M3 ; UD4.M3 94.45,24.6 95.01,24.04 95.01,22.65 95.35,22.3 95.86,22.3 v10(96.8,23.24) ; UD8.M3 72.35,24.6 72.91,24.04 72.91,22.65 73.25,22.3 73.76,22.3 v10(74.7,23.24)
  TOP w0.16: R1054.1 v2(114.99,28)
  GND1 w0.102: v2(114.99,28) v3(114.99,28.44)
  IN1 w0.127: v3(114.99,28.44) 114.99,27.67 v4(114.71,27.39)
  IN2 w0.122: v4(114.71,27.39) 114.31,26.99 113.19,26.99 112.48,26.28 112.48,25.77 110.82,24.11 108.71,24.11 v10(107.85,23.24) 107.85,24.31 107.61,24.54 104.52,24.54 103.41,23.43 103.06,23.43 102.92,23.57 102.92,24.36 102.69,24.59 100.78,24.59 100.66,24.46 100.66,23.88 100.53,23.75 99.39,23.75 98.88,23.24 97.94,23.24 97.82,23.37 97.82,23.93 97.69,24.05 97.46,24.05 97.33,23.93 97.33,23.37 97.21,23.24 v10(96.8,23.24) 96.8,24.31 96.56,24.54 95.43,24.54 95.13,24.25 92.95,24.25 92.82,24.12 92.82,23.22 92.69,23.09 92.13,23.09 92.01,23.22 92.01,25.77 91.88,25.9 90.32,25.9 90.2,25.77 90.2,23.67 90.2,23.66 90.2,23.21 90.08,23.09 89.81,23.09 89.68,23.21 89.68,23.55 89.48,23.75 87.93,23.75 87.8,23.88 87.8,24.79 87.68,24.92 87.4,24.92 87.27,24.79 87.27,23.37 87.14,23.24 86.89,23.24 86.77,23.37 86.77,23.96 86.65,24.08 86.4,24.08 86.28,23.96 86.28,23.37 86.16,23.24 v10(85.75,23.24) 85.75,24.31 85.51,24.54 82.43,24.54 81.32,23.43 80.96,23.43 80.82,23.57 80.82,24.36 80.59,24.59 78.69,24.59 78.56,24.46 78.56,23.88 78.43,23.75 77.29,23.75 76.78,23.24 75.84,23.24 75.72,23.37 75.72,23.93 75.59,24.05 75.36,24.05 75.23,23.93 75.23,23.37 75.11,23.24 v10(74.7,23.24) 74.7,24.31 74.46,24.54 73.43,24.54 72.88,23.99 70.87,23.99 70.75,24.12 70.75,24.45 70.87,24.57 71.46,24.57 71.58,24.7 71.58,25.11 71.24,25.45 69.71,25.45 68.08,27.09 68.08,27.94 67.87,28.15 67.87,28.43 68.08,28.64 68.08,28.92 67.87,29.12 67.87,29.41 68.08,29.61 68.08,30.07 67.96,30.19 67.83,30.19 67.71,30.31 67.71,30.55 67.83,30.68 67.96,30.68 68.08,30.8 68.08,31.04 67.96,31.16 67.83,31.16 67.71,31.29 67.71,31.53 67.83,31.65 67.96,31.65 68.08,31.77 68.08,32.02 67.96,32.14 67.83,32.14 67.71,32.26 67.71,32.5 67.83,32.63 67.96,32.63 68.08,32.75 68.08,33.54 69.05,34.51 69.71,34.51 70.37,35.17 v4(71.08,35.17)
  IN3 w0.122: v4(71.08,35.17) 71.08,35.19 71.21,35.32 71.46,35.32 71.74,35.04 71.98,35.04 72.26,34.76 73.24,34.76 73.36,34.89 73.36,35.44 73.53,35.6 73.86,35.6 73.97,35.71 74.02,35.76 74.53,35.76 74.66,35.63 74.66,35.12 74.78,34.99 76.41,34.99 76.54,35.12 76.54,35.39 76.41,35.51 75.85,35.51 75.72,35.63 75.72,35.88 75.85,36 77.1,36 77.22,36.13 77.22,36.36 77.1,36.49 75.85,36.49 75.72,36.61 75.72,36.85 75.85,36.98 76.24,36.98 76.36,37.1 76.36,39.15 76.49,39.28 77.27,39.28 77.4,39.41 77.4,39.64 77.27,39.76 76.3,39.76 76.17,39.89 76.17,40.22 76.7,40.74 76.7,43.62 77.66,44.58 78.01,44.58 78.14,44.71 78.14,45.04 78.26,45.16 78.52,45.16 78.64,45.04 78.64,44.71 78.76,44.58 78.94,44.58 79,44.58 79.13,44.71 79.13,45.04 79.25,45.16 79.49,45.16 79.61,45.04 79.61,44.14 79.74,44.01 79.97,44.01 80.1,44.13 80.1,45.04 80.22,45.16 80.53,45.16 80.65,45.04 80.65,44.21 80.78,44.08 81.1,44.08 81.23,44.21 81.23,47.47 80.94,47.76 80.61,47.76 80.52,47.85 80.52,48.04 80.23,48.32 80,48.32 79.78,48.55 79.23,48.55 79.01,48.77 79.01,49.32 78.12,50.21 78.12,51.74 72.84,57.02 72.36,57.02 71.93,57.44 71.61,57.44 71.49,57.56 71.49,57.88 71.04,58.33 68.92,58.33 68.75,58.5 68.75,59 68.16,59.59 68.16,60.36 67.96,60.57 67.58,60.57 67,61.15 v4(67,61.46)
  IN4 w0.091: v5(66.68,61.84) 66.68,61.78 v4(67,61.46)
  GND5 w0.102: v5(66.68,61.84) 66.52,61.67 v6(66.52,61.46)
  BOTTOM w0.076: v10(107.85,23.24) 107.77,23.24 107.57,23.04 107.57,22.73 108.04,22.25 108.43,22.25 108.48,22.3 108.48,23.15 108.08,23.55 108.08,24.01 UD1.M3 ; v10(96.8,23.24) 96.72,23.24 96.52,23.04 96.52,22.73 96.99,22.25 97.38,22.25 97.43,22.3 97.43,23.15 97.03,23.55 97.03,24.01 UD3.M3 ; UD5.M3 85.98,24.01 85.98,23.55 86.38,23.15 86.38,22.3 86.33,22.25 85.94,22.25 85.47,22.73 85.47,23.04 85.67,23.24 v10(85.75,23.24) ; v10(74.7,23.24) 74.62,23.24 74.42,23.04 74.42,22.73 74.89,22.25 75.28,22.25 75.33,22.3 75.33,23.15 74.93,23.55 74.93,24.01 UD7.M3
  BOTTOM w0.16: UCPU1.AV32 v6(66.52,61.46)
DDR_A_MA10: length 166.6
  TOP w0.076: UD6.H7 86.57,27.8 86.93,27.8 87.06,27.68 87.06,27.51 86.93,27.39 85.67,27.39 85.54,27.51 v10(85.54,27.63) ; UD8.H7 75.52,27.8 75.89,27.8 76.01,27.68 76.01,27.51 75.89,27.39 74.62,27.39 74.5,27.51 v10(74.5,27.63) ; v10(96.59,27.63) 96.59,27.51 96.72,27.39 97.98,27.39 98.1,27.51 98.1,27.68 97.98,27.8 97.62,27.8 UD4.H7 ; v10(107.64,27.63) 107.64,27.51 107.77,27.39 109.03,27.39 109.15,27.51 109.15,27.68 109.03,27.8 108.67,27.8 UD2.H7
  TOP w0.16: R1042.1 120.28,30.6 119.69,30.01 v2(119.64,30.01)
  GND1 w0.102: v2(119.64,30.01) 119.64,30.11 v3(119.29,30.47)
  IN1 w0.127: v4(118.88,30.82) 119.23,30.47 v3(119.29,30.47)
  IN3 w0.122: v4(63.55,57.97) 63.55,57.97 62.14,56.56 62.14,49.49 62.24,49.4 62.56,49.4 62.69,49.52 62.69,50.14 62.81,50.26 63.05,50.26 63.17,50.14 63.17,49.5 63.28,49.4 64.13,49.4 64.28,49.54 64.28,50.16 64.38,50.26 64.67,50.26 64.77,50.16 64.77,49.5 64.87,49.4 66.43,49.4 66.56,49.52 66.56,50.13 66.68,50.25 66.92,50.25 67.04,50.13 67.04,49.5 67.14,49.4 68.65,49.4 68.77,49.52 68.77,50.14 68.9,50.26 69.14,50.26 69.26,50.14 69.26,49.03 69.13,48.91 64.37,48.91 64.24,48.78 64.24,48.29 64.24,48.04 64.34,47.94 64.7,47.94 64.83,47.82 64.83,47.56 64.7,47.43 63.89,47.43 63.76,47.31 63.76,47 63.89,46.88 64.14,46.88 64.24,46.77 64.24,46.6 64.38,46.46 64.85,46.46 65.54,45.77 65.77,45.77 66.63,45.77 66.73,45.67 66.73,45.38 66.63,45.28 65.56,45.28 65.44,45.15 65.44,44.3 66.37,43.37 66.66,43.37 66.94,43.65 66.94,44.03 67.06,44.16 67.32,44.16 67.44,44.03 67.44,43.35 67.16,43.07 67.16,42.93 67.34,42.76 67.8,42.76 68.93,41.63 69.59,41.63 70.11,41.11 70.11,39.92 69.98,39.79 69.4,39.79 69.27,39.66 69.27,38.24 69.4,38.11 69.86,38.11 69.98,37.99 69.98,37.66 69.86,37.53 69.78,37.53 69.4,37.15 69.3,37.15 69.3,37.16 v4(69.28,37.16)
  IN4 w0.091: v4(118.88,30.82) 118.77,30.93 113.22,30.93 112.62,30.33 112.62,30.08 110.34,27.8 107.82,27.8 v10(107.64,27.63) 107.18,27.17 107.18,27.17 106.04,27.17 105.79,27.42 105.43,27.42 105.31,27.29 105.31,26.6 105.18,26.47 104.77,26.47 104.64,26.6 104.64,26.8 104.52,26.93 104.06,26.93 103.93,26.8 103.93,26.32 103.78,26.17 103.02,26.17 102.89,26.29 102.89,26.89 102.77,27.01 102.51,27.01 102.38,26.89 102.38,26.29 102.26,26.17 102,26.17 101.65,26.52 100.71,26.52 100.58,26.65 100.58,26.83 100.45,26.96 100.12,26.96 100,26.83 100,26.65 99.87,26.52 99.59,26.52 99,27.11 97.11,27.11 v10(96.59,27.63) 96.15,27.19 94.35,27.19 94.26,27.1 94.26,26.6 94.13,26.47 93.72,26.47 93.6,26.6 93.6,26.8 93.47,26.93 93.01,26.93 92.88,26.8 92.88,26.32 92.73,26.17 91.97,26.17 91.84,26.29 91.84,27.51 91.72,27.64 91.46,27.64 91.34,27.51 91.34,26.29 91.21,26.17 90.95,26.17 90.83,26.29 90.83,28.28 90.7,28.41 90.45,28.41 90.32,28.28 90.32,26.6 90.24,26.52 89.66,26.52 89.53,26.65 89.53,26.95 89.4,27.08 89.07,27.08 88.95,26.95 88.95,26.65 88.88,26.58 88.38,26.58 88.07,26.28 88.07,26.27 87.74,25.94 87.32,25.94 86.85,26.4 86.85,26.76 86.54,27.06 85.61,27.06 85.54,27.13 v10(85.54,27.63) 85.1,27.19 83.92,27.19 83.69,27.42 83.33,27.42 83.21,27.29 83.21,26.6 83.08,26.47 82.67,26.47 82.55,26.6 82.55,26.8 82.42,26.93 81.96,26.93 81.84,26.8 81.84,26.32 81.68,26.17 80.92,26.17 80.79,26.29 80.79,26.89 80.67,27.01 80.41,27.01 80.29,26.89 80.29,26.29 80.16,26.17 79.91,26.17 79.55,26.52 78.61,26.52 78.48,26.65 78.48,26.83 78.36,26.96 78.03,26.96 77.9,26.83 77.9,26.65 77.77,26.52 77.26,26.52 76.89,26.15 76.57,26.15 76.23,26.49 76.23,26.5 75.74,27 74.67,27 74.5,27.18 v10(74.5,27.63) 74.06,27.19 72.75,27.19 71.73,26.17 69.61,26.17 69.45,26.33 67.93,26.33 66.56,27.71 66.56,29.35 67.27,30.06 67.27,31.53 67.37,31.64 68.89,31.64 68.99,31.74 68.99,32.07 68.89,32.17 67.46,32.17 67.33,32.3 67.33,32.55 67.46,32.68 69.17,32.68 69.27,32.78 69.27,33.13 69.17,33.24 67.44,33.24 67.33,33.34 67.33,34.62 68.04,35.33 68.74,36.03 68.74,36.71 69.18,37.15 69.3,37.15 69.3,37.16 v4(69.28,37.16) ; v5(64.39,57.8) 63.72,57.8 v4(63.55,57.97)
  GND5 w0.102: v5(64.39,57.8) 64.39,57.89 v6(64.13,58.14)
  BOTTOM w0.076: v10(96.59,27.63) 96.18,28.04 94.66,28.04 UD3.H7 ; UD5.H7 83.61,28.04 85.13,28.04 v10(85.54,27.63) ; UD1.H7 105.71,28.04 107.23,28.04 v10(107.64,27.63) ; v10(74.5,27.63) 74.08,28.04 72.56,28.04 UD7.H7
  BOTTOM w0.16: UCPU1.BE37 64.38,57.89 v6(64.13,58.14)
DDR_A_MA11: length 171.9
  TOP w0.076: v10(74.08,23.24) 73.94,23.24 73.81,23.37 73.81,23.43 73.72,23.52 73.72,23.63 73.81,23.73 74.5,23.73 74.6,23.63 74.9,23.63 74.98,23.7 74.98,24.06 UD8.M7 ; v10(85.13,23.24) 84.99,23.24 84.86,23.37 84.86,23.43 84.77,23.52 84.77,23.63 84.86,23.73 85.54,23.73 85.65,23.63 85.95,23.63 86.03,23.7 86.03,24.06 UD6.M7 ; UD2.M7 108.13,24.06 108.13,23.7 108.05,23.63 107.74,23.63 107.64,23.73 106.96,23.73 106.86,23.63 106.86,23.52 106.96,23.43 106.96,23.37 107.08,23.24 v10(107.22,23.24) ; UD4.M7 97.08,24.06 97.08,23.7 97,23.63 96.69,23.63 96.59,23.73 95.91,23.73 95.82,23.63 95.82,23.52 95.91,23.43 95.91,23.37 96.03,23.24 v10(96.17,23.24)
  TOP w0.16: v2(115.88,28) R1056.1
  GND1 w0.102: v2(115.88,28) 115.88,27.85 v3(115.65,27.62)
  IN1 w0.127: v4(115.3,27.24) 115.65,27.6 v3(115.65,27.62)
  IN2 w0.122: v4(115.3,27.24) 114.77,26.71 113.32,26.71 112.76,26.15 112.76,25.61 110.99,23.83 110.56,23.83 109.53,22.8 107.67,22.8 v10(107.22,23.24) 106.79,23.68 106.42,23.68 105.97,24.13 104.67,24.13 104.49,23.96 104.49,23.3 104.31,23.12 102.92,23.12 102.64,23.4 102.64,24.16 102.49,24.31 102.15,24.31 102.02,24.19 102.02,23.57 101.9,23.45 101.66,23.45 101.54,23.57 101.54,24.04 101.41,24.17 101.14,24.17 101.01,24.04 101.01,22.94 100.89,22.81 96.61,22.81 v10(96.17,23.24) 95.75,23.67 95.52,23.67 95.23,23.96 94.61,23.96 94.49,23.84 94.49,23.23 94.36,23.1 94.13,23.1 94,23.23 94,23.84 93.88,23.96 93.22,23.96 93.09,23.84 93.09,23.04 92.87,22.81 91.85,22.81 91.73,22.94 91.73,25.49 91.6,25.62 90.61,25.62 90.48,25.49 90.48,22.94 90.35,22.81 88.04,22.81 87.92,22.69 87.92,21.77 87.79,21.64 87.56,21.64 87.43,21.77 87.43,22.82 87.31,22.95 86.11,22.95 85.98,22.81 85.56,22.81 v10(85.13,23.24) 84.69,23.68 84.32,23.68 83.87,24.13 82.57,24.13 82.39,23.96 82.39,23.3 82.22,23.12 80.82,23.12 80.54,23.4 80.54,24.16 80.39,24.31 80.05,24.31 79.93,24.19 79.93,23.57 79.8,23.45 79.56,23.45 79.44,23.57 79.44,24.04 79.31,24.17 79.04,24.17 78.91,24.04 78.91,22.94 78.79,22.81 74.51,22.81 v10(74.08,23.24) 74.08,23.6 74,23.68 70.27,23.68 69.91,24.04 69.91,24.87 67.77,27.01 67.39,27.01 66.93,27.48 66.93,29.88 67.05,30.01 67.29,30.01 67.42,30.14 67.42,30.34 67.29,30.47 66.99,30.47 66.86,30.59 66.86,30.82 66.99,30.95 67.29,30.95 67.42,31.08 67.42,31.28 67.3,31.4 67.08,31.4 66.96,31.52 66.96,31.76 67.08,31.89 67.3,31.89 67.42,32.01 67.42,32.25 67.3,32.37 67.08,32.37 66.96,32.5 66.96,32.74 67.08,32.86 67.3,32.86 67.42,32.98 67.42,33.45 68.76,34.79 69.59,34.79 70.42,35.61 71.29,35.61 71.53,35.37 71.53,35.2 71.67,35.06 75.62,35.06 75.75,35.18 75.75,36.12 75.59,36.28 75.23,36.28 75.08,36.13 75.08,35.67 74.96,35.55 74.71,35.55 74.59,35.67 74.59,36.13 74.47,36.25 74.18,36.25 74.07,36.15 74.07,35.95 73.97,35.85 72.65,35.85 72.52,35.72 v4(72.52,35.54)
  IN3 w0.122: v4(72.52,35.54) 72.59,35.54 72.91,35.85 72.91,35.98 72.64,36.25 72.64,36.42 72.83,36.6 73,36.6 73.46,36.15 73.64,36.15 74.08,36.6 74.08,36.77 73.77,37.09 73.77,37.27 74.14,37.64 75.49,37.64 75.81,37.96 75.81,39.28 75.62,39.47 75.62,40.02 75.5,40.14 74.95,40.14 74.75,40.34 74.75,41.01 74.88,41.14 75.46,41.14 75.72,40.88 76.02,40.88 76.15,41.01 76.15,41.48 76.03,41.6 75.83,41.6 75.7,41.72 75.7,41.96 75.83,42.09 76.03,42.09 76.15,42.21 76.15,43.85 77.59,45.29 77.59,45.59 77.72,45.71 80.38,45.71 80.67,46 80.67,47.08 80.55,47.21 80.08,47.21 79.96,47.33 79.96,47.37 79.96,47.59 79.61,47.94 78.57,47.94 78.46,48.04 78.46,49.09 77.57,49.98 77.57,51.51 72.61,56.47 72.04,56.47 71.91,56.59 71.91,56.6 71.79,56.73 71.5,56.73 71.37,56.6 71.37,56.59 71.24,56.47 70.97,56.47 70.85,56.59 70.85,57.67 70.72,57.8 70.49,57.8 70.36,57.67 70.36,56.6 70.23,56.48 69.96,56.48 69.83,56.6 69.83,57.67 69.7,57.8 69.43,57.8 69.3,57.67 69.3,57.19 69.17,57.06 68.82,57.06 68.42,57.46 68.42,57.46 68.3,57.59 68.3,58.38 68.3,58.81 67.48,59.63 v4(67.48,59.84)
  IN4 w0.091: v5(67.55,59.35) 67.48,59.41 v4(67.48,59.84)
  GND5 w0.102: v6(67.99,59.72) 67.92,59.72 v5(67.55,59.35)
  BOTTOM w0.076: v10(74.08,23.24) 74.08,23.23 73.71,22.86 73.27,22.86 72.91,23.22 72.91,24.01 UD7.M7 ; v10(96.17,23.24) 96.17,23.23 95.81,22.86 95.37,22.86 95.01,23.22 95.01,24.01 UD3.M7 ; UD1.M7 106.06,24.01 106.06,23.22 106.42,22.86 106.86,22.86 107.22,23.23 v10(107.22,23.24) ; UD5.M7 83.96,24.01 83.96,23.22 84.32,22.86 84.76,22.86 85.13,23.23 v10(85.13,23.24)
  BOTTOM w0.16: v6(67.99,59.72) 67.87,59.84 UCPU1.BA30
DDR_A_MA12: length 173.2
  TOP w0.076: v10(73.73,25.33) 73.73,25.1 73.99,24.85 74.53,24.85 75.06,25.38 75.06,25.75 UD8.K7 ; v10(106.88,25.33) 106.88,25.1 107.13,24.85 107.68,24.85 108.21,25.38 108.21,25.75 UD2.K7 ; UD6.K7 86.11,25.75 86.11,25.38 85.58,24.85 85.04,24.85 84.78,25.1 v10(84.78,25.33) ; UD4.K7 97.16,25.75 97.16,25.38 96.63,24.85 96.09,24.85 95.83,25.1 v10(95.83,25.33)
  TOP w0.16: R1036.1 v2(117.66,29.76)
  GND1 w0.102: v3(117.2,29.58) 117.48,29.58 v2(117.66,29.76)
  IN1 w0.127: v3(117.2,29.58) v4(116.82,29.2)
  IN3 w0.122: v4(69.03,59.29) 69.03,59.35 69.16,59.47 69.45,59.47 69.54,59.38 69.54,58.75 69.65,58.64 69.86,58.64 69.98,58.76 70.19,58.76 70.31,58.64 71.13,58.64 72.47,57.29 72.96,57.29 78.39,51.85 78.39,50.32 79.28,49.43 79.28,48.95 79.42,48.82 79.89,48.82 80.12,48.6 80.35,48.6 80.91,48.03 81.06,48.03 81.51,47.59 81.51,47.36 81.51,47.05 81.63,46.93 82.21,46.93 82.33,46.8 82.33,46.56 82.21,46.44 81.63,46.44 81.51,46.32 81.51,44.41 81.63,44.28 82.18,44.28 82.3,44.16 82.3,43.22 82.18,43.09 81.87,43.09 81.74,43.22 81.74,43.68 81.62,43.81 80.67,43.81 80.49,43.98 80.34,43.98 80.09,43.73 79.63,43.73 79.34,44.02 79.34,44.2 79.23,44.31 77.78,44.31 76.97,43.5 76.97,41.01 77.07,40.91 77.22,40.91 77.4,40.73 77.4,40.17 77.27,40.04 77.05,40.04 76.92,40.17 v4(76.92,40.32)
  IN4 w0.091: v4(69.03,59.29) 68.52,59.29 v5(68.46,59.35) ; v4(76.92,40.32) 76.87,40.27 76.51,40.27 76.38,40.4 76.38,40.73 76.51,40.86 77.78,40.86 77.91,40.98 77.91,42.28 77.78,42.41 75.7,42.41 75.57,42.28 75.57,42.02 75.7,41.9 77.25,41.9 77.38,41.77 77.38,41.49 77.25,41.36 76,41.36 75.88,41.24 75.88,40.17 75.75,40.04 74.92,40.04 74.06,39.18 73.26,39.18 73.13,39.05 73.13,38.05 73.01,37.92 72.84,37.92 72.55,38.21 72.55,38.93 72.42,39.05 71.59,39.05 70.24,39.05 70.11,39.18 70.11,39.36 69.98,39.49 69.37,39.49 69.25,39.36 69.25,38.85 69.12,38.72 68.71,38.72 68.2,38.21 68.2,37.51 67.9,37.21 67.9,36.38 66.5,34.97 66.5,32.07 65.64,31.22 65.64,27.44 68.25,24.83 68.81,24.83 68.81,24.83 69.04,24.83 69.76,24.83 69.88,24.7 69.88,23.9 70.01,23.78 70.73,23.78 72.72,25.77 73.29,25.77 v10(73.73,25.33) 74.09,25.68 74.55,25.68 75.14,25.09 75.16,25.09 75.25,24.99 76.49,24.99 76.61,24.87 76.61,24.54 76.49,24.41 76.25,24.41 76.12,24.29 76.12,23.91 76.25,23.79 76.63,23.79 76.76,23.91 76.76,24.13 76.86,24.23 78.69,24.23 79.32,23.6 82.28,23.6 82.4,23.73 82.4,24.02 82.2,24.22 82.2,24.41 82.33,24.53 82.53,24.53 83.93,25.94 84.17,25.94 v10(84.78,25.33) 85.14,25.68 85.6,25.68 85.85,25.43 85.85,25.15 86,24.99 87.5,24.99 87.68,24.82 87.68,24.51 87.58,24.41 87.3,24.41 87.17,24.29 87.17,24.01 87.3,23.88 87.7,23.88 87.83,23.75 87.83,23.5 87.7,23.37 87.3,23.37 87.17,23.24 87.17,22.66 87.42,22.41 88.85,22.41 89.56,21.69 90.52,21.69 90.65,21.82 90.65,22.66 90.85,22.86 91.69,22.86 91.82,22.99 91.82,23.51 91.94,23.64 92.33,23.64 92.45,23.51 92.45,23.42 92.58,23.3 93.17,23.3 93.3,23.42 93.3,23.65 93.17,23.78 92.96,23.78 92.83,23.9 92.83,24.21 92.96,24.34 93.53,24.34 93.67,24.48 93.67,24.95 93.82,25.09 94.14,25.09 94.98,25.94 95.22,25.94 v10(95.83,25.33) 96.24,25.74 96.6,25.74 97.34,24.99 98.58,24.99 98.71,24.87 98.71,24.54 98.58,24.41 98.35,24.41 98.22,24.29 98.22,23.91 98.35,23.79 98.73,23.79 98.85,23.91 98.85,24.13 98.96,24.23 100.78,24.23 101.42,23.6 104.38,23.6 104.5,23.73 104.5,24.02 104.3,24.22 104.3,24.41 104.43,24.53 104.63,24.53 106.03,25.94 106.27,25.94 v10(106.88,25.33) 107.24,25.68 107.69,25.68 107.89,25.49 109.32,25.49 110.02,26.19 110.06,26.19 110.31,26.44 110.31,26.48 110.69,26.86 111.13,26.86 112.96,28.69 116.24,28.69 116.75,29.2 v4(116.82,29.2)
  GND5 w0.102: v6(67.99,59.19) 68.3,59.19 v5(68.46,59.35)
  BOTTOM w0.076: UD1.K7 105.51,26.2 105.98,25.73 106.77,25.73 106.98,25.94 107.16,25.94 107.29,25.81 107.29,25.56 107.05,25.33 v10(106.88,25.33) ; v10(95.83,25.33) 96,25.33 96.24,25.56 96.24,25.81 96.11,25.94 95.93,25.94 95.72,25.73 94.93,25.73 94.46,26.2 UD3.K7 ; v10(73.73,25.33) 73.9,25.33 74.14,25.56 74.14,25.81 74.01,25.94 73.83,25.94 73.62,25.73 72.83,25.73 72.36,26.2 UD7.K7 ; UD5.K7 83.41,26.2 83.88,25.73 84.67,25.73 84.88,25.94 85.06,25.94 85.19,25.81 85.19,25.56 84.95,25.33 v10(84.78,25.33)
  BOTTOM w0.16: UCPU1.BC30 v6(67.99,59.19)
