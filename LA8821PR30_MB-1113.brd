# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_AXG_SENSE: length 58
  TOP w0.122: v1(16.82,83.27) PC702.2
  TOP w0.254: RC135.2 v2(56.32,80.35) ; PC702.2 17.79,82.89 17.76,82.87 PC707.1 PR702.1 16.94,81.5 PR705.2 16.87,82.03 v7(17.08,82.23)
  GND1 w0.254: v2(56.32,80.35) v3(56.32,80.81)
  IN1 w0.254: v4(55.99,80.12) 56.01,80.12 56.32,80.43 v3(56.32,80.81)
  IN4 w0.127: v7(17.08,82.23) 17.18,82.13 21.11,82.13 21.85,82.87 24.81,82.87 26.12,81.56 26.12,79.46 27.27,78.31 39.68,78.31 42.22,75.77 45.25,75.77 46.79,77.3 48.01,77.3 50.25,79.54 52.66,79.54 52.96,79.84 55.71,79.84 v4(55.99,80.12)
  IN4 w0.254: v4(55.99,80.12) 56.09,80.23 57.97,80.23 58.71,79.49 58.94,79.49 59.27,79.16 59.27,78.03 v5(59.77,77.53)
  GND5 w0.254: v6(60.21,77.53) v5(59.77,77.53)
  BOTTOM w0.254: v6(60.21,77.53) 60.6,77.53 UCPU1.F45
VCC_DIE_SENSE: length 8.4
  TOP w0.122: 55.67,79.65 54.54,80.78 RC142.2 ; 55.67,79.65 v1(55.67,79.64) ; 55.67,79.65 56.53,78.79 57.25,78.79 57.69,78.35 58.15,78.35 58.68,77.81 58.68,77.74 v2(58.73,77.69)
  GND1 w0.104: v2(58.73,77.69) 59.01,77.97 v3(59.01,78.02)
  IN1 w0.071: v4(58.38,78.12) 58.91,78.12 v3(59.01,78.02)
  IN4 w0.071: v4(58.38,78.12) 58.82,77.68 v5(58.82,77.61)
  GND5 w0.104: v6(58.82,78.04) v5(58.82,77.61)
  BOTTOM w0.122: UCPU1.F48 v6(58.82,78.04)
VCCIO_SENSE: length 86.3
  TOP w0.122: v2(74.99,63.61) 74.99,63.94 v1(74.76,64.17)
  TOP w0.254: RC126.2 v2(74.99,63.61) ; v7(124.26,48.98) 124.39,49.11 PR508.1
  GND1 w0.254: v2(74.99,63.61) v3(74.99,63.18)
  IN1 w0.254: v4(74.66,64.53) 74.66,63.51 v3(74.99,63.18)
  IN3 w0.254: v7(124.26,48.98) 123.78,49.47 123.27,49.47 122.99,49.19 122.99,48.78 123.65,48.12 125.69,48.12 128.4,45.41 128.4,43.52 124.9,40.02 120.2,40.02 117.84,37.66 99.23,37.66 91.08,45.8 91.08,47.07 79.53,58.62 77.69,58.62 76.72,59.6 75.93,59.6 75.46,60.07 75.46,61.04 75.29,61.2 75.29,62.98 74.45,63.82 74.45,64.33 v4(74.66,64.53)
  IN4 w0.254: v5(75.14,64.53) v4(74.66,64.53)
  GND5 w0.254: v6(75.14,64.08) v5(75.14,64.53)
  BOTTOM w0.254: UCPU1.AN16 v6(75.14,64.08)
VCCSA_SENSE: length 39.4
  TOP w0.122: v2(107.67,78.91) 107.3,78.53 v1(107.3,78.35) 107.3,78.3 107.54,78.05 PR610.1
  GND1 w0.104: v3(107.67,79.34) v2(107.67,78.91)
  IN1 w0.084: v3(107.67,79.34) v4(107.67,79.83)
  IN4 w0.071: v5(77.91,71.74) 78.24,72.07 78.24,73.04 79.31,74.1 81.41,74.1 83.75,71.77 89.47,71.77 90.8,73.1 91.63,73.1 97.54,79.01 106.82,79.01 107.63,79.83 v4(107.67,79.83)
  GND5 w0.104: v6(77.9,72.2) 77.9,71.75 v5(77.91,71.74)
  BOTTOM w0.122: UCPU1.U10 v6(77.9,72.2)
VCCSA_VID0: length 66.5
  TOP w0.122: PC619.1 PR602.1 108.77,85.81 v7(108.52,86.07)
  IN1 w0.071: v7(108.52,86.07) 108.52,85.23 107.73,84.44 107.73,80.73 106.69,79.69 106.69,78.45 106.43,78.19 102.5,78.19 101.59,79.1 96.73,79.1 95.82,78.19 92.63,78.19 90.45,76.01 86.29,76.01 83.37,78.93 77.05,78.93 76.59,78.47 v4(74.99,78.47)
  IN4 w0.071: v4(74.99,78.47) 74.58,78.07 64.76,78.07 62.34,75.65 61.91,75.65 61.33,75.07 v5(60.56,75.07)
  GND5 w0.104: v5(60.56,75.07) v6(60.13,75.07)
  BOTTOM w0.122: v6(60.13,75.07) 60.13,75.93 59.38,76.68 59.38,77.09 59.47,77.18 59.47,77.53 59.32,77.69 59.32,78.16 UCPU1.D48
  BOTTOM w0.254: v7(108.52,86.07) 108.9,86.07 109.36,85.6 PU600.14
VCCSA_VID1: length 68.4
  TOP w0.122: v7(109.68,86.07) 109.8,86.07 110.47,85.4 PR600.1
  IN1 w0.071: v7(109.68,86.07) 107.91,84.3 107.91,80.66 106.87,79.62 106.87,78.37 106.49,77.99 102.44,77.99 101.51,78.92 96.8,78.92 95.89,78.01 92.71,78.01 90.53,75.83 86.21,75.83 83.54,78.5 77.48,78.5 76.84,77.86 v4(75.78,77.86)
  IN4 w0.071: v5(59.57,74.31) 60.83,74.31 61.98,75.46 62.42,75.46 64.84,77.88 74.28,77.88 74.76,77.41 75.32,77.41 v4(75.78,77.86)
  GND5 w0.104: v6(59.14,74.31) v5(59.57,74.31)
  BOTTOM w0.122: UCPU1.D49 58.4,77.56 58.5,77.46 58.5,77.45 58.58,77.37 58.58,77.16 58.53,77.1 58.53,77.09 58.5,77.06 58.5,76.8 58.57,76.74 58.57,76.73 58.58,76.72 58.58,76.5 58.57,76.49 58.57,76.48 58.5,76.41 58.5,76.15 58.57,76.09 58.57,75.83 58.5,75.76 58.5,75.5 58.69,75.32 59.14,74.87 v6(59.14,74.31)
  BOTTOM w0.254: PU600.15 109.86,85.89 v7(109.68,86.07)
VCCSENSE: length 28.6
  TOP w0.254: v7(48.76,82.78) 48.76,82.41 49.3,81.88 RC98.2 RC97.2 ; PR733.2 29.78,77.97 PR737.1 29.78,78.85 29.23,79.4 29.23,79.88 28.8,80.31 PC739.2 28.8,80.37 29.23,80.8 29.26,80.8 29.29,80.84 PC737.1 30.41,80.84 v9(31.25,81.67) 33.05,83.48 v7(33.05,83.65)
  IN4 w0.254: v7(48.76,82.78) 48.42,83.13 48.42,83.15 48.22,83.35 47.12,83.35 46.59,83.88 41.76,83.88 40.95,83.07 40.47,83.07 39.89,82.49 38.99,82.49 38.37,81.86 35.24,81.86 34.79,82.31 34.4,82.31 v7(33.05,83.65)
VCCSENSE_R: length 19.9
  TOP w0.122: v7(51.62,77.32) 51.63,77.32 v1(52.13,77.81) 52.13,79.63 50.92,80.83 50.92,81.4 RC98.1
  IN4 w0.071: v7(51.62,77.32) 53.49,75.45 61.45,75.45 61.83,75.83 62.26,75.83 62.54,76.11 62.54,77.3 v5(62.29,77.56)
  GND5 w0.104: v6(61.96,77.25) 61.98,77.25 v5(62.29,77.56)
  BOTTOM w0.122: UCPU1.F43 61.65,77.57 v6(61.96,77.25)
VDD_1.35V: length 8.2
  TOP w0.254: PR303.2 27.77,19.06 PR301.1 28.76,19.57 v7(29.09,19.9) 29.12,19.93 30.36,19.93 30.57,20.14 PU300.11
  BOTTOM w0.122: PC310.1 31.49,19.95 v1(31.72,19.72)
  BOTTOM w0.254: v7(29.09,19.9) 29.65,19.9 30.66,20.92 PC310.1
VDDPWRGOOD: length 138.6
  TOP w0.122: v2(89.43,55.87) 87.57,55.87 v1(83.38,51.68) 81.74,50.03 79.32,50.03 78.56,50.79 73.8,50.79 73.7,50.68 71.65,50.68 71.3,50.34 70.17,50.34 69.97,50.55 67.46,50.55 65.59,52.41 64.12,52.41 62.76,53.77 61.08,53.77 60.59,54.26 RC8.2 59.28,54.26 RC57.1 ; 144.61,45.17 v7(144.61,43.4) ; 144.61,45.17 144.88,45.17 145.09,45.39 RC19.2 ; 144.61,45.17 143.12,45.17 142.84,45.46 UC1.4
  GND1 w0.104: v2(89.43,55.87) 89.53,55.97 v3(90.16,55.97)
  IN1 w0.071: v3(90.16,55.97) 90.2,55.97 90.26,56.02 v4(90.71,56.02)
  IN2 w0.094: v7(117.91,36.49) 120.99,36.49 128.44,29.03 129.37,29.03 131.01,27.39 141.03,27.39 142.89,29.26 147.16,29.26 147.94,30.04 149.03,30.04 150.57,31.58 150.57,40.89 148.9,42.56 148.33,42.56 148.2,42.68 145.32,42.68 v7(144.61,43.4)
  IN4 w0.071: v7(117.91,36.49) 114.63,36.49 113.88,37.24 99.05,37.24 90.57,45.72 90.57,55.88 v4(90.71,56.02)
VDDPWRGOOD_R: length 14.6
  TOP w0.122: v10(60.13,57.55) 60.18,57.5 60.18,56.38 59.68,55.88 59.02,55.88 58.71,55.56 v1(57.47,55.56) 56.32,55.56 56.19,55.43 56.19,55.11 56.32,54.98 57.23,54.98 57.36,54.85 57.36,54.47 57.23,54.34 56.33,54.34 56.2,54.22 56.2,53.84 56.33,53.71 58.22,53.71 58.35,53.84 58.35,54.23 58.22,54.36 58.14,54.36 58.01,54.48 58.01,54.76 58.14,54.89 59.11,54.89 59.24,55.02 RC57.2
  BOTTOM w0.122: UCPU1.BE45 60.48,57.89 v10(60.13,57.55)
VIN: length 37.4
  TOP w0.122: v9(186.77,71.42) 186.77,71.62 186.53,71.86 186.35,71.86 v7(186.2,71.7) ; PD10.2 149.95,45.65 v9(150.18,45.89)
  TOP w0.508: PR965.2 PR966.2 187.62,69.81 187.37,69.56 ; 187.37,69.56 PR964.2 186.19,68.25 PR942.1 ; 187.37,69.56 187.37,70.37 186.77,70.97 v9(186.77,71.42) ; v7(163.91,42.51) 163.91,42.84 163.18,43.57 PR16.2 163.22,44.39 PC41.1 ; PD10.2 149.73,44.26 148.99,43.52 v7(148.99,43.27)
  BOTTOM w0.508: v7(163.28,42.51) 160.26,45.53 156.98,45.53 154.82,43.37 154.12,43.37 153.63,42.88 151.63,42.88 151.24,43.27 v7(148.99,43.27) 146.16,43.27 145.83,42.94 PR18.1
  vias: v7(163.28,41.87) v7(163.91,41.87) v7(164.55,42.51) v7(164.55,41.87) v7(184.93,71.4) v7(185.22,70.83) v7(185.64,72.06) v7(185.6,71.41) v7(186.11,70.95) v9(163.89,40.34)
VSS_AXG_SENSE: length 56.1
  TOP w0.254: PC706.1 PC707.2 19.36,82.41 v7(19.59,82.64) ; RC136.1 v2(55.43,80.38)
  GND1 w0.254: v2(55.43,80.38) v3(55.43,80.81)
  IN1 w0.254: v3(55.43,80.81) v4(55.43,80.33)
  IN4 w0.127: v7(19.59,82.64) 19.59,82.92 20.02,83.35 20.5,83.35 20.63,83.22 24.78,83.22 26.35,81.66 26.35,79.56 27.37,78.54 39.8,78.54 42.34,76 44.98,76 46.67,77.69 47.89,77.69 50.1,79.9 52.51,79.9 52.94,80.33 v4(55.43,80.33)
  IN4 w0.254: v5(60.1,77.13) 60.18,77.2 60.18,77.66 59.67,78.17 59.67,79.26 59.08,79.84 58.85,79.84 58.12,80.58 55.68,80.58 v4(55.43,80.33)
  GND5 w0.254: v6(59.75,76.93) 59.95,77.13 v5(60.1,77.13)
  BOTTOM w0.254: v7(19.59,82.64) 19.69,82.64 20.38,81.95 20.6,81.95 20.61,81.94 PU700.39 ; UCPU1.G45 v6(59.75,76.93)
VSSIO_SENSE: length 85.8
  TOP w0.122: RC129.2 74.1,63.05
  TOP w0.254: PR509.2 v7(123.5,48.98) ; 74.1,63.05 v2(74.1,63.61)
  GND1 w0.254: v2(74.1,63.61) v3(74.1,63.18)
  IN1 w0.254: v4(73.97,64.68) 74.15,64.5 74.15,63.23 v3(74.1,63.18)
  IN3 w0.254: v7(123.5,48.98) 124.01,48.48 125.84,48.48 128.76,45.55 128.76,43.37 125.05,39.66 120.35,39.66 117.99,37.3 99.08,37.3 90.72,45.66 90.72,46.92 79.38,58.27 77.54,58.27 76.64,59.17 75.67,59.17 74.48,60.36 74.48,60.82 74.89,61.23 74.89,62.83 v2(74.1,63.61) 74.1,64.48 73.97,64.6 v4(73.97,64.68)
  IN4 w0.254: v4(73.97,64.68) 74,64.66 74,64.17 v5(73.87,64.05)
  GND5 w0.254: v6(74.2,64.38) v5(73.87,64.05)
  BOTTOM w0.254: UCPU1.AN17 73.9,64.08 v6(74.2,64.38)
VSSSENSE: length 28.9
  TOP w0.254: RC100.2 RC99.2 49.46,80.99 v9(48.56,81.89) 47.94,82.51 v7(47.94,82.84) ; PC738.1 26.6,80.99 27.11,80.48 27.23,80.48 v7(27.24,80.47) 27.37,80.34 PC739.1
  IN4 w0.254: v7(27.24,80.47) 27.56,80.47 28.44,81.35 32,81.35 32.6,81.95 34.64,81.95 35.09,81.51 38.52,81.51 39.14,82.13 40.03,82.13 40.62,82.72 41.1,82.72 41.9,83.52 46.46,83.52 47.03,82.94 47.76,82.94 47.86,82.84 v7(47.94,82.84)
  BOTTOM w0.254: PU700.16 27.08,80.35 27.19,80.45 27.22,80.45 v7(27.24,80.47)
8243_TON: length 4.6
  TOP w0.127: v7(193.43,58.64) 192.93,58.64 192.01,59.56 v1(192.01,59.93)
  TOP w0.254: PU501.3 193.54,58.52 v7(193.43,58.64)
  BOTTOM w0.254: v7(193.43,58.64) 192.54,57.75 PR19.1
+DDR_CHG: length 2.6
  BOTTOM w0.122: v1(59.39,48.07) 59.96,48.63 Q38.1
  BOTTOM w0.508: Q38.1 R293.2
+EC_VCCA: length 9.9
  TOP w0.203: v2(146.1,56.91) 146.11,56.9 146.11,56.65 146.37,56.39 146.37,56.06 ; v2(144.6,57.4) 144.66,57.34 144.71,57.34 144.91,57.13 144.91,57.11 U34.B11
  TOP w0.254: L43.2 145.96,51.89 145.96,52.54 C282.1 146.88,53.47 146.88,54.15 146.37,54.66 v9(146.37,54.86) 146.37,56.06
  GND1 w0.203: v2(144.6,57.4) 144.61,57.4 144.62,57.4 144.73,57.4 144.96,57.17 v3(145.31,57.17)
  GND1 w0.254: v3(146.57,57.19) 146.3,56.92 146.08,56.92 v2(146.1,56.91)
  IN1 w0.254: v3(146.57,57.19) 146.55,57.17 v3(145.31,57.17)
+EDP_COM: length 15.9
  BOTTOM w0.122: UCPU1.AD2 81.7,68.62 81.38,68.3 UCPU1.AF3 81.65,68.07 82.02,68.44 82.4,68.44 82.81,68.03 82.81,67.73 82.76,67.68 82.76,65.91 83.4,65.28 83.4,64.39 83.59,64.2 85.16,64.2 85.63,64.67
  BOTTOM w0.305: UCPU1.AD2 81.87,68.77 82.71,68.77 83.14,68.34 83.14,67.55 83.09,67.5 83.09,66.54 83.99,65.63 83.99,65.28 v9(84.16,65.11) 85.01,65.11 85.45,64.67 RC36.2
+INV_PWR_SRC: length 4
  TOP w0.122: R541.1 166.53,80.02 166.53,79.86 165.46,78.79 v9(165.46,78.66)
  BOTTOM w0.254: JLVDS1.16 v7(158.75,80.73) ; JLVDS1.15 159.25,80.59 v7(159.39,80.73)
  vias: v7(160.03,80.73)
+LCDVDD:
  vias: v7(174.35,68.54) v7(176.82,69.84) v7(177.15,69.28) v7(177.45,69.84) v7(178.38,78.61) v7(179.01,78.61) v7(179.65,78.61) v7(180.3,78.65) v9(176.46,69.05)
+LCDVDD_R: length 10.5
  TOP w0.122: Q305.2 165.73,84.04 165.54,84.23 165.54,85.84 164.93,86.45 v1(164.32,86.45) 161.89,86.45 161.15,85.7 Q71.2 158.53,84.59 R538.1
+PCH_V5REF_RUN: length 26.1
  TOP w0.122: CH64.1 111.46,70.51 v2(111.46,70.17) ; DH3.1 RH227.2 128.96,71.6 128.66,71.91 v2(128.43,71.91) 128.12,72.21 v1(128.02,72.21)
  GND1 w0.104: v3(111.49,70.62) 111.49,70.24 111.46,70.22 v2(111.46,70.17) ; v2(128.43,71.91) 128.18,72.16 v3(128.18,72.28)
  IN1 w0.084: v3(111.49,70.62) 111.34,70.48 v4(111.34,70.05) 112.95,70.05 113.18,70.29 113.55,70.29 113.68,70.16 115.44,70.16 116.26,69.34 118.28,69.34 119.74,70.8 119.74,70.91 119.98,71.15 121.02,71.15 122.37,72.49 127.96,72.49 v3(128.18,72.28)
  IN4 w0.071: v4(111.34,70.05) 111.43,70.14 111.43,71.02 v5(111.41,71.03)
  GND5 w0.104: v6(111.52,71.51) 111.51,71.51 111.41,71.41 v5(111.41,71.03)
  BOTTOM w0.122: v6(111.52,71.51) 111.83,71.19 UH1.N36
+PCH_V5REF_SUS: length 37.1
  TOP w0.122: v2(112.4,71.65) 112.85,71.21 CH56.1 ; RH222.2 131.99,64.64 131.24,64.64 v2(131.2,64.6) 129.83,64.6 129.29,65.14 129.29,66.69 DH2.1 128.35,67.39 v1(127.68,68.06)
  GND1 w0.104: v3(112.83,71.32) 112.68,71.32 112.4,71.6 v2(112.4,71.65) ; v3(131.05,64.2) 131.05,64.45 v2(131.2,64.6)
  IN1 w0.071: v3(131.05,64.2) 130.31,63.46 129.63,63.46 129.61,63.48 129.04,63.48 128.84,63.28 128.84,62.98 127.62,61.75 v4(127.62,61.58)
  IN1 w0.084: v4(112.55,71.71) 112.83,71.42 v3(112.83,71.32)
  IN2 w0.094: v4(112.55,71.71) 112.55,69.76 114.37,67.93 119.13,67.93 121.47,65.6 125.23,65.6 127.16,63.67 127.16,62.55 127.62,62.09 v4(127.62,61.58)
  IN4 w0.071: v5(112.26,71.27) 112.26,71.3 112.58,71.62 112.58,71.68 v4(112.55,71.71)
  GND5 w0.104: v5(112.26,71.27) 112.28,71.29 112.28,71.67 v6(112.26,71.68)
  BOTTOM w0.122: v5(112.26,71.27) v6(112.26,71.68)
+PCH_VCCDSW: length 3
  TOP w0.122: v2(111.44,59.52) 111.46,59.5 CH51.1
  GND1 w0.104: v3(111.87,59.68) 111.59,59.68 v2(111.44,59.52)
  IN1 w0.084: v3(111.87,59.68) 111.84,59.68 v4(111.49,59.32)
  IN4 w0.071: v4(111.49,59.32) 111.49,59.55 v5(111.26,59.78)
  GND5 w0.104: v6(111.26,60.19) v5(111.26,59.78)
  BOTTOM w0.122: UH1.R10 v6(111.26,60.19)
+RTCBATT: length 6.6
  BOTTOM w0.508: RH259.2 27.48,50.36 v1(27.21,50.62) 22.91,50.62 22.68,50.85 JRTC1.1
+RTCVCC: length 301.5
  TOP w0.122: v7(131.5,23.25) 131.92,23.67 v9(132.28,23.67)
  TOP w0.381: v2(117.57,64.45) 117.57,64.43 117.49,64.35 RH11.1 ; v2(111.26,62.67) 111.26,62.45 111.67,62.03 CH84.1 CH83.1 CH82.1
  TOP w0.508: RH25.1 123.43,58.36 123.45,58.38 123.73,58.38 v7(124.01,58.66) ; v7(119.47,67.01) 119.46,67.01 119.28,67.2 118.85,67.2 RH147.1 ; v7(122.9,63.43) 123.04,63.58 RH31.1 ; R1101.1 150.49,69.15 v7(150.41,69.08)
  GND1 w0.254: v2(111.26,62.67) 111.26,62.55 v3(111.64,62.17)
  GND1 w0.381: v2(117.57,64.45) 117.8,64.45 v3(117.99,64.26)
  IN1 w0.254: v4(111.79,62.65) 111.64,62.5 v3(111.64,62.17) ; v7(23.73,23.91) 23.27,24.37 15.83,24.37 v7(15.3,23.84)
  IN1 w0.381: v3(117.99,64.26) 118.04,64.31 v4(118.04,64.78)
  IN1 w0.508: v4(67.67,19.39) 68.13,18.94 97.04,18.94 98.13,20.03 105.34,20.03 106.23,19.14 112.55,19.14 113.09,19.67 121.16,19.67 121.9,20.41 128.15,20.41 130.99,23.25 v7(131.5,23.25)
  IN2 w0.381: v4(111.79,62.65) 113.52,64.38 113.67,64.38 113.81,64.52 115.77,64.52 116.03,64.78 v4(118.04,64.78)
  IN2 w0.508: v7(153.07,37) 153.8,37.73 153.8,42.7 152.08,44.42 v7(150.83,44.42) 149.88,44.42 149.71,44.59 145.5,44.59 145.27,44.81 143.34,44.81 141.79,46.37 140.88,46.37 137.8,49.44 133.11,49.44 132.22,50.33 131.6,50.33 131.27,50.66 v4(127.95,50.66)
  IN3 w0.381: v7(119.47,67.01) 119.5,67.01 119.84,66.66 119.84,66.03 118.6,64.78 v4(118.04,64.78)
  IN4 w0.254: v5(111.82,62.12) 111.82,62.62 v4(111.79,62.65)
  IN4 w0.508: v7(153.07,37) 153.07,33.9 150.98,31.81 148.67,31.81 145.24,28.38 143.69,28.38 140.57,25.26 137.98,25.26 136.3,23.58 131.83,23.58 v7(131.5,23.25) ; v4(67.67,19.39) 67.29,19.77 64.6,19.77 59.77,24.6 57.64,24.6 55.3,26.94 50.6,26.94 48.24,24.57 35.16,24.57 34.74,24.99 32.19,24.99 31.58,25.6 27.91,25.6 26.22,23.91 v7(23.73,23.91) 23.73,25.18 20.26,28.65 20.26,32.33 20.64,32.72 20.64,33.88 20.26,34.26 20.26,35.46 19.69,36.03 19.69,38.29 19.62,38.37 19.62,40.53 21.72,42.63 21.72,44.89 22.12,45.28 22.92,45.28 v5(23.3,45.66) ; v5(127.24,50.23) 127.52,50.23 v4(127.95,50.66)
  GND5 w0.254: v5(23.3,45.66) 23.84,45.66 24.37,46.18 v6(24.37,46.33) ; v6(111.82,62.55) v5(111.82,62.12)
  GND5 w0.508: v5(127.24,50.23) 127.03,50.43 126.88,50.43 v6(126.68,50.63)
  BOTTOM w0.122: PR104.2 153.07,36.37
  BOTTOM w0.254: JIOL1.8 15.6,24.14 v7(15.3,23.84) ; v6(111.82,62.55) 111.83,62.54 UH1.N16
  BOTTOM w0.508: v6(24.37,46.33) 24.74,46.7 27.4,46.7 CH95.1 27.62,46.77 28.91,45.48 DH4.1 ; v7(119.47,67.01) 119.65,67.01 120,66.66 RH23.1 120.56,66.48 122.26,64.78 122.9,64.14 v7(122.9,63.43) 124.36,63.43 124.96,64.03 126.54,64.03 127.19,63.39 127.19,60.49 126.23,59.52 124.87,59.52 v7(124.01,58.66) 125.64,57.03 125.64,54.73 125.3,54.39 125.3,52.02 v6(126.68,50.63) ; v7(150.83,44.42) 148.17,47.09 148.17,57.98 150.77,60.58 150.77,64.26 151.7,65.19 151.7,67.59 150.41,68.87 v7(150.41,69.08) ; 153.07,36.37 v7(153.07,37)
+V_SM_VREF: length 19.4
  TOP w0.508: v2(61.98,60.41) 61.98,60.31 61.58,59.91 57.68,59.91 57.11,59.34 RC116.1 57.11,57.13 RC141.1 55.51,57.11 54.67,56.27 v9(54.67,54.65) 54.67,51.45 v7(55.7,50.41)
  GND1 w0.254: v3(61.37,60.39) 61.4,60.41 v2(61.98,60.41)
  IN1 w0.254: v4(61.12,60.82) 61.37,60.57 v3(61.37,60.39)
  IN4 w0.254: v4(61.12,60.82) 61.32,60.62 v5(61.65,60.62)
  GND5 w0.254: v6(61.3,60.26) v5(61.65,60.62)
  BOTTOM w0.254: v6(61.3,60.26) 61.61,60.57 UCPU1.AY43
+VREFCA_A: length 64
  TOP w0.254: v10(109.88,26.62) 109.5,27 UD2.J8 ; RD17.2 111.07,20.15 RD19.1 CD114.1 CD113.1 v9(112.85,21.6) 112.85,25.14 v7(111.71,26.28) ; UD6.J8 87.4,27 v10(87.78,26.62) ; UD8.J8 76.35,27 v10(76.73,26.62) ; UD4.J8 98.45,27 v10(98.83,26.62)
  IN3 w0.254: v10(71.11,27.41) 72.66,25.86 74.68,25.86 74.77,25.77 74.81,25.77 74.84,25.74 75.85,25.74 v10(76.73,26.62) 77.07,26.28 80.58,26.28 80.85,26.01 81.99,26.01 82.16,26.18 v10(82.16,27.41) 83.71,25.86 85.69,25.86 85.94,25.62 86.77,25.62 v10(87.78,26.62) 88.12,26.28 91.63,26.28 91.89,26.01 93.04,26.01 93.21,26.18 v10(93.21,27.41) 94.76,25.86 96.61,25.86 96.76,25.72 97.92,25.72 v10(98.83,26.62) 99.17,26.28 102.68,26.28 102.94,26.01 104.09,26.01 104.26,26.18 v10(104.26,27.41) 105.8,25.86 107.83,25.86 107.95,25.74 109,25.74 v10(109.88,26.62) 110.22,26.28 v7(111.71,26.28)
  BOTTOM w0.254: UD1.J8 104.66,27 v10(104.26,27.41) ; v10(82.16,27.41) 82.57,27 UD5.J8 ; v10(93.21,27.41) 93.62,27 UD3.J8 ; UD7.J8 71.52,27 v10(71.11,27.41)
+VREFCA_B: length 63.9
  TOP w0.254: UD10.J8 60.86,32.08 v10(61.24,31.7) ; v7(20.48,40.3) v9(19.72,40.3) 19.41,40.3 CD115.1 CD116.1 18.05,42.52 RD18.2 17.03,43.41 16.15,42.54 RD20.1 ; v10(28.09,31.7) 27.71,32.08 UD16.J8 ; UD12.J8 49.81,32.08 v10(50.19,31.7) ; UD14.J8 38.76,32.08 v10(39.14,31.7)
  IN2 w0.254: v10(22.47,32.49) 22.47,33.33 20.21,35.59 20.21,40.03 v7(20.48,40.3)
  IN4 w0.254: v10(61.24,31.7) 60.86,32.08 UD9.J8 v10(55.61,32.49) 55.17,32.93 51.42,32.93 v10(50.19,31.7) 49.67,32.22 45.9,32.22 45.63,32.49 v10(44.57,32.49) 43.69,33.36 42.35,33.36 40.69,31.7 v10(39.14,31.7) 38.28,30.85 37.22,30.85 37.17,30.9 35.11,30.9 v10(33.52,32.49) 33.07,32.93 32.54,32.93 31.83,32.22 28.61,32.22 v10(28.09,31.7) 27.26,30.87 26.15,30.87 26.07,30.95 24.01,30.95 v10(22.47,32.49)
  BOTTOM w0.254: v10(44.57,32.49) 44.97,32.08 UD11.J8 ; v10(33.52,32.49) 33.93,32.08 UD13.J8 ; UD15.J8 22.88,32.08 v10(22.47,32.49) ; v10(55.61,32.49) 56.02,32.08 UD9.J8
+VREFDQ_A: length 163
  TOP w0.254: v10(91.16,31.44) 90.81,31.1 90.81,30.85 91.42,30.24 92.78,30.24 UD4.E1 ; v10(80.19,31.15) 80.16,31.12 80.16,30.5 80.41,30.25 80.44,30.25 80.45,30.24 81.73,30.24 UD6.E1 ; v10(69.86,30.19) 69.91,30.24 70.68,30.24 UD8.E1 ; v10(102.29,31.15) 102.26,31.12 102.26,30.5 102.51,30.25 102.53,30.25 102.55,30.24 103.83,30.24 UD2.E1 ; RD21.2 117.12,36.44 RD25.1 116.25,36.46 CD118.1 CD117.1 114.14,36.46 112.85,35.17 112.85,33.12 v7(113.1,32.87)
  IN1 w0.254: v10(69.86,30.19) 69.91,30.24 70.59,30.24 72.27,28.56 72.27,22.95 71.89,22.57 v4(65.21,22.57)
  IN2 w0.254: v4(65.21,22.57) 65.21,24.9 63.6,26.52 63.6,28.55 62.66,29.49 v7(62.66,30.26) 63.09,30.69 63.09,31.23 62.68,31.64 62.68,34.99 61.82,35.84 61.82,37.77 59.67,39.92 56.22,39.92 56.06,39.76 54.92,39.76 v7(54.9,39.79)
  IN3 w0.254: v7(54.9,39.79) 54.9,39.81 54.01,40.7 54.01,43.65 53.47,44.19 v7(53.47,47.26) ; v10(80.19,31.15) 80.09,31.05 80.09,30.55 80.42,30.22 81.67,30.22 81.83,30.06 83.02,30.06 83.02,28.15 84.05,27.11 86.21,27.11 87,27.91 87,28.23 v10(88.57,29.8) 88.57,30.08 88.72,30.23 88.72,30.24 89.92,31.44 v10(91.16,31.44) 90.94,31.22 90.94,30.72 91.4,30.26 92.77,30.26 93.75,29.28 93.75,28.44 95.04,27.16 96.97,27.16 v10(99.62,29.8) 99.77,29.95 99.77,30.33 100.59,31.15 v10(102.29,31.15) 102.29,30.95 102.26,30.92 102.26,30.53 102.53,30.25 103.73,30.25 104.8,29.18 104.8,28.36 106.06,27.1 107.97,27.1 v10(110.66,29.8) 110.69,29.8 113.1,32.21 v7(113.1,32.87) ; v10(80.19,31.15) 80.02,31.33 80.02,35.88 82.58,38.44 86.95,38.44 89.69,41.19 89.69,44.69 89.57,44.82 89.57,45.72 v7(89.64,45.79) ; v10(80.19,31.15) 79.46,31.15 78.98,30.67 78.98,30.06 78.34,29.43 77.89,29.43 v10(77.52,29.8) 76.01,28.29 76.01,27.91 75.2,27.1 72.87,27.1 71.84,28.13 71.84,29.05 70.59,30.29 69.96,30.29 v10(69.86,30.19)
  BOTTOM w0.254: UD7.E1 77.12,30.2 v10(77.52,29.8) ; UD3.E1 99.22,30.2 v10(99.62,29.8) ; v10(88.57,29.8) 88.17,30.2 UD5.E1 ; v7(53.47,47.26) 53.83,47.62 v9(53.83,48.35) RCU1.1 53.93,49.72 53.93,51.45 QC6.1 ; UD1.E1 110.27,30.2 v10(110.66,29.8) ; v7(89.64,45.79) 89.62,45.81 89.62,47.07 RD27.1
  BOTTOM w0.381: QD1.1 92.94,48.33 RD27.1
+VREFDQ_B: length 125.8
  TOP w0.254: v10(62.02,34.88) 62.32,34.58 63,34.58 65.03,36.61 73.44,36.61 73.46,36.64 73.46,36.66 v7(73.51,36.72) ; v10(20.68,36.36) 20.47,36.15 20.47,35.58 20.72,35.33 20.75,35.33 20.76,35.32 22.04,35.32 UD16.E1 ; v7(81.31,39.94) 83.85,39.94 v9(87.51,43.6) 89.11,45.2 89.11,46.32 90.69,47.9 RD30.1 92.37,47.9 92.53,47.74 QD2.1 ; v10(42.51,36.52) 42.17,36.18 42.17,35.93 42.78,35.32 44.14,35.32 UD12.E1 ; v10(53.65,36.23) 53.62,36.2 53.62,35.58 53.87,35.33 53.89,35.33 53.91,35.32 55.19,35.32 UD10.E1 ; UD14.E1 33.09,35.32 31.81,35.32 31.79,35.33 31.77,35.33 31.52,35.58 31.52,36.2 v10(31.55,36.23)
  IN2 w0.254: v10(62.02,34.88) 59.32,32.18 56.67,32.18 53.62,35.23 53.62,36.2 v10(53.65,36.23) ; v7(21.14,40.32) 21.14,40.27 20.61,39.74 20.61,36.44 v10(20.68,36.36) 20.71,36.33 21.72,36.33 22,36.06 22,35.27 23.48,33.8 23.48,32.91 24.19,32.19 26.17,32.19 28.86,34.88 v10(28.88,34.88) 29.03,35.03 29.03,35.32 29.05,35.35 29.05,35.38 29.9,36.23 v10(31.55,36.23) 31.55,36.03 31.52,36 31.52,35.61 31.79,35.33 32.99,35.33 34.48,33.85 34.48,32.97 35.27,32.18 37.2,32.18 v10(39.9,34.88) 40.21,34.88 41.92,36.59 42.45,36.59 v10(42.51,36.52) 42.51,36.45 42.3,36.23 42.3,34.76 43.57,33.49 44.23,33.49 45.72,32 49.57,32 50.97,33.4 v10(50.97,34.88)
  IN4 w0.254: v10(53.65,36.23) 53.6,36.18 53.6,33.62 53.34,33.35 51.46,33.35 50.97,33.84 v10(50.97,34.88) ; v7(73.51,36.72) 76.84,36.72 79.17,39.04 80.41,39.04 v7(81.31,39.94)
  BOTTOM w0.254: UD9.E1 61.63,35.28 v10(62.02,34.88) ; UD15.E1 28.48,35.28 v10(28.88,34.88) ; UD11.E1 50.58,35.28 v10(50.97,34.88) ; 17.82,40.47 CD119.1 CD120.1 ; 17.82,40.47 19.41,40.47 19.72,40.78 20.68,40.78 v7(21.14,40.32) ; 17.82,40.47 17.13,40.47 16.91,40.7 RD26.1 16.91,41.96 RD22.2 ; UD13.E1 39.53,35.25 v10(39.9,34.88)
+VSBP: length 129.4
  TOP w0.122: v9(173.62,82.55) 173.76,82.69 175.62,82.69 176.26,82.05 PJP702.1
  IN2 w0.254: v7(80.04,53.12) 81.18,54.26 92.78,54.26 93.19,54.67 94,54.67 96.69,57.37 103.23,57.37 105.12,59.25 105.12,61.44 105.62,61.94 105.62,63.97 105.04,64.55 105.04,65.21 104.58,65.67 104.47,65.67 104.07,66.07 104.07,68.63 105.31,69.87 105.31,70.24 106.74,71.67 106.94,71.67 107.65,72.38 107.66,72.38 109.77,74.49 109.77,75.31 110.25,75.78 110.25,76.17 110.48,76.41 110.87,76.41 111.07,76.61 111.07,77.32 112.83,79.08 114.03,79.08 115.56,80.61 119.41,80.61 120.31,81.52 123.62,81.52 125.57,83.48 126.93,83.48 127.93,84.48 131.39,84.48 131.68,84.77 133.1,84.77 135.87,82 136.79,82 137.65,81.14 153.49,81.14 153.97,81.62 168.69,81.62 168.98,81.91 170.9,81.91 171.77,81.04 176.03,81.04 176.49,81.5 v7(176.84,81.5)
  BOTTOM w0.254: v7(80.04,53.12) 79.99,53.07 77.6,53.07 75.94,51.41 RC101.1
AC_PRESENT: length 32.3
  TOP w0.076: U34.E5 143.17,60.35 v2(143.17,60.9)
  TOP w0.122: RH137.2 119.34,59.04 119.7,59.04 120.11,58.64 RH150.1 120.69,59.1 v2(120.69,59.11)
  GND1 w0.104: v3(120.56,58.66) 120.69,58.8 v2(120.69,59.11) ; v2(143.17,60.9) 143.1,60.9 142.64,61.35 v3(142.64,61.44)
  IN1 w0.071: v3(142.64,61.44) 142.61,61.44 141.88,62.17 141.88,62.83 140.34,64.37 137.7,64.37 137.01,65.06 131.47,65.06 130.06,63.65 129.7,63.65 129.69,63.67 128.96,63.67 128.66,63.36 128.66,63.06 128,62.4 127.9,62.4 127.24,61.73 127.24,61.15 125.96,59.87 125.71,59.87 124.52,58.68 124.52,58.59 124.16,58.23 123.73,58.23 123.1,58.86 120.75,58.86 v3(120.56,58.66)
AC_PRESENT_R: length 7.2
  TOP w0.122: RH137.1 117.63,59.52 115.85,61.31 115.85,61.72 115.39,62.18 115.34,62.18 114.79,62.73 v2(114.79,62.78)
  GND1 w0.104: v3(114.43,63) 114.56,63 v2(114.79,62.78)
  IN1 w0.071: v3(114.43,63) 114.43,63.36 v4(114.56,63.49)
  IN4 w0.071: v5(114.06,63.44) 114.1,63.49 v4(114.56,63.49)
  GND5 w0.104: v5(114.06,63.44) 114.09,63.44 114.26,63.62 v6(114.45,63.62)
  BOTTOM w0.122: UH1.H19 114.39,63.55 v6(114.45,63.62)
ACC_INT1: length 27.4
  TOP w0.076: v2(161.88,65.07) 161.44,65.07 161.3,64.92 161.3,64.72 161.15,64.57 160.8,64.57 U636.F6
  TOP w0.122: v2(161.88,65.07) 161.88,65.08 163.38,66.57 164.27,66.57 R1108.2 ; U637.5 152.29,54.01 152.48,54.2 152.48,55.37 152.33,55.52 152.33,57.33 153.51,58.51 153.51,62.2 153.38,62.33 v1(153.38,62.67) 153.38,63.59 v2(153.65,63.87)
  GND1 w0.104: v2(161.88,65.07) 161.47,65.07 v3(161.44,65.1) ; v3(153.96,64.33) 153.65,64.02 v2(153.65,63.87)
  IN1 w0.071: v3(161.44,65.1) 161.64,64.9 161.64,64.43 161.34,64.12 159.31,64.12 158.87,64.57 157.91,64.57 157.65,64.31 157.65,63.94 156.94,63.23 154.88,63.23 154.35,63.76 154.35,63.93 v3(153.96,64.33)
ACC_INT2: length 19.6
  TOP w0.076: 160.7,61.81 160.64,61.81 160.3,62.15 160.3,63.42 160.05,63.67 U636.E4
  TOP w0.122: v2(161.58,60.49) 161.58,60.93 160.7,61.81 ; v2(153.87,59.04) 153.87,58.88 153.8,58.82 v1(153.8,57.9) 153.8,54.58 153.09,53.87 U637.4
  GND1 w0.104: v2(161.58,60.49) 161.55,60.47 v3(161.55,59.32) ; v3(154.76,59.7) 154.1,59.04 v2(153.87,59.04)
  IN1 w0.071: v3(161.55,59.32) 159.19,59.32 158.46,60.06 155.84,60.06 155.48,59.7 v3(154.76,59.7)
ACIN: length 112.7
  TOP w0.076: U34.F5 142.67,60.35 142.67,60.85 v2(142.56,60.96) ; v2(138.56,55.81) 138.34,55.59
  TOP w0.122: 138.34,55.59 138.33,55.58 138.33,55.33 137.73,54.72 137.73,54.54 137.28,54.09 C1116.2 R924.2 137.28,52.86 v2(137.52,52.62) ; 189.73,72.5 189.44,72.8 v7(189.44,73.43) ; 189.73,72.5 191.45,72.5 193.4,70.55 PR967.1 ; 189.73,72.5 189.73,70.98 189.29,70.54 188.27,70.54 187.71,71.09 PR954.1 ; v7(168.04,61.48) 167.38,60.82 166.91,60.82 166.71,60.62 v9(166.71,60.31) 166.71,59.31 167.14,58.88 167.14,58.36 167.55,57.95 169.65,57.95 170.11,57.49 170.11,55.71 169.15,54.75 169.15,53.91 168.41,53.17 168.41,52.81 168.99,52.22 168.99,49.09 168.64,48.73 167.9,48.73 167.32,48.15 167.32,47.59 165.16,45.43 v7(165.16,45.3)
  GND1 w0.104: v3(142.06,60.83) 142.44,60.83 v2(142.56,60.96) ; v2(138.56,55.81) 138.56,56.09 v3(137.88,56.77) ; v2(137.52,52.62) v3(138.03,52.62)
  IN1 w0.071: v3(142.06,60.83) 141.63,61.26 140.94,61.26 140.62,60.95 140.62,60.45 140.33,60.16 139.98,60.16 139.56,59.74 139.39,59.74 139.08,59.43 138.82,59.43 137.66,58.27 137.66,56.99 v3(137.88,56.77) ; v3(138.03,52.62) 138.41,52.24 138.41,52.18 v4(138.54,52.06)
  IN2 w0.094: v7(165.16,45.3) 164.82,45.64 159.62,45.64 159.26,46 146.44,46 145.14,47.3 144.02,47.3 143.14,48.19 143.14,48.81 140.49,51.45 139.02,51.45 138.54,51.93 v4(138.54,52.06)
  IN4 w0.071: v5(169.02,71.39) 171.13,73.49 186.66,73.49 186.98,73.81 188.27,73.81 188.65,73.43 v7(189.44,73.43)
  GND5 w0.104: v6(168.74,70.65) 168.89,70.8 168.89,71.26 v5(169.02,71.39)
  BOTTOM w0.122: v6(168.74,70.65) 168.64,70.55 168.64,70.22 168.87,69.99 168.87,68.44 169.91,67.4 169.91,66.98 169.4,66.47 169.4,63.56 168.04,62.2 v7(168.04,61.48)
AD_BID0: length 10.3
  TOP w0.122: v1(145.45,49.9) 145.98,49.36 R219.1 R225.2 C283.1 146.39,52.04 147.2,52.84 147.2,54.42 v2(146.91,54.71) ; v2(145.6,55.33) 145.7,55.44 145.7,56.23 145.42,56.51 U34.A12
  GND1 w0.104: v2(146.91,54.71) 146.79,54.83 v3(146.79,55.38) ; v2(145.6,55.33) v3(146.03,55.33)
  IN1 w0.071: v3(146.03,55.33) 146.74,55.33 v3(146.79,55.38)
ADET: length 8
  TOP w0.254: PQ7.1 v7(151.06,42.53)
  TOP w0.508: PR28.1 v7(147.92,41.14)
  IN4 w0.254: v7(151.06,42.53) 151.04,42.53 149.65,41.14 v7(147.92,41.14)
  BOTTOM w0.122: v1(144.69,39.41) 144.67,39.41 143.95,40.13 PD11.1
ADP_I: length 133.5
  TOP w0.122: v7(125.95,27.22) 125.93,27.22 PR936.2 ; v2(144.56,56.98) 144.56,56.98 144.92,56.62 U34.B12
  GND1 w0.104: v3(145.54,56.6) 144.94,56.6 v2(144.56,56.98)
  IN1 w0.071: v3(145.54,56.6) 145.94,56.6 146.12,56.79 147.14,56.79 147.84,57.49 148.03,57.49 148.18,57.65 148.88,57.65 149.03,57.49 149.38,57.49 149.68,57.2 151.33,57.2 152.03,56.5 158.08,56.5 158.5,56.08 159.42,56.08 159.43,56.09 163.08,56.09 163.55,55.61 164.41,55.61 166.23,53.79 168.9,53.79 170.04,52.65 171.97,52.65 172.21,52.41 174.7,52.41 176.92,50.19 176.92,46.06 177.72,45.26 177.72,38.51 178.06,38.17 178.06,36.5 178.76,35.8 178.76,34.88 177.4,33.52 177.4,32.4 177.5,32.3 177.5,31.85 175.88,30.22 175.88,29.51 173.42,27.04 166.15,27.04 165.62,27.57 150.81,27.57 v7(150.5,27.27) 149.94,27.83 147.92,27.83 147.25,27.17 145.03,27.17 143.43,25.57 142.38,25.57 142.03,25.22 139.53,25.22 138.87,24.56 134.42,24.56 133.69,25.29 127.88,25.29 v7(125.95,27.22)
  BOTTOM w0.122: PC38.1 152.57,38.75 153.04,38.28 154.62,38.28 155.46,37.44 v1(155.46,33.88) 151.72,30.14 151.72,29.51 150.5,28.3 v7(150.5,27.27)
  BOTTOM w0.254: PC38.1 152.57,39.04 152.18,39.43 151.59,39.43 151.14,38.98 151.14,38.62 150.82,38.31 PU2.9
ADPIN: length 2.3
  TOP w0.508: PC901.1 PC900.1 191.36,81.57 190.57,82.36 v7(190.57,82.49)
  vias: v9(188.75,78.65) v9(189.44,82.05) v9(189.73,80.19)
AGATE: length 17.3
  TOP w0.254: v7(156.42,44.06) 157.22,44.86 v9(157.22,44.96) 157.36,45.1 161.21,45.1 PR20.2
  IN4 w0.254: v7(146.62,40.09) 146.62,40.65 147.63,41.67 148.27,41.67 150.25,43.65 150.83,43.65 151.24,44.06 v7(156.42,44.06)
ALS_SMBCLK: length 56.3
  TOP w0.122: v2(130.41,79.5) 130.36,79.5 R985.1 R983.1
  GND1 w0.104: v2(130.41,79.5) v3(130.41,79.95)
  IN1 w0.071: v4(181.52,80.15) 179.75,80.15 179.22,79.62 151.92,79.62 151.51,80.04 134.58,80.04 133.81,80.8 133.43,80.8 132.93,80.3 130.77,80.3 v3(130.41,79.95)
  IN4 w0.071: v4(181.52,80.15) v5(182.04,80.15)
  GND5 w0.104: v6(182.07,80.58) 182.07,80.19 v5(182.04,80.15)
  BOTTOM w0.122: JLVDS2.7 182.24,80.41 v6(182.07,80.58)
ALS_SMBDATA: length 53.9
  TOP w0.122: R986.1 R984.1 v1(133.69,80.29) 133.68,80.29 v7(132.91,81.06)
  IN1 w0.071: v7(132.91,81.06) 132.98,80.99 133.87,80.99 134.65,80.21 151.71,80.21 152.05,79.87 179.2,79.87 179.69,80.35 180.4,80.35 180.73,80.68 181.31,80.68 v7(181.49,80.86)
  BOTTOM w0.122: JLVDS2.8 181.74,80.4 181.64,80.51 181.64,80.71 v7(181.49,80.86)
AOAC_THERMAL: length 256.5
  TOP w0.203: U34.D7 144.11,59.3 144.22,59.4 v2(144.28,59.4)
  TOP w0.254: v7(64.07,23.84) 63.52,24.38 R928.1 ; v2(149.16,59.8) 149.72,59.25 R927.2
  GND1 w0.104: v2(144.28,59.4) 144.62,59.74 v3(144.67,59.74)
  GND1 w0.254: v2(149.16,59.8) 148.83,59.8 v3(148.72,59.91)
  IN1 w0.203: v3(144.67,59.74) 144.87,59.74 145.19,59.42 145.46,59.42 145.5,59.46 146.16,59.46 146.32,59.3 146.88,59.3 146.96,59.22 147.7,59.22 148.31,59.83 148.65,59.83 v3(148.72,59.91) 148.82,60 149.86,60 150.55,60.69 150.55,61.13 151.14,61.71 v4(151.14,61.66)
  IN1 w0.254: v7(64.07,23.84) 63.46,23.23 63.46,21.1 64.79,19.76 67.08,19.76 67.47,20.15 70.24,20.15 70.64,20.55 72.35,20.55 73.01,19.9 75.21,19.9 76.04,20.73 82.51,20.73 83.27,19.98 86.54,19.98 87.66,21.09 106.53,21.09 106.64,21.2 113.4,21.2 114.42,20.18 120.99,20.18 121.7,20.89 127.95,20.89 130.79,23.74 134.02,23.74 136.02,21.73 140.9,21.73 142.91,23.74 147.43,23.74 v7(148.14,23.03)
  IN2 w0.203: v4(151.14,61.66) 150.54,61.66 149.62,62.59 148.73,62.59 146.87,64.45 144.88,64.45 144.3,65.03 136.59,65.03 134.88,63.31 132.91,63.31 v4(132.54,63.68)
  IN4 w0.203: v4(132.54,63.68) 132.75,63.88 v5(132.75,64.35)
  IN4 w0.254: v7(148.14,23.03) 149.54,24.42 163.28,24.42 163.77,23.94 169.45,23.94 170.85,25.34 170.85,28.12 173.26,30.53 173.26,38.93 172.91,39.28 172.91,41.76 171.34,43.33 170.97,43.33 167.19,47.12 164.83,47.12 163.58,45.86 159.65,45.86 159.43,46.08 155.77,46.08 v5(155.53,46.32)
  GND5 w0.203: v5(132.75,64.35) v6(132.75,64.78)
  GND5 w0.254: v6(155.33,47.18) 155.33,46.52 v5(155.53,46.32)
  BOTTOM w0.254: v6(155.33,47.18) 154.1,47.18 152.67,48.6 149.88,48.6 149.43,49.05 149.43,55.2 152.92,58.69 152.92,69.08 152.64,69.35 152.64,70.41 151.57,71.48 151.57,72.89 152.69,74.01 152.69,75.98 v9(152.86,76.16) 152.86,76.34 151.95,77.25 140.1,77.25 139.36,76.52 139.36,75.95 138.26,74.84 138.26,71.92 136.15,69.81 136.15,69.6 135.27,68.72 135.27,68.64 132.75,66.11 v6(132.75,64.78)
APWROK_R: length 15.5
  TOP w0.122: RH131.2 123.68,59.41 v2(123.83,59.56)
  GND1 w0.104: v2(123.83,59.56) 123.58,59.56 v3(123.37,59.35)
  IN1 w0.071: v3(123.37,59.35) 123.57,59.55 v4(124.59,59.55)
  IN2 w0.094: v4(124.59,59.55) 123.48,59.55 122.91,58.98 120.62,58.98 120.35,59.25 118.94,59.25 118.51,58.81 117.37,58.81 115.01,56.46 v4(114.66,56.46)
  IN4 w0.071: v5(114.18,56.12) 114.21,56.12 114.54,56.46 v4(114.66,56.46)
  GND5 w0.104: v5(114.18,56.12) 114.15,56.15 v6(114.15,56.55)
  BOTTOM w0.122: UH1.G3 v6(114.15,56.55)
AUD_MUTE#: length 164.8
  TOP w0.076: 138.4,56.24 138.54,56.38 139.12,56.38 139.35,56.6 U34.N12
  TOP w0.122: 138.4,56.24 v2(138.16,55.99) ; v2(25.41,44.46) 25.65,44.7 31.38,44.7 31.96,44.12 36.85,44.12 37.53,44.81 54.55,44.81 55.33,44.03 63.23,44.03 63.45,44.24 80.82,44.24 81.11,44.53 83.9,44.53 89.72,50.36 91.95,50.36 94.2,52.6 94.37,52.6 v1(94.58,52.81) v2(95.04,53.28)
  GND1 w0.104: v2(95.04,53.28) 95.04,53.54 95.05,53.55 v3(95.05,53.75) ; v3(137.43,56.38) 137.81,55.99 v2(138.16,55.99) ; v2(25.41,44.46) v3(24.98,44.46)
  IN1 w0.071: v3(137.43,56.38) 137.32,56.38 136.94,56 130.07,56 128.05,53.98 126.99,53.98 126.85,54.13 125.68,54.13 124.01,52.46 119.72,52.46 119.37,52.82 119.06,52.82 118.51,52.27 113.19,52.27 112.96,52.04 111.7,52.04 111.28,52.46 107.11,52.46 106.46,53.11 106.46,53.62 106.05,54.03 103.05,54.03 102.7,53.68 102.45,53.68 102.11,54.02 95.32,54.02 v3(95.05,53.75) ; v3(24.98,44.46) 25.28,44.77 v4(25.28,44.89)
  IN2 w0.094: v7(17.81,20.89) 17.22,21.49 16.44,21.49 15.61,22.32 15.61,22.43 13.99,24.04 13.99,27.5 14.59,28.1 14.59,29.33 14.79,29.53 14.79,30.08 15.07,30.35 15.07,35.38 14.6,35.85 14.6,39.41 15.42,40.23 15.42,40.91 15.73,41.23 15.73,41.97 16.59,42.83 16.59,43.37 16.17,43.8 16.17,44.16 16.58,44.57 16.58,45.61 18.21,47.24 23.64,47.24 25.28,45.61 v4(25.28,44.89)
  BOTTOM w0.122: JIOL1.17 18.1,20.6 v7(17.81,20.89)
B+: length 26.6
  TOP w0.254: 182.51,84.09 182.3,84.29 179.59,84.29 178.92,83.63 PQ903.3 ; 182.51,84.09 PR908.1 ; 182.51,84.09 182.68,84.26 186.95,84.26 187.37,83.85 PC908.1
  TOP w0.508: R535.1 164.78,85.4 v7(164.78,85.94) ; C613.1 v7(163.89,85.94)
  IN1 w3.048: 129.27,43.32 124.77,38.82 118.09,38.82 117.23,39.69
  vias: v7(8.71,26.76) v7(8.71,26.12) v7(9.34,26.76) v7(9.34,26.12) v7(9.98,26.76) v7(9.98,26.12) v7(18.22,54.83) v7(18.22,53.94) v7(18.85,53.43) v7(19.36,52.79) v7(19.74,53.43) v7(20.5,54.83) v7(20.5,53.94) v7(26.33,54.94) v7(26.33,54.18) v7(26.6,53.17) v7(27.24,53.68) v7(28.25,53.68) v7(29.01,54.95) v7(29.01,54.32) v7(29.01,53.17) v7(41.36,22.09) v7(41.36,21.45) v7(41.99,22.09) v7(41.99,21.45) v7(42.63,22.09) v7(42.63,21.45) v7(114.59,40.91) v7(114.56,40.17) v7(114.56,39.51) v7(115.22,40.88) v7(115.22,40.22) v7(115.25,39.51) v7(129.5,33.82) v7(129.5,33.19) v7(130.13,33.82) v7(130.13,33.19) v7(130.77,33.85) v7(132.14,44.97) v7(132.14,44.34) v7(132.77,44.97) v7(132.77,44.34) v7(133.48,44.97) v7(133.48,44.34) v7(134.12,44.97) v7(134.12,44.34) v7(134.8,45) v7(134.8,44.36) v7(146.62,76.29) v7(146.62,75.65) v7(147.25,76.29) v7(147.25,75.65) v7(147.89,76.29) v7(147.89,75.65) v7(148.52,76.29) v7(148.52,75.65) v7(149.16,76.29) v7(149.16,75.65) v7(149.79,76.29) v7(149.79,75.65) v7(150.43,76.29) v7(150.43,75.65) v7(151.06,76.29) v7(151.06,75.65) v7(151.7,76.29) v7(151.7,75.65) v7(159.32,83.15) v7(159.95,83.15) v7(160.59,83.15) v7(172.9,84.29) v7(195.76,74.05) v7(196.4,74.08) v7(196.4,73.44) v7(197.03,74.08) v7(197.03,73.44) v7(197.67,74.71) v7(197.67,74.08) v7(197.67,73.44) v7(198.36,74.08) v7(198.36,73.44) v9(25.15,52.06)
B++: length 20.8
  TOP w0.254: PR219.1 186.1,54.67 189.61,54.67 190.02,54.27 191.57,54.27
  IN3 w0.508: v7(195.66,60.03) 196.17,59.52 196.17,58.72 195.83,58.38 195.83,57.66 194.67,56.5 194.67,55.41 193.45,54.19 v7(191.65,54.19)
  BOTTOM w0.254: PC216.1 191.52,54.67 191.65,54.55 v7(191.65,54.19) 189.93,54.19 189.58,54.54 189.58,55.6 v9(189.43,55.75) 189.21,55.97 PD200.1
BATBTN#: length 164.9
  TOP w0.076: U34.B4 145.17,60.85 145.85,60.85 v2(145.85,60.85)
  TOP w0.122: v7(216.44,45.63) 215.23,44.42 215.23,25.57 220.68,20.12 222.5,20.12 225.28,22.9 v1(226.44,22.9) 228.18,22.9 228.91,22.16 C1122.1 230.37,21.42 SW1.3 SW1.1 ; R937.2 149.88,63.62 D84.1 149.88,62.57 149.66,62.34 v2(149.18,62.34)
  GND1 w0.104: v3(148.75,62.22) 148.88,62.34 v2(149.18,62.34) ; v2(145.85,60.85) 145.74,60.96 v3(145.35,60.96)
  IN1 w0.071: v4(148.42,61.79) 148.16,61.53 147.91,61.53 147.54,61.16 145.73,61.16 145.73,61.16 145.55,61.16 v3(145.35,60.96)
  IN1 w0.084: v4(148.42,61.79) 148.75,62.12 v3(148.75,62.22)
  IN2 w0.094: v7(216.44,45.63) 215.98,46.09 215.98,52.79 215.39,53.39 211.91,53.39 209.84,55.45 208.76,55.45 208.22,55.99 208.22,56.77 209.71,58.25 209.71,71.11 209.91,71.31 209.91,74.76 208.84,75.83 201.59,75.83 199.31,78.11 197.8,78.11 197.02,78.89 194.97,78.89 194.18,79.69 190.75,79.69 188.26,77.2 188.26,76.05 187.85,75.64 187.74,75.64 182.58,70.48 181.35,70.48 180.42,69.55 179.68,69.55 176.9,66.78 176.9,62.52 174.92,60.53 171.68,60.53 171.41,60.27 168.33,60.27 167.68,59.61 164.58,59.61 164.45,59.74 156.67,59.74 156.39,60.02 153.67,60.02 153.2,59.55 152.4,59.55 152.16,59.32 150.72,59.32 149.57,60.48 149.31,60.48 148.42,61.37 v4(148.42,61.79)
BATT+: length 2.5
  TOP w0.508: PC905.1 v7(121.34,32.73) ; PR47.2 v7(122.23,32.73) ; PC904.1 v7(123.12,32.73)
  vias: v9(109,37.99)
BATT++: length 0.9
  TOP w0.122: v7(130.18,41.49) v9(130.18,42.34)
  vias: v7(128.86,39.92) v7(129.57,40.35) v7(129.6,39.66) v7(129.62,39) v7(130.49,21.3) v7(130.49,20.66) v7(130.89,41.49) v7(131.12,21.68) v7(131.76,21.68) v7(132.26,22.95) v7(132.26,22.31) v7(132.39,21.68)
BATT_CHG_LED#: length 171.9
  TOP w0.122: U34.A4 145.49,60.53 146.21,60.53 146.37,60.69 146.37,60.8 146.56,60.99 v2(146.56,62.38) ; v2(95.18,54.42) 95.18,54.29 91.74,50.85 89.52,50.85 83.7,45.03 80.9,45.03 80.61,44.74 57.93,44.74 57.81,44.63 55.44,44.63 54.73,45.33 37.35,45.33 36.64,44.62 32.16,44.62 31.59,45.2 25.83,45.2 25.17,45.86 24.7,45.86 23.96,45.12 22.79,45.12 v1(21.98,44.31) 21.5,43.83 20.91,43.83 20.5,44.23 20.5,44.35 20.09,44.77 v7(20.02,44.77)
  GND1 w0.104: v3(95.49,54.75) 95.18,54.44 v2(95.18,54.42) ; v3(146.78,62.88) 146.78,62.86 146.56,62.64 v2(146.56,62.38)
  IN1 w0.071: v3(95.49,54.75) 95.51,54.75 95.87,55.11 96.02,55.11 96.42,55.51 99.39,55.51 100.17,54.72 106.41,54.72 106.6,54.53 107.87,54.53 107.93,54.59 108.64,54.59 108.82,54.41 111.89,54.41 111.99,54.31 116.81,54.31 117.12,54.62 121.17,54.62 121.43,54.88 124.56,54.88 125.52,55.84 127.46,55.84 130.87,59.25 130.87,59.37 131.86,60.36 132.32,60.36 133.73,61.77 134.35,61.77 134.85,62.26 134.85,62.89 135.62,63.67 138.09,63.67 v4(138.53,63.22) ; v4(146.39,63.18) 146.48,63.18 v3(146.78,62.88)
  IN2 w0.094: v4(146.39,63.18) 145.43,62.23 143.46,62.23 142.28,63.41 138.72,63.41 v4(138.53,63.22) ; v7(19.11,21.53) 19.79,22.21 19.79,24.09 19.2,24.67 18.37,24.67 17.8,25.25 17.8,29.86 17.59,30.07 17.59,39.3 17.81,39.52 17.81,40.06 18.49,40.73 18.89,40.73 19.64,41.48 19.64,44.39 v7(20.02,44.77)
  BOTTOM w0.122: JIOL1.25 20.1,20.51 20.17,20.59 20.17,21.09 19.74,21.53 v7(19.11,21.53)
BATT_LED#_LV1: length 121.6
  TOP w0.076: v2(145.78,57.24) 145.66,57.35 145.23,57.35 144.98,57.6 U34.B10
  TOP w0.122: v2(220.89,20.92) 220.89,21.82 220.82,21.88 v1(220.82,22.42) R906.1 220.95,23.62 Q316.2
  GND1 w0.104: v2(220.89,20.92) v3(220.89,20.37) ; v3(145.42,58.29) 145.31,58.17 145.31,57.71 v2(145.78,57.24)
  IN1 w0.071: v4(146.39,58.52) 146.15,58.29 v3(145.42,58.29) ; v4(220.89,19.82) v3(220.89,20.37)
  IN2 w0.094: v4(146.39,58.52) 146.76,58.52 147.04,58.8 149.9,58.8 150.34,58.36 150.91,58.36 151.61,57.66 154.49,57.66 154.66,57.84 155.12,57.84 155.16,57.79 156.45,57.79 156.85,57.39 159.9,57.39 160.15,57.14 161.4,57.14 161.86,56.67 165.23,56.67 165.54,56.36 168.08,56.36 168.8,57.09 170.43,57.09 172.32,58.98 179.97,58.98 183.69,55.26 189.03,55.26 191.49,52.8 203.84,52.8 205.53,54.49 209.9,54.49 211.58,52.8 215.14,52.8 215.4,52.55 215.4,21.08 217.35,19.12 219.87,19.12 220.57,19.82 v4(220.89,19.82)
BATT_LED#_LV2: length 137.3
  TOP w0.076: v2(144.52,58.62) 144.52,58.5 144.92,58.1 U34.B9
  TOP w0.122: Q317.2 228.12,9.61 v2(229.29,10.79)
  GND1 w0.104: v2(229.29,10.79) v3(229.29,11.28) ; v2(144.52,58.62) 144.55,58.65 v3(145.19,58.65)
  IN1 w0.071: v3(229.29,11.28) v4(229.29,10.24) ; v3(145.19,58.65) 145.19,58.66 145.21,58.64 145.82,58.64 v4(145.83,58.65)
  IN2 w0.094: v4(145.83,58.65) 146.22,59.04 149.94,59.04 150.42,58.56 150.99,58.56 151.69,57.86 154.41,57.86 154.6,58.05 155.18,58.05 155.24,57.99 156.58,57.99 156.99,57.59 159.98,57.59 160.22,57.34 161.58,57.34 162.05,56.86 165.57,56.86 165.86,56.58 167.66,56.58 168.98,57.9 170.96,57.9 172.24,59.18 180.28,59.18 183.65,55.8 189.26,55.8 189.88,55.18 191.55,55.18 192.92,53.81 198.75,53.81 199.45,53.11 201.75,53.11 203.25,54.61 204.29,54.61 204.36,54.69 209.98,54.69 211.66,53 215.22,53 215.59,52.63 215.59,21.16 217.43,19.32 219.64,19.32 220.65,20.33 221.43,20.33 222.05,19.71 223.43,19.71 223.95,20.22 227.41,20.22 229.32,18.31 229.32,10.26 v4(229.29,10.24)
BATT_LED#_LV3: length 151.9
  TOP w0.076: 140.29,63.08 140.29,63.04 140.48,62.85 140.48,62.43 140.67,62.24 140.67,61.85 U34.K2
  TOP w0.122: Q318.2 225.83,7.2 v2(225.1,6.47) ; v2(140.19,63.59) 140.29,63.49 140.29,63.08
  GND1 w0.104: v2(140.19,63.59) 140.29,63.49 140.29,63.12 v3(140.29,63.12) ; v2(225.1,6.47) v3(225.59,6.47)
  IN1 w0.071: v4(140.32,62.64) 140.29,62.66 140.29,63.12 v3(140.29,63.12) ; v3(225.59,6.47) v4(226.19,6.47)
  IN2 w0.094: v4(226.19,6.47) 226.3,6.47 229.75,9.92 229.75,18.21 227.54,20.42 223.86,20.42 223.35,19.9 222.13,19.9 221.51,20.52 220.57,20.52 219.56,19.51 217.51,19.51 215.79,21.24 215.79,52.71 215.3,53.2 211.83,53.2 209.76,55.26 208.68,55.26 208.22,55.72 202.62,55.72 202.29,55.38 200.95,55.38 200.46,54.9 199.77,54.9 198.88,54.01 192.99,54.01 192.01,55 192.01,56.12 191.45,56.68 189.66,56.68 189.11,56.13 183.8,56.13 180.56,59.37 172.16,59.37 171,58.21 168.9,58.21 167.56,56.87 166.1,56.87 165.91,57.06 162.13,57.06 161.65,57.55 160.29,57.55 159.39,58.45 156.32,58.45 155.9,58.86 155.13,58.86 154.33,58.06 151.77,58.06 151.07,58.75 150.5,58.75 150.02,59.24 145.62,59.24 142.04,62.82 140.49,62.82 140.32,62.65 v4(140.32,62.64)
BATT_LED#_LV4: length 142.6
  TOP w0.076: 140.94,63.08 140.94,62.57 141.17,62.34 141.17,61.85 U34.J2
  TOP w0.122: v2(226.06,12.03) 225.32,12.03 R917.1 ; v2(140.89,63.3) 140.94,63.25 140.94,63.08
  GND1 w0.104: v2(140.89,63.3) 140.89,63.37 v3(140.62,63.64) ; v2(226.06,12.03) v3(225.53,12.03)
  IN1 w0.071: v4(141.28,62.41) 141.28,62.98 v3(140.62,63.64) ; v3(225.53,12.03) v4(226.52,12.03)
  IN2 w0.094: v4(226.52,12.03) 226.75,12.03 228.92,14.2 228.92,18.34 227.24,20.02 224.02,20.02 223.29,19.29 220.32,19.29 219.95,18.93 217.27,18.93 215.2,21 215.2,52.47 215.06,52.61 191.3,52.61 189.14,54.77 180.9,54.77 176.89,58.78 172.4,58.78 170.51,56.89 169.06,56.89 168.31,56.13 165.04,56.13 164.7,56.47 161.78,56.47 161.34,56.92 160.09,56.92 159.82,57.19 156.48,57.19 156.27,56.99 154.4,56.99 153.98,57.4 150.2,57.4 149.88,57.72 149.88,58.33 149.61,58.61 148.13,58.61 147.62,58.1 145.84,58.1 145.43,58.51 145.43,59.04 142.07,62.41 v4(141.28,62.41)
BATT_LED#_LV5: length 152
  TOP w0.076: 138.23,59.02 138.35,59.13 139.06,59.13 139.28,59.35 139.67,59.35 U34.M6
  TOP w0.122: 138.23,59.02 v2(138.07,58.85) ; v2(225.11,5.01) 225.49,5.01 225.71,4.79 Q320.2
  GND1 w0.104: v2(138.07,58.85) 138.17,58.75 v3(138.61,58.75) ; v2(225.11,5.01) 225.11,5.28 v3(225.25,5.42)
  IN1 w0.071: v4(163.51,54.44) 163.51,54.93 162.86,55.57 160.39,55.57 159.8,54.98 v4(159.8,54.37) ; v4(224.8,5.64) 225.01,5.42 v3(225.25,5.42) ; v3(138.61,58.75) 138.69,58.83 139.44,58.83 v4(140.08,59.46)
  IN2 w0.094: v4(159.8,54.37) 159.8,54.69 159.39,55.1 158.06,55.1 157.54,55.62 146.38,55.62 144.06,57.94 144.06,58.47 142.73,59.8 140.42,59.8 v4(140.08,59.46) ; v4(224.8,5.64) 224.58,5.85 224.58,8.7 224.75,8.86 224.75,11.44 228.56,15.25 228.56,18.3 227.03,19.82 224.1,19.82 223.37,19.09 220.4,19.09 220.03,18.73 217.19,18.73 215.01,20.92 215.01,52.39 214.98,52.41 191.22,52.41 189.12,54.51 180.64,54.51 176.56,58.59 172.48,58.59 170.59,56.7 169.28,56.7 168.2,55.62 164.07,55.62 163.51,55.05 v4(163.51,54.44)
BATT_LED_LV1: length 16.2
  TOP w0.122: Q316.3 222.61,22.97 222.99,22.59 224.57,22.59 v2(225.28,23.3) ; v2(230.18,14.38) 229.5,14.38 v1(229.23,14.66)
  GND1 w0.104: v2(225.28,23.3) v3(225.74,23.3) ; v2(230.18,14.38) v3(230.18,14.94)
  IN1 w0.071: v3(225.74,23.3) 225.74,22.38 230.18,17.93 v3(230.18,14.94)
BATT_LED_LV2: length 3
  TOP w0.122: R911.2 229.77,11.24 228.94,11.24 228.78,11.09 228.78,10.67 228.38,10.26 Q317.3
BATT_LED_LV3: length 6
  GND1 w0.104: v2(230.18,8.54) v3(230.18,8.01) ; v2(226.06,6.55) v3(226.67,6.55)
  IN1 w0.071: v3(226.67,6.55) 229.93,6.55 230.18,6.81 v3(230.18,8.01)
BATT_LED_LV4: length 8.4
  GND1 w0.104: v2(226.06,11.38) v3(226.52,11.38) ; v2(230.18,7.01) v3(229.74,7.01)
  IN1 w0.071: v3(226.52,11.38) 226.52,11.37 226.52,7.68 227.48,6.72 229.55,6.72 229.74,6.91 v3(229.74,7.01)
BATT_LED_LV5: length 5.7
  TOP w0.122: Q320.3 226.6,4.14 227.05,3.7 228.76,3.7 228.96,3.49 229.31,3.49 229.94,2.86 v1(230.08,2.86) 230.14,2.86 230.18,2.91 R916.2
BATT_LOW_LED#: length 166.4
  TOP w0.122: v2(95.64,54.25) 95.43,54.04 95.37,54.04 94.94,53.62 94.86,53.62 91.85,50.6 89.62,50.6 83.8,44.78 81.01,44.78 80.71,44.49 63.35,44.49 63.13,44.27 55.44,44.27 54.66,45.05 37.43,45.05 36.74,44.37 32.06,44.37 31.48,44.95 25.26,44.95 v1(25.13,44.82) 25.1,44.82 24.35,44.07 22.85,44.07 22.27,43.48 20.7,43.48 v7(20.05,44.13) ; v2(145.92,62.32) 145.92,62.32 145.92,62.2 145.42,61.71 U34.A2
  GND1 w0.104: v2(95.64,54.25) 95.64,54.32 95.92,54.6 v3(95.92,54.72) ; v3(146.03,62.8) 145.92,62.69 v2(145.92,62.32)
  IN1 w0.071: v3(95.92,54.72) 96.51,55.32 99.31,55.32 100.08,54.55 106.32,54.55 106.53,54.34 107.95,54.34 108.01,54.4 108.56,54.4 108.75,54.22 111.81,54.22 111.91,54.12 116.89,54.12 117.21,54.44 121.24,54.44 121.49,54.7 124.64,54.7 125.6,55.65 127.53,55.65 131.04,59.16 131.04,59.29 131.93,60.18 132.39,60.18 133.8,61.59 134.43,61.59 135.46,62.61 135.95,62.61 136.55,63.22 v4(137.89,63.22) ; v3(146.03,62.8) 145.78,63.06 v4(145.78,63.23)
  IN2 w0.094: v4(137.89,63.22) 138.27,63.6 142.36,63.6 143.42,62.55 145.09,62.55 v4(145.78,63.23) ; v7(19.72,20.92) 19.99,21.18 19.99,24.17 19.28,24.87 18.45,24.87 17.99,25.33 17.99,29.95 17.79,30.15 17.79,39.22 18.01,39.44 18.01,39.98 18.54,40.51 18.95,40.51 20.17,41.74 20.17,44.01 v7(20.05,44.13)
  BOTTOM w0.122: v7(19.72,20.92) 19.6,20.8 JIOL1.23
BATT_PRS: length 18.4
  TOP w0.122: PD905.2 128.18,19.16 v7(122.1,19.16) 121.34,19.93 PR915.1 120.48,24.6 v1(120.07,24.19)
  BOTTOM w0.122: v7(122.1,19.16) 122.45,19.16 122.87,19.59 JBATT9.5
BBS_BIT0_R: length 4.3
  BOTTOM w0.122: UH1.R1 110.68,55.91 110.68,54.11 111.23,53.56 111.32,53.56 v1(111.56,53.31) RH276.2
BBS_BIT1: length 4.7
  TOP w0.122: v2(115.45,71.92) 115.72,72.19 RH291.1 116.14,72.48 v1(116.91,71.7)
  GND1 w0.104: v3(115.88,72.17) 115.63,71.92 v2(115.45,71.92)
  IN1 w0.071: v4(115.4,72.17) v3(115.88,72.17)
  IN4 w0.071: v4(115.4,72.17) 115.4,72.61 v5(115.35,72.66)
  GND5 w0.104: v5(115.35,72.66) v6(114.85,72.66)
  BOTTOM w0.122: UH1.F42 v6(114.85,72.66)
BEEP#: length 171.3
  TOP w0.076: U34.M8 139.67,58.35 139.07,58.35 v2(139.01,58.29)
  TOP w0.122: v2(24.8,44.03) 25.51,44.03 25.93,44.45 31.28,44.45 31.86,43.87 36.95,43.87 37.63,44.56 54.45,44.56 55.23,43.78 63.34,43.78 63.55,43.99 80.92,43.99 81.21,44.28 84.01,44.28 89.44,49.72 v9(90.63,49.72) 91.67,49.72 94.26,52.32 94.65,52.32 95.43,53.11 v2(95.43,53.56)
  GND1 w0.104: v3(138.49,57.42) 138.49,57.77 v2(139.01,58.29) ; v3(95.84,53.71) 95.59,53.71 v2(95.43,53.56) ; v2(24.8,44.03) v3(24.37,44.03)
  IN1 w0.071: v3(138.49,57.42) 138.2,57.13 138.2,54.31 136.15,52.26 134.04,52.26 133.03,53.27 125.83,53.27 124.64,52.08 113.27,52.08 113.03,51.85 111.62,51.85 111.26,52.22 107.08,52.22 106.24,53.06 106.24,53.58 105.96,53.86 103.14,53.86 102.78,53.5 102.37,53.5 102.04,53.83 95.96,53.83 v3(95.84,53.71) ; v3(24.37,44.03) v4(24.37,43.55)
  IN2 w0.094: v4(24.37,43.55) 24.54,43.55 25.7,44.7 25.7,45.61 23.86,47.45 18.13,47.45 16.38,45.7 16.38,44.65 15.97,44.24 15.97,43.72 16.38,43.31 16.38,42.89 15.42,41.94 15.42,41.2 15.22,40.99 15.22,40.31 14.4,39.49 14.4,35.77 14.87,35.3 14.87,30.43 14.6,30.16 14.6,29.62 14.4,29.41 14.4,28.18 13.8,27.58 13.8,23.89 15.41,22.28 15.41,22.24 16.38,21.27 16.8,21.27 v7(17.18,20.89)
  BOTTOM w0.122: v7(17.18,20.89) 17.6,20.47 JIOL1.15
BGATE: length 2.9
  BOTTOM w0.254: PR46.1 150.71,33.97 150.08,34.6 v7(149.57,34.6) 149.57,34.63 149.41,34.78 149.39,34.78 149.19,34.98 149.19,34.98 149.16,35.02 149.16,35.04 149.12,35.07 PU2.16
BKOFF#: length 39.1
  TOP w0.122: v2(146.25,64.5) 146.25,64.48 145.3,63.53 144.75,63.53 144.45,63.23 144.05,63.23 143.86,63.04 143.72,63.04 143.56,62.88 143.56,62.24 U34.E1 ; v7(168.45,71.11) 167.16,72.39 167.16,72.75 167.16,72.89 v1(166.92,73.13) D72.2
  GND1 w0.104: v2(146.25,64.5) 146.45,64.71 v3(146.79,64.71)
  IN1 w0.071: v4(146.64,65.29) 146.64,64.86 v3(146.79,64.71)
  IN2 w0.094: v7(168.45,71.11) 168.45,70.8 168.6,70.65 168.6,69.77 167.86,69.03 167.86,68.66 166.83,67.64 166.83,64.95 165.36,63.48 163.59,63.48 163.35,63.24 161.94,63.24 161.79,63.39 159.13,63.39 158.53,64 157.96,64 157.4,63.44 156.12,63.44 155.8,63.12 149.99,63.12 149.88,63.23 149,63.23 147.14,65.09 146.84,65.09 v4(146.64,65.29)
BMON: length 120.2
  TOP w0.122: v7(124.66,29.6) 124.66,30.99 124.18,31.47 v1(124.18,32.58) 124.84,33.24 PR960.2 PC1914.1 ; U34.A13 145.42,55.62 145.26,55.46 145.26,55.04 144.98,54.76 144.98,53.63 144.8,53.45 143.21,53.45 v7(142.27,52.51)
  IN2 w0.094: v7(124.66,29.6) 124.66,29.13 122.46,26.94 122.46,24.65 122.8,24.31 125.22,24.31 126.25,25.34 140.73,25.34 143.66,28.26 147.28,28.26 147.48,28.06 156.57,28.06 157.17,28.66 170.02,28.66 172.81,31.45 172.81,32.34 175.09,34.62 175.09,40.23 171.87,43.44 170.68,43.44 169.41,44.71 168.03,44.71 166.91,45.83 159.7,45.83 159.34,46.19 146.52,46.19 145.22,47.5 144.1,47.5 143.33,48.27 143.33,48.89 142.27,49.95 v7(142.27,52.51)
