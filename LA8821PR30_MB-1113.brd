# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_PRX_DTX_N0: length 84
  IN4 w0.071: v7(181.57,55.21) 181.4,55.37 180.54,55.37 179.7,56.21 177.76,56.21 177.22,55.68 170.58,55.68 169.35,54.44 168,54.44 167.48,54.97 164.56,54.97 163.9,55.63 158.39,55.63 158.2,55.82 149.23,55.82 148.76,55.35 137.17,55.35 136.65,55.87 129.32,55.87 128.65,55.2 121.46,55.2 121.32,55.06 119.53,55.06 118.92,55.66 117.3,55.66 116.89,56.08 115.36,56.08 114.25,54.97 111.19,54.97 111.02,55.15 107.71,55.15 106.84,56.02 105,56.02 104.16,56.86 104.02,56.86 103.97,56.81 103.97,56.63 v5(104.06,56.54)
  GND5 w0.089: v5(104.06,56.54) 104.06,56.93 v6(103.99,57)
  BOTTOM w0.104: CS53.1 180.87,55.25 181.12,55.5 181.28,55.5 v7(181.57,55.21) ; v6(103.99,57) UH1.AN3
SATA_PRX_DTX_N0_C: length 5
  BOTTOM w0.104: CS53.2 179.67,55.37 179.03,55.37 v7(178.82,55.57) 177.7,56.69 177.06,56.69 176.79,56.42 JSATA1.25
SATA_PRX_DTX_P0: length 84
  IN4 w0.071: v5(103.58,57.1) 103.62,57.06 103.92,57.06 103.97,57.11 104.26,57.11 105.1,56.27 106.94,56.27 107.81,55.4 111.12,55.4 111.3,55.22 114.15,55.22 115.26,56.33 116.99,56.33 117.41,55.91 119.02,55.91 119.63,55.31 121.22,55.31 121.36,55.45 128.55,55.45 129.22,56.12 136.75,56.12 137.27,55.6 148.66,55.6 149.13,56.07 158.3,56.07 158.49,55.87 164,55.87 164.66,55.21 167.59,55.21 168.11,54.69 169.25,54.69 170.48,55.93 177.12,55.93 177.65,56.46 179.8,56.46 180.64,55.62 181.35,55.62 v8(181.57,55.84)
  GND5 w0.089: v6(103.59,56.54) 103.58,56.55 v5(103.58,57.1)
  BOTTOM w0.104: CS54.1 181.08,55.77 181.49,55.77 v8(181.57,55.84) ; v6(103.59,56.54) UH1.AN1
SATA_PRX_DTX_P0_C: length 5
  BOTTOM w0.104: CS54.2 179.63,55.64 179.14,55.64 v7(178.09,56.69) 177.82,56.96 177.05,56.96 176.78,57.22 JSATA1.23
SATA_PTX_DRX_N0: length 89.4
  IN4 w0.071: v8(182.1,53.56) 182.1,53.44 182.19,53.35 182.47,53.35 182.56,53.44 182.56,53.74 182.26,54.04 178.49,54.04 177.44,52.99 170.43,52.99 169.63,52.19 168.39,52.19 168.32,52.13 166.19,52.13 165.96,51.9 160.86,51.9 159.02,53.75 158.34,53.75 158,54.08 158,54.75 157.63,55.12 149.58,55.12 148.68,54.22 137.01,54.22 136.52,54.72 135.22,54.72 134.78,55.16 131.72,55.16 130.89,54.34 127.07,54.34 126.9,54.5 121.8,54.5 121.65,54.35 119.23,54.35 118.87,54.71 115.03,54.71 114.55,54.23 110.88,54.23 110.7,54.41 106.86,54.41 106.44,54.83 103.89,54.83 102.7,56.02 102.27,56.02 102.18,56.11 v5(101.93,56.11)
  GND5 w0.089: v6(101.96,56.57) 101.96,56.14 v5(101.93,56.11)
  BOTTOM w0.104: CS43.1 180.83,53.51 180.83,53.33 180.9,53.25 181.8,53.25 v8(182.1,53.56) ; UH1.AU3 v6(101.96,56.57)
SATA_PTX_DRX_N0_C: length 4.7
  BOTTOM w0.104: CS43.2 179.77,53.37 178.91,53.37 178.53,53.75 v7(177.67,53.75) 176.88,53.75 176.6,54.02 JSATA1.31
SATA_PTX_DRX_P0: length 89.4
  IN4 w0.071: v8(182.1,52.92) 182.28,53.1 182.57,53.1 182.81,53.34 182.81,53.85 182.37,54.29 178.39,54.29 177.34,53.24 170.33,53.24 169.53,52.44 168.28,52.44 168.22,52.37 166.08,52.37 165.86,52.15 160.97,52.15 159.12,53.99 158.44,53.99 158.25,54.19 158.25,54.85 157.73,55.37 149.47,55.37 148.58,54.47 137.12,54.47 136.62,54.97 135.32,54.97 134.88,55.41 131.61,55.41 130.79,54.58 127.17,54.58 127.01,54.75 121.7,54.75 121.55,54.6 119.34,54.6 118.97,54.96 114.92,54.96 114.45,54.48 110.98,54.48 110.8,54.66 106.97,54.66 106.55,55.08 103.99,55.08 102.8,56.27 102.37,56.27 102.28,56.36 102.28,56.49 v5(102.37,56.58)
  GND5 w0.089: v6(102.37,56.13) 102.37,56.58 v5(102.37,56.58)
  BOTTOM w0.104: UH1.AU1 v6(102.37,56.13) ; CS42.1 181.01,52.79 181.2,52.98 182.04,52.98 v8(182.1,52.92)
SATA_PTX_DRX_P0_C: length 4.7
  BOTTOM w0.104: JSATA1.33 176.59,53.22 176.84,53.48 178.42,53.48 178.8,53.1 v7(179.11,53.1) 179.78,53.1 CS42.2
SBD_INT#: length 5.7
  TOP w0.076: 159.37,62.05 159.3,62.12 159.3,64.57 U636.D6
  TOP w0.122: T253.1 160.89,60.35 159.98,61.26 159.71,61.26 159.54,61.43 159.54,61.87 159.37,62.05
SBD_WAKE#: length 4.8
  TOP w0.122: T252.1 163.78,67.68 162.73,66.63 161.51,66.63 161.34,66.8 160.93,66.8 160.67,66.55 160.67,65.95 U636.F8
SENSOR_I2C_SCL: length 53.7
  TOP w0.076: 157.66,64.57 157.94,64.57 157.94,64.57 158.3,64.57 U636.B5
  TOP w0.122: R985.2 130.53,79.9 130.87,80.24 v1(131.39,80.24) v7(132.24,81.09) ; U638.2 v7(138.54,76.71) ; U637.2 154.69,53.93 155.78,55.02 R854.1 155.29,56.25 155.29,57.78 154.5,58.57 154.5,59.45 154.31,59.64 154.31,64.07 v2(154.36,64.12) ; v2(157.2,64.39) 157.37,64.57 157.66,64.57
  GND1 w0.104: v3(157.2,63.94) v2(157.2,64.39) ; v2(154.36,64.12) 154.36,64.2 154.81,64.65 v3(154.81,64.68)
  IN1 w0.071: v4(151.68,71.29) 151.68,70.37 153.97,68.08 153.97,66.67 155.02,65.62 155.02,64.89 v3(154.81,64.68) 154.87,64.68 155.71,63.84 156.27,63.84 156.39,63.97 157.17,63.97 v3(157.2,63.94)
  IN2 w0.094: v4(151.68,71.29) 151.68,71.44 151.19,71.93 150.93,71.93 150.36,71.36 147.73,71.36 142.38,76.71 v7(138.54,76.71) 134.6,80.66 132.67,80.66 v7(132.24,81.09)
SENSOR_I2C_SDA: length 59.4
  TOP w0.076: U636.C5 158.8,64.07 158.8,63.72 158.65,63.57 157.94,63.57 157.7,63.33 157.66,63.33
  TOP w0.122: v7(131.54,81.06) 131.54,81.48 132.18,82.12 134.79,82.12 136.23,80.68 136.23,79.92 R986.2 ; 157.66,63.33 157.65,63.32 156.99,63.32 v2(156.91,63.25) ; v2(154.34,64.66) 154.03,64.35 154.03,64.22 154.02,64.21 154.02,63.74 153.63,63.35 153.63,62.94 154.01,62.56 154.01,60.97 153.96,60.92 v1(153.96,60.08) 153.96,59.6 154.25,59.31 154.25,56.29 R855.1 154.89,55.65 154.89,54.96 153.89,53.96 U637.3 ; U638.3 v7(138.56,76.06)
  GND1 w0.104: v2(154.34,64.66) 154.34,64.81 v3(154.57,65.04) ; v2(156.91,63.25) 156.85,63.31 v3(156.85,63.68)
  IN1 w0.071: v3(156.85,63.68) 156.77,63.6 155.67,63.6 154.88,64.38 154.68,64.38 154.52,64.55 154.52,64.99 v3(154.57,65.04) 154.57,65.33 153.79,66.1 153.79,68.02 151.19,70.62 v4(151.19,70.74)
  IN2 w0.094: v7(131.54,81.06) 132.25,80.35 134.28,80.35 v7(138.56,76.06) 142.55,76.06 147.58,71.03 150.72,71.03 151.01,70.74 v4(151.19,70.74)
SENSOR_RST#: length 22.7
  TOP w0.122: v2(155.51,65.06) 155.26,65.31 R1090.2 ; v7(164.92,64.53) v1(164.92,63.84) 165.53,63.23 165.53,60.24 163.7,58.41 v7(163.7,58.04)
  GND1 w0.104: v3(155.65,64.6) 155.51,64.74 v2(155.51,65.06)
  IN1 w0.071: v4(160.74,64.55) 159.13,64.55 158.62,65.06 156.69,65.06 156.55,64.92 155.96,64.92 v3(155.65,64.6)
  IN3 w0.094: v4(160.74,64.55) 161.03,64.85 164.6,64.85 v7(164.92,64.53)
  BOTTOM w0.122: JSATA1.20 164.08,58.42 v7(163.7,58.04)
SERIRQ: length 77.6
  TOP w0.076: U34.M3 139.91,61.1 139.66,60.85 139.28,60.85 139.07,61.06 138.82,61.06 138.65,60.9 138.65,60.45 v2(138.69,60.41)
  TOP w0.122: RH29.2 107.94,52.71 108.02,52.79 v2(108.02,53.14) 108.04,53.11 108.04,55.1 108.21,55.27 108.21,56.11 108.64,56.54 v2(108.64,57.09) ; v1(158.33,48.73) 158.33,49.7 158.75,50.12 v2(158.76,50.12) U652.27
  GND1 w0.104: v2(158.76,50.12) v3(158.76,50.63) ; v3(108.87,57.49) 108.64,57.26 v2(108.64,57.09) ; v2(138.69,60.41) 138.44,60.41 v3(138.27,60.58) ; v3(108.36,53.91) 108.02,53.57 v2(108.02,53.14)
  IN1 w0.071: v4(149.23,50.29) 149.23,49.7 149.6,49.32 157.91,49.32 158.76,50.17 v3(158.76,50.63) ; v3(108.87,57.49) 108.87,57.85 v4(108.72,58) ; v3(108.36,53.91) 108.42,53.85 111.66,53.85 111.76,53.75 117.04,53.75 117.28,53.99 118.93,53.99 119.9,53.02 123.75,53.02 125.81,55.08 128.34,55.08 131.16,57.9 132.32,57.9 134.43,60.02 135.06,60.02 135.31,60.26 136.05,60.26 136.39,59.92 136.39,59.64 v4(136.88,59.16) 137.22,59.16 138.27,60.21 v3(138.27,60.58)
  IN2 w0.094: v4(136.88,59.16) 137.09,58.94 138.87,58.94 139.12,58.69 140.39,58.69 140.58,58.88 141.13,58.88 141.73,58.28 142.21,58.28 143.2,57.29 143.65,57.29 147.78,53.16 147.78,51.05 148.54,50.29 v4(149.23,50.29)
  IN4 w0.071: v5(108.95,57.47) 108.72,57.7 v4(108.72,58)
  GND5 w0.104: v6(108.8,57.85) 108.8,57.62 v5(108.95,57.47)
  BOTTOM w0.122: v6(108.8,57.85) 108.87,57.77 UH1.Y4
SGATE: length 12.2
  TOP w0.122: v7(145.04,38.34) 144.51,38.34 v1(144.2,38.04)
  IN4 w0.508: 146.13,38.39 146.77,38.39 147.91,39.54 150.68,39.54 150.96,39.81 152.58,39.81 154.62,37.78 154.62,36.43
  vias: v7(154.69,35.06)
SH_DFU_EN#: length 73.8
  TOP w0.076: U636.F2 160.55,62.67 160.8,62.42 160.8,62.08 161.07,61.81 161.26,61.81
  TOP w0.122: RH307.1 117.34,73.27 117.06,72.99 v1(116.87,72.99) 113.37,72.99 v2(113.06,72.68) ; v2(162.06,60.36) 162.06,60.81 161.46,61.4 161.46,61.61 161.26,61.81
  GND1 w0.104: v2(113.06,72.68) 113.24,72.5 v3(113.24,72.3) ; v2(162.06,60.36) 162.58,60.36 v3(162.97,60.76)
  IN1 w0.071: v4(113.72,72.2) 113.34,72.2 v3(113.24,72.3) ; v3(162.97,60.76) 162.97,62.55 162.22,63.3 162.12,63.3 162.05,63.37 162.05,67.13 161.82,67.36 156.98,67.36 v4(156.6,66.98)
  IN2 w0.094: v4(156.6,66.98) 155.88,67.69 154.52,67.69 153.33,66.5 150.29,66.5 149.76,67.03 148.61,67.03 147.92,66.34 147.54,66.34 147.07,66.81 145.86,66.81 145.25,67.42 142.42,67.42 142.26,67.26 139.73,67.26 137.81,69.17 136.89,69.17 136.13,69.94 135.78,69.94 131.11,74.61 127.79,74.61 127.3,74.13 125.15,74.13 124.68,74.6 121.99,74.6 120.05,72.67 118.52,72.67 118.23,72.96 116.16,72.96 115.97,72.77 114.32,72.77 113.75,72.2 v4(113.72,72.2)
  IN4 w0.071: v4(113.72,72.2) 113.67,72.25 113.24,72.25 113.21,72.22 v5(113.14,72.22)
  GND5 w0.104: v6(113.11,72.68) 113.11,72.25 v5(113.14,72.22)
  BOTTOM w0.122: UH1.K42 113.19,72.76 v6(113.11,72.68)
SH_PWR_CNTRL: length 82
  TOP w0.122: RH257.1 107.58,55.44 107.83,55.69 107.83,56.05 108.33,56.54 108.33,57.3 108.77,57.75 v1(108.77,58.51) 108.77,58.81 v2(109,59.04) ; C1207.1 R1105.1 156.13,75.43 154.49,77.07 146.5,77.07 146.08,76.64 146.08,75.18 145.06,74.17 v2(145.06,72.91)
  GND1 w0.104: v2(109,59.04) 109.3,59.35 v3(109.33,59.35) ; v2(145.06,72.91) 145.06,72.4 v2(144.78,72.11) v3(144.78,71.13)
  IN1 w0.071: v4(136.84,69.79) 140.14,69.79 141.49,71.13 v3(144.78,71.13) ; v3(109.33,59.35) 109.66,59.68 v4(109.76,59.68)
  IN2 w0.094: v4(136.84,69.79) 136.57,69.79 132.3,74.05 132.3,75.31 132.04,75.57 130.37,75.57 130.17,75.78 128.63,75.78 127.99,75.13 127.75,75.13 127.3,74.68 125.55,74.68 125.17,75.06 121.64,75.06 120.21,73.63 119.07,73.63 118.27,74.43 116.78,74.43 115.54,73.19 112.2,73.19 111.97,72.96 110.81,72.96 110.27,72.42 110.27,72.03 110.74,71.56 110.74,69.09 111.46,68.36 111.46,67.09 111.83,66.73 111.83,65.71 111.54,65.42 111.54,64.29 110.57,63.32 110.57,62.4 110.52,62.34 110.52,61.71 110.67,61.56 110.67,60.59 v4(109.76,59.68)
  IN4 w0.071: v5(109.74,60.19) 109.74,59.7 v4(109.76,59.68)
  GND5 w0.104: v6(109.33,60.19) v5(109.74,60.19)
  BOTTOM w0.122: UH1.W12 v6(109.33,60.19)
SH_VBAT: length 16.5
  TOP w0.076: U636.C6 158.8,65.07 157.91,65.07 157.84,65.14 157.73,65.14
  TOP w0.122: R1105.2 156.13,72.69 154.43,70.99 154.43,69.88 154.1,69.55 v7(153.87,69.55) 153.87,68.81 v1(153.72,68.66) 153.26,68.66 R1101.2 R1102.2 ; 157.73,65.14 157.47,65.14 157.31,65.3
  TOP w0.254: v7(155.76,65.7) 156.15,65.3 157.31,65.3
  BOTTOM w0.508: v7(153.87,69.55) 153.87,66.7 154.87,65.7 v7(155.76,65.7)
SM_INTRUDER#: length 4
  TOP w0.122: RH11.2 115.6,64.35 v1(115.2,63.94) 114.89,63.64 v2(114.71,63.64)
  GND1 w0.104: v2(114.71,63.64) 114.51,63.84 v3(114.51,64)
  IN1 w0.071: v4(114.03,64) v3(114.51,64)
  IN4 w0.071: v5(113.54,63.97) 113.57,64 v4(114.03,64)
  GND5 w0.104: v5(113.54,63.97) 113.55,63.97 113.19,63.97 v6(113.14,64.02)
  BOTTOM w0.122: v6(113.14,64.02) 113.13,64.03 UH1.K22
SM_RCOMP0: length 4.3
  BOTTOM w0.254: 60.89,56.79 60.94,56.84 60.94,57.38 UCPU1.BF44
  BOTTOM w0.508: RC55.1 59.98,54.44 v9(59.98,55.21) 59.98,55.46 60.89,56.37 60.89,56.79
SM_RCOMP1: length 5.2
  BOTTOM w0.254: UCPU1.BE43 61.66,57.7 62.14,57.23 62.14,56.72 62.75,56.11
  BOTTOM w0.508: 62.75,56.11 63.17,56.11 63.46,55.82 63.48,55.72 v9(63.48,55.19) 63.48,54.34 RC58.1
SM_RCOMP2: length 3.3
  BOTTOM w0.254: UCPU1.BG43 61.66,56.22
  BOTTOM w0.508: RC60.1 61.66,54.02 v1(61.66,55.21) 61.66,56.22
SMBALERT#: length 10.4
  TOP w0.122: v2(114.1,60.21) 114.1,59.96 115.11,58.95 115.11,58.8 115.46,58.45 115.73,58.45 116.17,58 116.17,57.18 117.46,55.89 117.46,55.65 118,55.11 118.52,55.11 R812.1
  GND1 w0.104: v2(114.1,60.21) 113.9,60.41 v3(113.9,60.57)
  IN1 w0.071: v4(113.57,60.92) 113.9,60.59 v3(113.9,60.57)
  IN4 w0.071: v4(113.57,60.92) 113.82,60.67 v5(113.99,60.67)
  GND5 w0.104: v6(113.99,61.11) v5(113.99,60.67)
  BOTTOM w0.122: UH1.H12 v6(113.99,61.11)
SMBCLK: length 150
  TOP w0.122: QH3.6 134.61,25.55 RH105.1 133.76,24.7 v7(133.38,24.7) ; v2(115.27,61.81) 115.27,61.57 117.43,59.41 v2(117.43,59.09) 117.86,58.66 RH67.1 ; v7(176.64,44.33) 175.94,43.62 v1(175.94,43.57) 175.94,43.03 175.9,42.99 R724.2 176.33,41.96 Q327.6
  GND1 w0.104: v2(117.43,59.09) 117.43,59.04 v3(117.79,58.69) ; v3(115.7,62.06) 115.6,62.06 115.35,61.81 v2(115.27,61.81)
  IN1 w0.071: v3(115.7,62.06) 115.23,62.06 v4(115.17,62.01)
  IN1 w0.084: v4(118.35,58.43) 118.04,58.43 v3(117.79,58.69)
  IN2 w0.094: v7(133.38,24.7) 135.59,22.49 138.83,22.49 139.78,23.44 140.84,23.44 142.76,25.36 160.26,25.36 161.69,26.79 171.26,26.79 175.88,31.41 175.88,31.72 179.12,34.96 179.12,40.92 179.23,41.04 179.23,43.5 178.41,44.33 v7(176.64,44.33) 176.64,45.4 176.15,45.89 176.15,49.64 174.49,51.3 171.24,51.3 170.95,51.01 170.3,51.01 168.79,49.5 159.52,49.5 158.17,48.15 148.75,48.15 145.5,51.4 145.5,53.51 143.28,55.73 140.45,55.73 139.78,56.4 139.02,56.4 137.3,58.12 135.91,58.12 135.32,57.53 129.15,57.53 127.83,58.85 126.83,58.85 126.37,58.39 125.45,58.39 124.87,58.97 124.59,58.97 124.26,59.3 123.73,59.3 123.13,58.7 120.17,58.7 119.45,57.98 118.8,57.98 v4(118.35,58.43)
  IN4 w0.071: v5(115.46,62.43) 115.46,62.3 v4(115.17,62.01)
  GND5 w0.104: v5(115.46,62.43) 115.26,62.62 v6(115.26,62.79)
  BOTTOM w0.122: UH1.F17 115.06,62.79 v6(115.26,62.79)
SMBDATA: length 149.9
  TOP w0.122: v7(138.01,22.9) 137.45,23.46 RH111.1 137.26,23.65 QH3.3 ; RH69.1 117.2,55.55 117.2,55.78 115.95,57.04 115.95,57.91 115.64,58.22 115.37,58.22 114.75,58.84 v2(114.69,58.84) ; Q327.3 177.63,38.1 177.65,38.08 R725.2 177.74,38.08 178.3,37.52 v2(178.39,37.52)
  GND1 w0.104: v2(114.69,58.84) 114.71,58.84 114.97,59.09 v3(115.02,59.09) ; v2(178.39,37.52) 178.76,37.52 v3(178.98,37.73)
  IN1 w0.071: v4(178.73,37.24) 178.73,37.49 v3(178.98,37.73) ; v3(115.02,59.09) 115.02,59.32 v4(114.69,59.65)
  IN2 w0.094: v7(138.01,22.9) 138.94,22.9 139.88,23.84 140.88,23.84 142.65,25.62 160.19,25.62 161.6,27.03 171.22,27.03 175.62,31.43 175.62,31.78 177.91,34.06 177.91,36.41 v4(178.73,37.24) 178.04,37.93 178.04,40.12 179.04,41.12 179.04,43.42 178.57,43.89 176.43,43.89 175.75,44.57 175.75,45 175.8,45.05 175.8,45.54 175.36,45.98 174.6,45.98 172.39,48.19 170.9,48.19 169.98,49.11 159.68,49.11 158.33,47.76 148.58,47.76 145.11,51.24 145.11,53.34 143.11,55.34 139.12,55.34 138.21,56.25 138.21,56.39 137.14,57.45 136.39,57.45 135.88,56.94 128.44,56.94 127.73,57.65 126.86,57.65 126.72,57.51 125.27,57.51 125.17,57.4 122.32,57.4 121.98,57.75 120.3,57.75 118.64,56.08 117.99,56.08 117.27,56.81 116.02,56.81 115.03,55.82 114.29,55.82 114.09,56.02 114.09,56.8 113.21,57.67 113.1,57.79 113.1,58.26 113.43,58.6 113.44,58.6 114.01,59.16 114.03,59.16 114.09,59.22 114.09,59.22 114.53,59.65 v4(114.69,59.65)
  IN4 w0.071: v5(114.4,60.06) 114.41,60.04 114.41,60.04 114.69,59.76 v4(114.69,59.65)
  GND5 w0.104: v6(114.85,60.17) 114.74,60.06 v5(114.4,60.06)
  BOTTOM w0.122: UH1.F10 v6(114.85,60.17)
SML0CLK: length 9.3
  TOP w0.122: RH70.1 115,54.95 114.32,55.63 114.14,55.63 113.98,55.79 113.98,56.25 v1(113.62,56.6) 113.2,57.02 113.2,58.47 113.47,58.74 113.47,59.73 113.21,59.98 113.21,60.34 v2(113.37,60.49)
  GND1 w0.104: v3(112.96,60.52) 113.34,60.52 v2(113.37,60.49)
  IN1 w0.071: v4(112.68,60.92) 112.68,60.79 v3(112.96,60.52)
  IN4 w0.071: v5(113.1,60.64) 113.1,60.66 112.83,60.92 v4(112.68,60.92)
  GND5 w0.104: v5(113.1,60.64) 113.13,60.67 v6(113.13,61.07)
  BOTTOM w0.122: UH1.K12 v6(113.13,61.07)
SML0DATA: length 5.7
  BOTTOM w0.122: RH72.1 v1(120.07,57.01) 120.07,57.67 119.59,58.15 118.22,58.15 116.83,59.54 UH1.A9
SML1CLK: length 12.8
  TOP w0.122: QH4.6 RH73.1 124.08,55.87 v7(123.79,55.87)
  IN4 w0.071: v5(116.77,59.52) 116.77,59.52 116.08,60.21 v5(115.93,60.21)
  GND5 w0.104: v6(115.88,60.76) 115.93,60.71 v5(115.93,60.21) ; v5(116.77,59.52) 117.2,59.52 v6(117.25,59.58)
  BOTTOM w0.122: UH1.D12 v6(115.88,60.76) ; v7(123.79,55.87) 121.07,58.58 v1(120.02,58.58) 118.25,58.58 v6(117.25,59.58)
SML1DATA: length 16.1
  TOP w0.122: v2(126.42,59.35) 126.59,59.18 127.75,59.18 RH74.1 127.74,58.78 QH4.3
  GND1 w0.104: v3(126.45,59.8) 126.42,59.78 v2(126.42,59.35)
  IN1 w0.071: v4(124.82,58.18) 124.82,58.72 125.79,59.69 126.33,59.69 v3(126.45,59.8)
  IN4 w0.071: v5(119.13,58.94) 119.21,59.02 119.69,59.02 120.11,58.6 121.38,58.6 121.57,58.41 123.49,58.41 123.67,58.23 124.77,58.23 v4(124.82,58.18)
  GND5 w0.104: v5(119.13,58.94) v6(118.68,58.94) ; v6(116.33,60.35) 116.73,59.94 v6(116.75,59.94)
  BOTTOM w0.122: v6(118.68,58.94) 117.67,59.94 v6(116.75,59.94) ; UH1.C11 v6(116.33,60.35)
SNUB_1.5V: length 4
  TOP w0.508: PR302.2 58.36,20.82 v9(57.82,20.27) 57.78,20.23 57.2,20.23 56.87,20.56 PC311.1
SNUB_1.5VSP: length 2.8
  TOP w0.122: v1(165.98,43.66) PC409.1
  TOP w0.508: PC409.1 165.98,41.49 PR406.2
SNUB_1.8VSP: length 3
  BOTTOM w0.122: v1(95.79,48.76) 96.2,48.35 PC405.1
  BOTTOM w0.508: PR400.2 96.64,47.08 PC405.1
SNUB_3V: length 3.3
  TOP w0.122: PR208.2 v9(187.76,65.56)
  TOP w0.508: PC212.1 190.81,65.56 PR208.2
SNUB_5V: length 3.2
  TOP w0.122: v1(205.16,66.38) 204.91,66.13 PC213.1
  TOP w0.508: PR209.2 204.97,64.77 204.08,65.66 PC213.1
SOSCI: length 5
  TOP w0.122: U636.B8 158.55,66.16 158.57,66.18 158.57,66.75 v1(158.21,67.11) 157.5,67.82 CH1202.1 157.5,69.39 157.8,69.68 Y1.2
SOSCO: length 5.9
  TOP w0.076: 158.11,66.13 158.3,65.94 158.3,65.57 U636.B7
  TOP w0.122: Y1.1 156.42,69.68 156.66,69.44 CH1203.1 156.66,67.26 v1(156.91,67.01) 157.13,66.79 157.32,66.79 157.98,66.13 158.11,66.13
SUS_A#: length 3.3
  TOP w0.122: T216.1 115.64,58.76 v2(115.42,58.98)
  GND1 w0.104: v3(115.83,58.74) 115.67,58.74 v2(115.42,58.98)
  IN1 w0.071: v4(115.45,59.31) 115.83,58.92 v3(115.83,58.74)
  IN4 w0.071: v4(115.45,59.31) 115.77,59.31 115.93,59.14 v5(115.93,59.12)
  GND5 w0.104: v6(116.31,58.73) 116.31,58.76 115.96,59.12 v5(115.93,59.12)
  BOTTOM w0.122: v6(116.31,58.73) UH1.C7
SUS_STAT#: length 3.6
  TOP w0.122: v2(113.67,57.49) T76.1
  GND1 w0.104: v3(113.67,58.51) v2(113.67,57.49)
  IN1 w0.071: v4(113.67,58.03) v3(113.67,58.51)
  IN4 w0.071: v5(113.69,57.49) 113.67,57.51 v4(113.67,58.03)
  GND5 w0.104: v5(113.69,57.49) 113.67,57.49 113.67,57.5 v6(114.15,57.5)
  BOTTOM w0.122: v6(114.15,57.5) 114.13,57.5 114.15,57.52 UH1.G6
SUSACK#: length 41.3
  TOP w0.122: T218.1 v2(114.92,61.11) ; U34.M13 139.79,55.98 v2(139.79,55.71)
  GND1 w0.104: v2(114.92,61.11) 114.92,61.05 v3(114.56,60.69) ; v2(139.79,55.71) 139.56,55.49 v3(139.33,55.49)
  IN1 w0.071: v4(139.35,56.02) 139.35,55.51 v3(139.33,55.49) ; v3(114.56,60.69) 114.92,61.05 v4(115.42,61.05)
  IN2 w0.094: v4(115.42,61.05) 115.53,60.95 115.53,59.83 115.83,59.52 115.83,59.14 115.58,58.89 115.02,58.89 114.53,58.4 113.52,58.4 113.29,58.18 113.29,57.87 114.29,56.88 114.29,56.25 114.51,56.03 114.9,56.03 116.14,57.26 119.11,57.26 120.31,58.47 123.23,58.47 123.84,59.08 124.19,59.08 124.61,58.66 124.9,58.66 125.39,58.17 126.42,58.17 126.91,58.65 127.67,58.65 128.99,57.33 135.51,57.33 136.1,57.92 137.22,57.92 139.13,56.02 v4(139.35,56.02)
  IN4 w0.071: v4(115.42,61.05) 114.74,61.05 v5(114.59,61.2)
  GND5 w0.104: v5(114.59,61.2) 114.43,61.35 v6(114.43,61.61)
  BOTTOM w0.122: v6(114.43,61.61) 114.45,61.62 UH1.F15
SUSCLK: length 6.5
  BOTTOM w0.122: RH132.2 116.48,51.9 CH102.2 115.58,52.81 115.58,54.11 114.85,54.84 114.85,55.55 114.76,55.64 114.76,56.3 115.04,56.58
  BOTTOM w0.305: UH1.D3 115.4,56.58 115.04,56.58
SUSCLK_R: length 37.1
  TOP w0.122: R253.1 139.57,67.08 139.48,67.17 v1(138.41,67.17) 137.48,67.17 135.53,65.21 135.53,64.22 135.27,63.97 135.27,61.52 135.31,61.48 135.31,60.87 v2(135.8,60.39)
  GND1 w0.104: v3(135.8,59.96) v2(135.8,60.39)
  IN1 w0.071: v3(135.8,59.96) 136.23,59.52 136.23,57.24 135.9,56.91 130.44,56.91 128.42,54.89 125.9,54.89 123.84,52.83 119.84,52.83 119.22,53.45 117.94,53.45 v4(117.51,53.02)
  IN4 w0.071: v5(117.8,53.44) 117.51,53.15 v4(117.51,53.02)
  GND5 w0.104: v6(117.36,53.51) 117.43,53.44 v5(117.8,53.44)
  BOTTOM w0.122: RH132.1 116.9,53.05 v6(117.36,53.51)
SUSP: length 127.8
  TOP w0.122: v7(110.7,39.61) 110.62,39.61 v1(110.22,39.2) 110.22,39.18 Q4.2 ; v7(174.35,57.32) 175.44,56.22 178.96,56.22 179.79,55.4 179.79,53.96 178.62,52.79 178.62,52.41 178.37,52.16 Q330.1 ; v7(168.46,43.93) 168.57,44.04 Q34.2 167.82,44.86 R1024.2
  IN4 w0.071: v7(168.46,43.93) 169.3,43.93 170.65,42.58 171.12,42.58 172.29,41.41 172.29,39.01 172.63,38.67 172.63,31.18 166.66,25.21 142.45,25.21 141.43,24.19 138.42,24.19 135.77,21.55 134.37,21.55 132.45,19.63 129.34,19.63 126.17,22.81 122.32,22.81 120.83,24.29 120.83,35.9 119.82,36.92 118.57,36.92 118.4,37.1 114.86,37.1 114.12,37.83 113.37,37.83 113.01,38.19 112.12,38.19 v7(110.7,39.61)
  BOTTOM w0.122: v7(174.35,57.32) 174.2,57.32 171.76,54.88 171.76,52.26 170.9,51.4 170.9,46.32 168.51,43.93 v7(168.46,43.93)
SUSP#: length 266.5
  TOP w0.122: PR308.1 26.75,23.18 v7(26.6,23.03) ; v2(141.76,61.25) 141.77,61.25 U34.G4 ; 169.94,47.97 172.55,47.97 172.65,47.87 176.69,47.87 177.11,48.29 177.59,48.29 R1027.1 177.96,48.96 177.72,49.2 Q330.2 178.95,51.05 178.95,52.59 180.04,53.68 180.04,55.54 179.1,56.48 176.03,56.48 175.11,57.39 175.11,61.73 174.38,62.47 173.82,62.47 172.96,63.33 U654.3 ; 169.94,47.97 169.94,47.64 170.01,47.57 171.83,47.57 172.52,46.88 172.52,44.56 171.61,43.65 PR405.1 ; 169.94,47.97 v7(169.87,48.04) 170.08,48.26 170.49,48.26 170.95,48.72 170.95,51.81 171.33,52.19 U655.5 ; v2(127.5,53.49) 127.5,52.53 128.82,51.21 PR503.1 ; v2(102.57,54.42) 102.98,54.83 PR402.1 ; v7(45.75,43.14) 45.83,43.07 46.46,43.07 v9(46.95,43.55) 47.21,43.81 54.11,43.81 54.89,43.03 63.65,43.03 63.86,43.25 76.14,43.25 77,42.39 78.67,42.39 78.74,42.32 80.97,42.32 v7(81.29,42.63)
  GND1 w0.104: v2(127.5,53.49) 127.25,53.75 v3(127.25,54.38) ; v3(141.46,61.74) 141.46,61.57 141.76,61.26 v2(141.76,61.25) ; v3(102.57,53.99) v2(102.57,54.42)
  IN1 w0.071: v7(45.75,43.14) 45.75,43.09 45.22,43.62 27.79,43.62 23.68,39.52 19.82,39.52 19.03,40.31 18.52,40.31 17.64,39.43 17.64,37.88 16.79,37.03 16.79,30.18 17.01,29.95 17.01,25.87 18.06,24.82 23.75,24.82 25.55,23.03 v7(26.6,23.03) ; v4(93.78,53.84) 94.15,54.2 102.36,54.2 v3(102.57,53.99) 102.79,54.2 106.14,54.2 106.64,53.71 106.64,53.25 107.25,52.64 111.36,52.64 111.78,52.22 112.88,52.22 113.11,52.45 118.43,52.45 118.98,53 119.42,53 119.78,52.65 123.94,52.65 125.99,54.7 126.55,54.7 126.87,54.38 v3(127.25,54.38) 128.19,54.38 130.11,56.3 136.72,56.3 v4(136.96,56.54) 137.14,56.72 137.14,58.27 138.35,59.48 138.35,60.04 138.72,60.4 138.72,61.19 139.22,61.7 140,61.7 140.34,62.04 140.75,62.04 141.05,61.74 v3(141.46,61.74)
  IN2 w0.094: v4(93.78,53.84) 93.38,53.84 82.58,43.04 81.69,43.04 v7(81.29,42.63) ; v4(136.96,56.54) 138.76,54.75 142.87,54.75 144.52,53.1 144.52,50.99 148.34,47.17 158.57,47.17 159.93,48.53 169.39,48.53 v7(169.87,48.04)
  BOTTOM w0.122: v7(81.29,42.63) 81.08,42.63 79.86,43.85 76.74,43.85 75.19,45.4 75.19,46.72 75.69,47.22 RC104.1
SUSWARN#: length 46.6
  TOP w0.122: RH297.1 RH154.1 150.65,61.08 v2(150.2,61.53)
  GND1 w0.104: v2(150.2,61.53) 150.17,61.51 v3(150.17,60.85)
  IN1 w0.071: v4(129.42,64.4) 129.17,64.4 128.45,63.69 128.1,63.69 127.03,62.62 127.03,61.21 125.88,60.06 125.64,60.06 124.7,59.12 123.81,59.12 123.73,59.04 117.61,59.04 116.47,60.19 v4(116.47,60.67) ; v4(148.29,60.28) 148.33,60.24 149.67,60.24 150.17,60.74 v3(150.17,60.85)
  IN2 w0.094: v4(148.29,60.28) 147.86,60.71 147.86,62.52 146.57,63.81 144.61,63.81 144.03,64.39 137.2,64.39 136.36,63.55 136.36,62.98 135.94,62.55 133.17,62.55 133.06,62.67 132.33,62.67 131.3,63.69 129.95,63.69 129.42,64.22 v4(129.42,64.4)
  IN4 w0.071: v5(115.91,61.17) 115.97,61.17 v4(116.47,60.67)
  GND5 w0.104: v5(115.91,61.17) 115.91,61.16 v6(116.33,61.16)
  BOTTOM w0.122: UH1.C13 v6(116.33,61.16)
SW_1.35V: length 18.2
  IN2 w1.016: 50.22,23.1 50.22,20.74 48.65,19.16 45.09,19.16 44.43,19.82 35.29,19.82
  vias: v7(33.26,20) v7(33.92,20) v7(50.98,24.22) v7(50.98,23.58) v7(51.47,22.95) v7(51.62,24.22) v7(51.62,23.58) v7(52.25,24.22) v7(52.25,23.58) v7(52.89,24.22) v7(52.89,23.58) v7(53.52,24.22) v7(53.52,23.58) v9(50.1,24.22)
SW_+V1.05S_VCCPP:
  vias: v7(113.42,47.26) v7(114.05,47.26) v7(114.69,47.26) v7(115.5,47.18) v7(115.5,46.55) v7(115.5,45.91) v7(115.5,45.28) v7(115.7,48.3) v7(116.14,47.82) v7(116.14,47.18) v7(116.14,46.55) v7(116.14,45.91) v7(116.14,45.28) v7(116.77,47.82) v7(116.77,47.18) v7(116.77,46.55) v7(116.77,45.91) v7(116.77,45.28) v7(125.28,44.11) v7(125.28,43.47) v9(114.94,47.99)
SW_USB20_N1: length 33.5
  TOP w0.114: UI1.2 213.65,53.43 213.86,53.64 214.01,53.64 214.29,53.36 214.29,53.1 215.03,52.37 215.03,52.32 215.78,51.57 215.78,47.01 216.95,45.83 216.95,45.4 215.78,44.23 215.78,27.39 217.3,25.86 217.3,25.49 217.18,25.36 217.1,25.36 v8(217.01,25.45)
  BOTTOM w0.114: v8(217.01,25.45) 217.17,25.45 217.27,25.35 217.27,25.13 216.98,24.83 L40.1 216.98,24.22 R222.1
SW_USB20_P1: length 33.5
  TOP w0.114: UI1.3 213.76,53.93 213.79,53.9 214.12,53.9 214.55,53.47 214.55,53.21 215.29,52.48 215.29,52.43 216.04,51.68 v7(216.04,47.42) 216.04,47.11 217.21,45.94 217.21,45.3 216.04,44.12 216.04,27.5 217.56,25.97 217.56,25.67 217.76,25.47 v7(217.76,25.46)
  BOTTOM w0.114: R262.1 217.78,24.22 L40.4 217.78,24.65 217.53,24.89 217.53,25.23 v7(217.76,25.46)
SYS_PRS: length 7
  TOP w0.122: v7(122.92,24.78) 122.84,24.7 v1(122.84,23.49) 122.96,23.38 PR918.1
  BOTTOM w0.122: v7(122.92,24.78) 122.69,25.01 121.85,25.01 121.37,24.53 JBATT9.4
SYS_PWROK: length 12.5
  TOP w0.122: 112.83,52.38 113.26,51.95 113.26,51.09 113.52,50.83 v1(113.52,50.36) ; 112.83,52.38 RH272.1 ; 112.83,52.38 113.33,52.38 113.36,52.34 RH273.2 113.72,52.79 113.59,52.92 113.59,54.97 113.2,55.36 113.2,55.83 112.4,56.63 112.4,57.61 111.82,58.19 v2(111.82,58.48)
  GND1 w0.104: v3(111.82,58.92) v2(111.82,58.48)
  IN1 w0.071: v3(111.82,58.92) 112.12,59.22 v4(112.22,59.22)
  IN4 w0.071: v4(112.22,59.22) 112.22,59.3 v5(111.92,59.6)
  GND5 w0.104: v6(112.22,59.3) 112.22,59.3 v5(111.92,59.6)
  BOTTOM w0.122: UH1.M10 v6(112.22,59.3)
SYSON: length 207.5
  TOP w0.076: v2(144.8,62.47) 144.67,62.34 144.67,61.85 U34.B2
  TOP w0.122: v2(147.66,46.18) 149.74,48.26 149.74,52.44 150.17,52.87 150.17,54.51 149.75,54.93 149.75,57.72 150.38,58.34 152.14,58.34 152.98,59.18 152.98,61.47 152.58,61.86 152.58,63.46 151.82,64.22 151.52,64.22 150.99,64.75 R923.1 ; Q35.5 150.31,64.97 R923.1 ; R923.1 151.04,64.25 151.04,63.16 150.67,62.79 v2(150.58,62.79) ; v2(59.54,41.58) 59.94,41.58 60.1,41.41 76.04,41.41 77.04,40.41 83.56,40.41 87.59,44.44 v9(87.59,45.49) 87.59,45.92 90.04,48.37 92.15,48.37 v7(93.25,49.47)
  GND1 w0.104: v2(59.54,41.58) 59.13,42 v3(59.11,42) ; v2(147.66,46.18) 147.61,46.18 147.2,45.77 v3(146.91,45.77) ; v2(150.58,62.79) 150.01,62.79 v3(149.89,62.9) ; v2(144.8,62.47) 145.09,62.18 145.09,62.02 v3(145.33,61.78)
  IN1 w0.071: v7(26.6,22.31) 25.99,22.31 23.67,24.64 17.98,24.64 16.64,25.97 16.64,26.33 15.78,27.19 15.78,27.52 16.64,28.38 16.64,29.8 16.42,30.02 16.42,37.14 17.29,38.02 17.29,39.61 18.36,40.68 19.18,40.68 19.97,39.89 23.53,39.89 27.95,44.31 49.74,44.31 51.67,42.38 58.73,42.38 v3(59.11,42) ; v3(146.91,45.77) 145.6,45.77 145.04,46.33 142.48,46.33 v4(141.56,47.25) ; v3(145.33,61.78) 145.44,61.78 145.7,61.53 147.36,61.53 148.73,62.9 v3(149.89,62.9)
  IN2 w0.094: v7(93.25,49.47) 93.25,50.51 95.97,53.23 101.53,53.23 103.12,51.63 105.31,51.63 105.66,51.29 118.47,51.29 118.66,51.09 122.7,51.09 123.2,51.59 125.09,51.59 125.82,50.87 127.08,50.87 127.63,51.42 131.55,51.42 131.95,51.02 132.67,51.02 133.69,50 137.92,50 140.48,47.43 141.38,47.43 v4(141.56,47.25)
  BOTTOM w0.122: v7(26.6,22.31) PR306.1
SYSON#: length 3.7
  TOP w0.122: R295.2 148.92,67.73 Q35.3 149.66,67.53 149.83,67.36 150.17,67.36 150.31,67.5 Q35.2 150.31,68.17 v1(149.78,68.71)
SYSTEM_FAN_FB: length 186
  TOP w0.076: v2(138.97,56.01) 139.32,56.35 139.53,56.35 139.67,56.49 139.67,56.85 U34.M11
  TOP w0.122: D81.2 5.7,22.44 4.93,23.2 4.11,23.2 v7(3.66,22.76) R884.1 ; v7(85.99,44.44) 85.99,44.21 v1(85.48,43.7) 82.69,40.91 77.25,40.91 75.67,42.49 64.16,42.49 63.96,42.28 54.58,42.28 54,42.86 53.05,42.86 52.74,43.17 49.58,43.17 48.76,42.35 45.83,42.35 45.61,42.14 45.16,42.14 44.86,42.43 44.86,43.47 44.29,44.04 37.82,44.04 37.16,43.38 31.65,43.38 31.07,43.95 26.58,43.95 v2(26.13,43.5)
  GND1 w0.104: v3(139.14,56.77) 139.14,56.17 v2(138.97,56.01) ; v3(25.69,43.62) 26,43.62 v2(26.13,43.5)
  IN1 w0.071: v4(25.18,43.01) 25.18,43.12 v3(25.69,43.62) ; v3(139.14,56.77) 138.93,56.56 138.93,56.41 138.74,56.22 138.74,54.09 136.05,51.4 134.53,51.4 134.12,50.99 v4(133.51,50.99)
  IN2 w0.094: v7(85.99,44.44) 85.99,44.73 93.68,52.43 94.42,52.43 96.27,54.28 101.03,54.28 103.28,52.03 105.48,52.03 105.82,51.68 118.66,51.68 118.85,51.49 122.55,51.49 123.04,51.98 125.26,51.98 125.98,51.26 126.92,51.26 127.47,51.81 131.72,51.81 132.11,51.41 133.09,51.41 v4(133.51,50.99) ; v4(25.18,43.01) 25.18,43.09 25.99,43.9 25.99,45.87 24.12,47.74 18.15,47.74 16.19,45.78 16.19,44.73 15.77,44.32 15.77,43.64 16.15,43.26 16.15,42.94 15.11,41.9 15.11,41.38 14.21,40.48 14.21,35.69 14.68,35.22 14.68,30.51 14.4,30.24 14.4,29.72 12.81,28.13 12.81,23.46 10.12,20.76 8.03,20.76 6.72,22.08 4.34,22.08 v7(3.66,22.76)
SYSTEM_FAN_PWM: length 165.9
  TOP w0.076: 138.23,56.92 138.23,56.93 138.37,57.06 138.37,57.06 138.7,57.39 139.09,57.39 139.31,57.6 U34.N10
  TOP w0.122: 138.23,56.92 137.28,55.97 v2(137.28,55.88) ; v2(53.3,43.21) 54.01,43.21 54.68,42.53 63.85,42.53 64.06,42.74 75.77,42.74 77.35,41.16 80.98,41.16 v1(81.64,41.82) 82.05,41.82 v7(82.35,42.13)
  GND1 w0.104: v2(53.3,43.21) 53.16,43.21 v3(52.9,43.46) ; v2(137.28,55.88) 137.28,55.45 v3(137.29,55.44)
  IN1 w0.071: v4(134.44,53.35) 135.05,53.96 136.49,53.96 137.03,54.5 137.03,55.17 v3(137.29,55.44) ; v3(52.9,43.46) 52.85,43.46 52.59,43.19 51.12,43.19 49.82,44.5 26.63,44.5 25.2,45.93 24.57,45.93 24.04,45.4 22.28,45.4 21.47,46.21 20.79,46.21 19.95,45.37 19.09,45.37 18.81,45.65 18.05,45.65 17.46,45.07 16.32,45.07 15.05,43.8 15.05,42.24 14.62,41.8 14.62,41.11 13.51,40 13.51,34.32 14.12,33.71 14.12,30.59 13.72,30.19 13.72,29.95 11.56,27.78 11.5,27.78 10.73,27.01 10.73,26.21 7.28,22.77 v7(7.28,22.31)
  IN2 w0.094: v7(82.35,42.13) 82.55,42.13 93.47,53.04 94.14,53.04 97.49,56.4 102.79,56.4 104.71,54.48 106.08,54.48 106.48,54.08 107.23,54.08 107.85,53.46 118.57,53.46 119.31,52.72 121.89,52.72 122.3,53.14 128.65,53.14 128.72,53.07 131.75,53.07 131.94,53.26 134.34,53.26 v4(134.44,53.35)
  BOTTOM w0.122: JFAN1.3 7.71,22.74 v7(7.28,22.31)
TABLET_MODE: length 58.8
  TOP w0.076: 138.49,62.28 139.17,61.6 U34.N2
  TOP w0.122: v9(175,76.44) 176.39,77.83 v7(176.39,78.55) ; v2(137.4,65.7) 137.4,63.54 137.31,63.45 R980.1 137.87,63.11 138.49,62.48 138.49,62.28
  GND1 w0.104: v3(138.27,65.66) 138.25,65.63 137.46,65.63 v2(137.4,65.7)
  IN1 w0.071: v4(138.64,66.69) 138.27,66.32 v3(138.27,65.66)
  IN2 w0.094: v4(138.64,66.69) 139.02,66.31 139.6,66.31 140.16,66.86 142.42,66.86 142.59,67.03 145.08,67.03 145.7,66.42 146.91,66.42 147.42,65.91 151.91,65.91 153.37,64.45 153.99,64.45 154.83,65.29 156.74,65.29 156.89,65.45 158.54,65.45 158.87,65.77 161.56,65.77 162.29,66.5 165.14,66.5 165.86,67.21 165.86,68.04 166.43,68.62 166.43,70.82 168.14,72.53 169.86,72.53 172.73,75.4 173.92,75.4 175.64,77.11 175.64,77.8 v7(176.39,78.55)
  BOTTOM w0.122: JLVDS2.18 176.74,78.91 176.39,78.55 v7(176.39,78.55)
TP_CLK: length 107.2
  TOP w0.122: v2(139.38,24.5) L60.1 139.12,25.36 C1155.1 v1(138.36,25.51) ; R223.2 147.7,59.44 v2(147,60.15) 146.66,60.15 146.63,60.18 145.5,60.18 U34.A5
  GND1 w0.104: v3(147.48,60.21) 147.06,60.21 v2(147,60.15) ; v2(139.38,24.5) v3(139.81,24.5)
  IN1 w0.071: v3(139.81,24.5) 142.09,24.5 142.61,25.01 143.67,25.01 144.4,25.74 150.97,25.74 152.2,26.97 165.44,26.97 166.62,25.78 168.71,25.78 169.39,26.46 173.63,26.46 176.44,29.28 176.44,29.76 179.53,32.85 179.53,33.9 179.86,34.23 179.86,38.23 179.6,38.49 179.6,48.3 174.93,52.97 172.44,52.97 172.24,53.17 170.31,53.17 169.13,54.35 167.22,54.35 164.76,56.81 163.53,56.81 163.32,57.01 157.4,57.01 156.62,57.8 153.82,57.8 153.41,58.21 153.41,60.65 152.01,62.05 150.92,62.05 149.87,61 149.87,60.72 149.65,60.51 149.33,60.51 149.17,60.67 148.1,60.67 147.64,60.21 v3(147.48,60.21)
TP_CLK_C: length 11.5
  TOP w0.122: v1(141.83,26.63) 141.54,26.34 C1157.1 L60.2 140.58,23.89 DE1.2 140.22,23.18 v7(139.61,22.57)
  BOTTOM w0.122: v7(139.61,22.57) 141.25,24.21 JTP1.3
TP_DATA: length 114.7
  TOP w0.076: U34.B5 145.17,60.35 146.44,60.35 146.69,60.6
  TOP w0.122: v7(143.47,24.55) 143.24,24.32 143.24,21.48 142.53,20.76 137.7,20.76 137.26,21.21 L59.1 136.96,21.21 v1(135.59,21.21) 135.4,21.21 134.93,21.68 C1154.1 ; R224.2 147.36,60.63 v2(146.72,60.63) 146.69,60.6
  GND1 w0.104: v3(146.29,60.87) 146.53,60.63 146.72,60.63 v2(146.72,60.63)
  IN1 w0.071: v7(143.47,24.55) 144.44,25.52 160.27,25.52 161.53,26.79 165.36,26.79 166.55,25.6 168.79,25.6 169.47,26.28 173.7,26.28 176.62,29.2 176.62,29.64 179.72,32.74 179.72,33.84 180.04,34.16 180.04,38.3 179.77,38.57 179.77,48.39 175.01,53.15 172.52,53.15 172.33,53.34 170.4,53.34 169.21,54.53 167.28,54.53 164.84,56.98 163.6,56.98 163.16,57.42 157.31,57.42 156.76,57.97 153.89,57.97 153.58,58.28 153.58,60.74 152.08,62.24 149.2,62.24 148.88,61.91 148.88,61.58 148.62,61.33 147.97,61.33 147.57,60.92 146.34,60.92 v3(146.29,60.87)
TP_DATA_C: length 12
  TOP w0.122: v7(140.24,22.54) 140.24,21.63 DE1.3 139.53,21.6 139,22.14 C1156.1 137.84,22.41 L59.2 135.79,22.41 v1(135.63,22.57)
  BOTTOM w0.122: v7(140.24,22.54) 140.24,22.57 141.94,24.27 141.94,26.76 142.25,27.06 JTP1.2
TPM_DET: length 7.5
  IN4 w0.071: v5(108.8,56.32) 108.69,56.32 v5(108.36,55.99)
  GND5 w0.104: v5(108.36,55.99) 108.36,55.79 v6(108.16,55.59) ; v5(108.8,56.32) 108.54,56.58 v6(108.46,56.58)
  BOTTOM w0.122: UH1.AA3 v6(108.46,56.58) ; v6(108.16,55.59) 107.7,55.13 107.28,55.13 106.71,54.55 106.45,54.55 106,54.1 v1(106,53.95) 106,53.04 RH274.2 105.36,52.43 RH337.1
TRIP_+V1.05S_VCCPP: length 3.1
  TOP w0.254: PU500.2 125.65,48.37 125.94,48.65 127.95,48.65 PR502.2
UG_3V: length 3.9
  IN1 w1.016: 190.05,57.24 190.05,58.56 191.35,59.86 192.13,59.86
  vias: v7(190.23,56.27) v7(194.34,60.19) v7(195,60.19) v8(190.86,56.27)
UG_5V: length 7.3
  IN1 w1.016: 196.48,56.71 196.58,56.71 198.38,58.51 198.38,61.15 199.78,62.55
  vias: v7(196.07,56.22) v7(196.7,56.22) v7(200.34,63.33) v7(201,63.33)
UG_+V1.05S_VCCPP: length 18.6
  IN4 w1.016: 111.08,46.29 111.08,45.43 114.38,42.13 126.27,42.13 126.5,42.35 126.5,43.19
  vias: v7(110.75,47.26) v7(111.54,47.26) v7(126.12,44.16) v7(126.75,44.16)
UGATE: length 2.2
  IN4 w1.016: 141.54,37.63 142.07,37.1 143.52,37.1
  vias: v7(140.14,37.91) v7(140.16,37.27) v7(144.38,37.31) v7(145.02,37.3)
UGATE1: length 12.7
  TOP w0.122: v1(26.39,76.42) 26.85,76.89 v7(26.85,77.3)
  IN1 w1.016: 27.62,76.8 29.45,74.97 29.45,71.03 31.94,68.54 33.46,68.54 33.46,68.54
  vias: v7(26.35,77.69) v7(33.2,67.14) v7(33.84,67.14)
UGATE1G: length 4.6
  IN1 w1.016: 19.49,77.18 16.75,74.43 16.75,73.75
  vias: v7(17.1,73.39) v7(17.1,72.76) v7(20.2,78.65) v7(20.23,77.99) v9(17.1,73.98)
USB3RN0: length 147.3
  IN4 w0.071: v5(96.98,66.03) 96.78,66.03 96.59,66.22 96.59,66.33 96.66,66.4 96.93,66.4 97.67,67.13 97.67,67.2 98.04,67.58 99.14,67.58 99.9,66.81 100.68,66.81 100.91,66.58 100.91,66.15 101.54,65.52 101.54,64.83 102.22,64.15 102.22,63.54 102.89,62.88 104.78,62.88 104.88,62.98 105.29,62.98 106.84,61.43 109.24,61.43 109.36,61.54 110.43,61.54 113.06,58.92 113.68,58.92 114.22,58.38 114.41,58.38 114.52,58.27 114.9,57.89 115.93,57.89 116.01,57.81 121.07,57.81 121.74,57.14 125.33,57.14 126.68,58.5 127.64,58.5 128.65,57.48 135.91,57.48 136.29,57.86 137.9,57.86 138.78,56.98 140.68,56.98 140.75,57.05 146.85,57.05 148.4,58.6 150.46,58.6 151.23,57.84 156.04,57.84 156.34,57.53 157.91,57.53 158.02,57.43 158.52,57.43 158.79,57.7 160.56,57.7 160.86,57.39 167.69,57.39 168.34,58.04 171.22,58.04 175.62,62.45 175.62,63.13 178.75,66.26 185.81,66.26 188.36,68.81 204.19,68.81 209.33,63.67 209.33,57.7 206.47,54.84 203.35,54.84 202.99,54.48 202.99,54.01 203.23,53.77 203.44,53.77 203.69,53.52 v8(203.69,53.48)
  GND5 w0.076: v6(96.98,66.45) v5(96.98,66.03)
  BOTTOM w0.114: UH1.BJ25 v6(96.98,66.45) ; v8(203.69,53.48) 203.95,53.74 204.17,53.74 204.5,53.41 L54.4 205.06,53.3 R892.1
USB3RN0_RC_CON: length 22.5
  IN1 w0.071: JUSB2.5 220.5,59.47 219.19,58.17 215.81,58.17 214.08,59.89 212.25,59.89 211.11,58.75 211.11,57.51 211.93,56.68 212.17,56.68 v7(212.43,56.43)
  BOTTOM w0.114: v7(212.43,56.43) 212.27,56.58 211.97,56.58 211.78,56.39 D82.1 210.49,56.39 210.28,56.6 210.16,56.6 209.86,56.29 v7(209.86,56.05) 209.86,55.81 209.5,55.45 209.1,55.05 208.88,55.05 208.59,54.77 208.59,54.54 207.79,53.74 207.46,53.74 207.13,53.41 L54.3 206.54,53.3 R892.2
USB3RN1: length 184
  IN4 w0.071: v5(96.73,66.89) 96.62,67.01 96.62,67.26 97.04,67.68 97.2,67.68 97.53,68.01 99.12,68.01 99.68,68.57 99.68,70.15 100.27,70.75 100.94,70.75 101.28,71.08 103.74,71.08 104.42,70.41 104.68,70.41 105.7,69.38 107.46,69.38 108.06,68.78 108.87,68.78 110.79,66.87 110.79,65.72 112.11,64.4 117.51,64.4 117.96,63.94 118.47,63.94 118.82,63.59 118.82,61.73 119.59,60.96 120.36,60.96 120.48,61.08 122.57,61.08 122.64,61.15 123.43,61.15 124.32,60.26 129.83,60.26 130.03,60.46 137.25,60.46 137.44,60.27 139.95,60.27 141.36,61.68 147.6,61.68 148.17,62.26 151.92,62.26 154.41,59.77 156.39,59.77 156.48,59.68 158.77,59.68 159.03,59.41 166.79,59.41 168.3,60.93 169.02,60.93 170.64,62.55 171.71,62.55 173.16,64 173.16,64.6 176.71,68.16 179.17,68.16 179.2,68.14 179.71,68.14 179.73,68.16 180.68,68.16 180.96,67.88 184.45,67.88 186.89,70.32 191.8,70.32 192.34,70.85 199.27,70.85 199.87,71.45 201.4,71.45 201.89,71.93 203.32,71.93 211.82,63.44 211.82,62.12 214.36,59.58 214.36,54.17 215.82,52.71 215.82,42.04 215.81,42.02 215.81,25.03 216.78,24.05 219.16,24.05 219.5,24.4 219.5,25.17 v7(219.79,25.46)
  GND5 w0.076: v5(96.73,66.89) 96.73,67.01 v6(96.98,67.26)
  BOTTOM w0.114: UH1.BJ27 v6(96.98,67.26) ; R560.1 219.92,24.38 L46.1 219.81,24.75 219.5,25.06 219.5,25.17 v7(219.79,25.46)
USB3RN1_RC_CON: length 33
  IN1 w0.071: v8(222.03,21.37) 222.28,21.12 222.77,21.12 222.89,21.25 222.89,21.96 222.18,22.67 222.18,28.28 221.63,28.83 217.64,28.83 216.4,30.07 216.4,38.61 217.34,39.55 217.59,39.55 218.62,40.58 218.83,40.58 218.92,40.67 JUSB1.5
  BOTTOM w0.114: R560.2 219.92,22.89 L46.2 219.81,22.21 219.72,22.11 219.44,22.11 219.36,22.03 219.36,21.44 219.71,21.08 219.85,21.08 220.12,21.36 D74.1 221.34,21.36 221.58,21.12 221.77,21.12 v8(222.03,21.37)
USB3RP0: length 147.3
  IN4 w0.071: v8(203.69,54.11) 203.51,53.94 203.3,53.94 203.16,54.08 203.16,54.41 203.42,54.67 206.54,54.67 209.49,57.63 209.49,63.73 204.25,68.97 188.29,68.97 185.74,66.42 178.68,66.42 175.46,63.2 175.46,62.51 171.15,58.2 168.27,58.2 167.62,57.56 160.93,57.56 160.62,57.86 158.72,57.86 158.45,57.59 158.09,57.59 157.98,57.7 156.41,57.7 156.11,58 151.29,58 150.53,58.76 148.33,58.76 146.78,57.21 140.68,57.21 140.61,57.15 138.85,57.15 137.97,58.03 136.22,58.03 135.84,57.65 128.72,57.65 127.71,58.66 126.61,58.66 125.26,57.31 121.81,57.31 121.14,57.98 116.07,57.98 116,58.05 114.97,58.05 114.48,58.55 114.28,58.55 113.75,59.08 113.13,59.08 110.5,61.71 109.29,61.71 109.17,61.59 106.91,61.59 105.36,63.14 104.82,63.14 104.71,63.04 102.96,63.04 102.39,63.61 102.39,64.22 101.71,64.9 101.71,65.59 101.07,66.22 101.07,66.65 100.75,66.98 99.97,66.98 99.2,67.74 97.97,67.74 97.5,67.27 97.5,67.2 96.86,66.56 96.59,66.56 96.43,66.4 96.43,66.29 96.18,66.05 v5(96.13,66.05)
  GND5 w0.076: v5(96.13,66.05) 96.13,66.43 v6(96.12,66.45)
  BOTTOM w0.114: R893.1 205.06,54.32 L54.1 204.57,54.21 204.36,54 203.81,54 v8(203.69,54.11) ; UH1.BL25 v6(96.12,66.45)
USB3RP0_RC_CON: length 22.5
  IN1 w0.071: v7(212.43,57.06) 212.21,56.85 212,56.85 211.27,57.57 211.27,58.68 212.32,59.73 214.01,59.73 215.74,58 219.26,58 220,58.74 220.28,58.74 220.45,58.56 220.45,57.65 JUSB2.6
  BOTTOM w0.114: v7(212.43,57.06) 212.2,56.84 211.97,56.84 211.77,57.04 D82.2 210.64,57.04 210.46,56.86 210.06,56.86 209.6,56.4 209.6,55.92 208.99,55.31 208.77,55.31 208.33,54.87 208.33,54.65 v7(207.97,54.28) 207.68,54 207.07,54 206.86,54.21 L54.2 206.54,54.32 R893.2
USB3RP1: length 184
  IN4 w0.071: v5(96.32,66.89) 96.32,66.91 96.45,67.04 96.45,67.33 96.97,67.84 97.13,67.84 97.46,68.17 99.05,68.17 99.51,68.64 99.51,70.22 100.2,70.91 100.87,70.91 101.21,71.25 103.81,71.25 104.48,70.57 104.75,70.57 105.77,69.55 107.53,69.55 108.12,68.95 108.94,68.95 110.95,66.93 110.95,65.79 112.18,64.57 117.58,64.57 118.03,64.11 118.54,64.11 118.99,63.66 118.99,61.8 119.66,61.12 120.29,61.12 120.41,61.25 122.5,61.25 122.57,61.32 123.5,61.32 124.39,60.43 129.76,60.43 129.96,60.63 137.32,60.63 137.51,60.44 139.88,60.44 141.29,61.85 147.53,61.85 148.1,62.42 151.99,62.42 154.48,59.93 156.46,59.93 156.55,59.84 158.84,59.84 159.1,59.58 166.72,59.58 168.23,61.09 168.95,61.09 170.58,62.71 171.64,62.71 172.99,64.06 172.99,64.67 176.65,68.33 179.24,68.33 179.26,68.3 179.64,68.3 179.66,68.33 180.75,68.33 181.03,68.05 184.39,68.05 186.82,70.48 191.73,70.48 192.27,71.02 199.2,71.02 199.8,71.62 201.34,71.62 201.82,72.1 203.39,72.1 211.98,63.51 211.98,62.18 214.52,59.64 214.52,54.23 215.98,52.77 215.98,41.97 215.97,41.96 215.97,25.1 216.85,24.22 219.09,24.22 219.34,24.47 219.34,25.16 v8(219.03,25.46)
  GND5 w0.076: v5(96.32,66.89) 96.32,67.05 v6(96.12,67.26)
  BOTTOM w0.114: v6(96.12,67.26) UH1.BL27 ; R565.1 218.9,24.38 L46.4 219.01,24.77 219.24,25 219.24,25.26 v8(219.03,25.46)
USB3RP1_RC_CON: length 33
  IN1 w0.071: v7(222.03,20.69) 222.3,20.95 222.83,20.95 223.06,21.18 223.06,22.03 222.35,22.74 222.35,28.35 221.7,28.99 217.71,28.99 216.57,30.14 216.57,38.54 217.41,39.38 217.66,39.38 218.69,40.41 218.83,40.41 218.92,40.32 JUSB1.6
  BOTTOM w0.114: R565.2 218.9,22.89 L46.3 219.01,22.12 219.1,22.03 219.1,21.33 219.61,20.83 219.92,20.83 220.04,20.71 D74.2 221.42,20.71 221.57,20.86 221.86,20.86 v7(222.03,20.69)
USB3TN0: length 143.7
  IN4 w0.071: v8(201.23,54.19) 200.97,54.44 200.8,54.44 200.44,54.81 200.44,55.43 200.93,55.92 204.88,55.92 208.55,59.59 208.55,63.24 203.76,68.03 188.69,68.03 186.13,65.47 179.04,65.47 176.46,62.89 176.46,62.15 170.93,56.62 158.61,56.62 158.57,56.65 148.76,56.65 148.37,56.26 140.07,56.26 139.91,56.43 137.69,56.43 137.14,56.98 136.7,56.98 136.44,56.72 128.13,56.72 127.66,56.25 124.88,56.25 124.75,56.38 121.12,56.38 120.79,56.71 119.35,56.71 119.11,56.94 118.41,56.94 118.4,56.95 113.83,56.95 113.04,56.16 111.56,56.16 111.51,56.21 110.42,56.21 110.14,56.49 109.11,56.49 108.83,56.77 108.07,56.77 107.04,57.79 107.04,57.89 106.5,58.43 105.87,58.43 104.69,59.61 104.69,60.86 103.24,62.31 102.74,62.31 101.8,63.26 101.8,63.75 100.65,64.89 99.31,64.89 98.19,66.01 98.19,67.26 v5(98.18,67.27)
  GND5 w0.076: v5(98.18,67.27) 98.18,67.03 v6(98.01,66.87)
  BOTTOM w0.114: v6(98.01,66.87) UH1.BF26 ; v8(201.23,54.19) 201.51,54.47 201.78,54.47 202.08,54.76 202.08,55.29 202.21,55.43 202.38,55.43 C1108.1
USB3TN0_C: length 2
  BOTTOM w0.114: C1108.2 203.83,55.42 204.14,55.42 204.24,55.52 204.39,55.52 204.6,55.31 L53.4 205.06,55.21 R891.1
USB3TN0_RC_CON: length 21.3
  IN1 w0.071: v7(212.91,57.65) 212.68,57.87 212.47,57.87 212.14,58.21 212.14,58.5 212.68,59.04 213.2,59.04 213.72,58.52 213.72,58.52 218.92,53.33 219.2,53.33 219.65,52.87 220.06,52.87 220.5,53.31 JUSB2.8
  BOTTOM w0.114: R891.2 206.54,55.21 L53.3 207.07,55.31 207.34,55.58 207.58,55.58 208,55.99 208,56.53 208.8,57.34 209.18,57.34 v7(209.45,57.61) 209.59,57.74 209.78,57.93 210.14,57.93 210.39,57.69 D82.3 212.18,57.69 212.34,57.84 212.71,57.84 v7(212.91,57.65)
USB3TN1: length 180.5
  IN4 w0.071: v7(222.87,26.4) 223.22,26.05 223.22,24.54 222.02,23.34 216.49,23.34 215.17,24.66 215.17,52.45 213.72,53.9 213.72,59.15 210.61,62.26 210.61,63.73 204.61,69.74 187.9,69.74 185.4,67.23 177.28,67.23 169.78,59.73 168.53,59.73 167.4,58.61 167.12,58.61 167.02,58.51 164.76,58.51 164.62,58.65 156.61,58.65 156.13,59.13 153.21,59.13 152.63,59.72 151.7,59.72 151.65,59.66 150.75,59.66 149.97,60.44 149.25,60.44 148.84,60.85 144.9,60.85 144,59.94 141.37,59.94 140.5,59.08 137.82,59.08 137.08,59.82 134.24,59.82 132.87,58.45 129.07,58.45 128.01,59.5 125.2,59.5 124.8,59.11 124.43,59.11 124.26,59.28 123.24,59.28 123.13,59.17 121.96,59.17 121.77,59.36 120.45,59.36 120.01,59.79 118.63,59.79 117.77,58.93 116.86,58.93 115.93,59.87 115.25,59.87 114.65,60.47 114.65,60.67 113.85,61.47 111.94,61.47 111.45,61.96 111.45,62.17 111.12,62.5 110.69,62.5 110.44,62.26 109,62.26 108.39,62.86 107.71,62.86 107.69,62.84 107.04,62.84 105.78,64.1 104.62,64.1 100.79,67.93 100.3,67.93 100.08,67.71 100.08,67.55 99.98,67.45 v5(99.96,67.45)
  GND5 w0.076: v6(99.74,67.83) 99.96,67.61 v5(99.96,67.45)
  BOTTOM w0.114: UH1.BB28 v6(99.74,67.83) ; v7(222.87,26.4) 223.07,26.2 223.07,25.64 222.76,25.33 C623.1
USB3TN1_C: length 1.9
  BOTTOM w0.114: R556.1 222.71,23.06 L45.4 222.82,23.49 223.06,23.72 223.06,24.07 C623.2
USB3TN1_RC_CON: length 27.1
  IN2 w0.094: v7(218.62,20.64) 218.9,20.36 219.18,20.36 219.4,20.57 219.4,21.51 216.39,24.52 216.39,34.22 216.99,34.83 217.72,34.83 218.71,33.84 218.86,33.84 218.92,33.89 JUSB1.8
  BOTTOM w0.114: v7(218.62,20.64) 218.82,20.44 219.06,20.44 219.64,19.86 219.69,19.86 219.89,20.06 D74.3 221.6,20.06 221.96,19.7 222.21,19.7 v7(222.58,20.07) 223.19,20.68 223.19,20.84 223.15,20.88 222.88,20.88 222.82,20.94 L45.3 222.71,21.57 R556.2
USB3TP0: length 143.7
  IN4 w0.071: v8(201.23,54.95) 201.23,54.8 201.04,54.61 200.87,54.61 200.6,54.88 200.6,55.36 201,55.75 204.95,55.75 208.72,59.52 208.72,63.31 203.83,68.2 188.62,68.2 186.06,65.63 178.97,65.63 176.3,62.96 176.3,62.22 170.86,56.78 158.68,56.78 158.64,56.82 148.69,56.82 148.3,56.43 140.14,56.43 139.97,56.59 137.75,56.59 137.2,57.14 136.63,57.14 136.37,56.89 128.06,56.89 127.59,56.41 124.95,56.41 124.82,56.54 121.19,56.54 120.86,56.87 119.42,56.87 119.18,57.11 118.48,57.11 118.47,57.11 113.76,57.11 112.97,56.32 111.63,56.32 111.58,56.38 110.49,56.38 110.21,56.65 109.18,56.65 108.9,56.93 108.13,56.93 107.21,57.86 107.21,57.96 106.57,58.6 105.94,58.6 104.85,59.68 104.85,60.93 103.3,62.48 102.81,62.48 101.96,63.32 101.96,63.82 100.72,65.06 99.38,65.06 98.36,66.08 98.36,66.94 v5(98.69,67.27)
  GND5 w0.076: v5(98.69,67.27) 98.69,67.07 v6(98.87,66.88)
  BOTTOM w0.114: v8(201.23,54.95) 201.45,54.73 201.68,54.73 201.82,54.87 201.82,55.4 202.11,55.69 202.3,55.69 202.66,56.04 C1107.1 ; UH1.BD26 v6(98.87,66.88)
USB3TP0_C: length 2.1
  BOTTOM w0.114: R890.1 205.06,56.22 L53.1 204.72,56.11 204.39,55.78 204.13,55.78 204.03,55.68 203.94,55.68 C1107.2
USB3TP0_RC_CON: length 21.2
  IN1 w0.071: JUSB2.9 220.47,51.63 220.47,52.51 220.27,52.71 219.58,52.71 219.13,53.16 218.85,53.16 213.66,58.36 213.14,58.88 212.74,58.88 212.3,58.43 212.3,58.28 212.54,58.04 212.67,58.04 v7(212.91,58.28)
  BOTTOM w0.114: R890.2 206.54,56.22 L53.2 206.88,56.11 207.16,55.84 207.48,55.84 207.74,56.1 v7(207.74,56.35) 207.74,56.64 208.69,57.59 209.07,57.59 209.4,57.93 209.67,58.19 210.25,58.19 210.4,58.34 D82.4 212.1,58.34 212.34,58.1 212.73,58.1 v7(212.91,58.28)
USB3TP1: length 180.4
  IN4 w0.071: v8(223.5,26.4) 223.39,26.29 223.39,24.47 222.09,23.18 216.42,23.18 215.01,24.59 215.01,52.38 213.56,53.83 213.56,59.08 210.45,62.19 210.45,63.67 204.54,69.57 187.97,69.57 185.47,67.07 177.35,67.07 169.85,59.57 168.59,59.57 167.47,58.45 167.19,58.45 167.09,58.34 164.7,58.34 164.56,58.48 156.54,58.48 156.06,58.97 153.14,58.97 152.56,59.55 151.77,59.55 151.72,59.5 150.68,59.5 149.91,60.27 149.18,60.27 148.77,60.68 144.97,60.68 144.07,59.78 141.44,59.78 140.57,58.92 137.75,58.92 137.01,59.65 134.31,59.65 132.94,58.28 129,58.28 127.94,59.33 125.27,59.33 124.87,58.94 124.37,58.94 124.19,59.11 123.3,59.11 123.2,59 121.89,59 121.7,59.19 120.38,59.19 119.95,59.63 118.7,59.63 117.84,58.76 116.8,58.76 115.86,59.7 115.18,59.7 114.48,60.4 114.48,60.6 113.78,61.3 111.87,61.3 111.28,61.89 111.28,62.1 111.05,62.33 110.75,62.33 110.51,62.09 108.93,62.09 108.32,62.7 107.78,62.7 107.75,62.67 106.97,62.67 105.71,63.93 104.55,63.93 100.72,67.76 100.37,67.76 100.25,67.64 100.25,67.5 100.3,67.45 v5(100.44,67.45)
  GND5 w0.076: v5(100.44,67.45) 100.44,67.68 v6(100.6,67.85)
  BOTTOM w0.114: v8(223.5,26.4) 223.33,26.23 223.33,25.6 C621.1 ; UH1.AY28 v6(100.6,67.85)
USB3TP1_C: length 2
  BOTTOM w0.114: C621.2 223.32,24.13 223.32,23.87 223.4,23.79 223.53,23.79 223.6,23.71 223.6,23.18 L45.1 223.62,23.05 223.68,22.99 R555.1
USB3TP1_RC_CON: length 27.1
  IN2 w0.094: v8(218.62,20) 218.78,20.16 219.26,20.16 219.6,20.49 219.6,21.59 216.59,24.6 216.59,34.14 217.08,34.63 217.63,34.63 218.62,33.64 218.83,33.64 218.92,33.56 JUSB1.9
  BOTTOM w0.114: v8(218.62,20) 218.8,20.18 218.96,20.18 219.53,19.6 219.69,19.6 219.89,19.41 D74.4 221.68,19.41 221.71,19.44 222.32,19.44 222.76,19.89 223.53,20.65 223.53,21.03 223.62,21.13 L45.2 223.68,21.52 R555.2
USB20_N0: length 123.9
  IN1 w0.071: v7(210.8,59.63) 210.59,59.84 210.14,59.84 209.4,60.58 209.4,72.63 207.77,74.27 201.6,74.27 198.02,77.85 195.23,77.85 193.44,79.64 188.26,79.64 184.49,75.87 184.49,75.73 181.59,72.83 169.18,72.83 168.28,73.74 153.73,73.74 153.58,73.58 149.61,73.58 148.3,72.28 146.76,72.28 146.5,72.53 138.55,72.53 138.18,72.9 136.66,72.9 136.2,72.44 134.04,72.44 132.58,70.98 129.61,70.98 129.47,70.84 129.04,70.84 127.48,69.28 127.48,68.23 125.14,65.9 119.76,65.9 119.59,65.74 118.92,65.74 118.55,66.1 115.77,66.1 115.64,65.98 115.07,65.98 114.48,65.39 114.48,64.94 114.56,64.86 114.69,64.86 v4(114.87,65.04)
  IN4 w0.091: v4(114.87,65.04) 114.69,65.04 114.55,65.18 114.55,65.48 v5(114.64,65.57)
  GND5 w0.076: v5(114.64,65.57) 114.64,65.24 v6(114.84,65.04)
  BOTTOM w0.114: v7(210.8,59.63) L52.1 211.76,59.52 R888.1 ; UH1.F24 114.85,65.05 v6(114.84,65.04)
USB20_N0_CONN: length 10.7
  BOTTOM w0.114: R888.2 213.25,59.52 L52.2 213.59,59.63 213.85,59.9 214.13,59.9 214.39,59.64 214.39,59.08 214.06,58.75 214.06,58.19 214.29,57.96 214.68,57.96 214.94,57.69 D82.6 216.39,57.69 216.58,57.88 216.76,57.88 217.44,57.2 217.44,55.77 217.7,55.51 218.09,55.51 JUSB2.2
USB20_N1: length 128
  TOP w0.114: v8(208.59,53.09) 208.83,53.32 209.79,53.32 210.02,53.55 210.55,53.55 210.67,53.43 UI1.7
  IN1 w0.071: v8(208.59,53.09) 208.31,53.37 208.14,53.37 207.92,53.59 207.92,54.48 209.24,55.8 209.24,58.87 208.72,59.39 208.72,72.41 207.52,73.61 201.36,73.61 197.77,77.2 194.79,77.2 193.02,78.98 188.5,78.98 185.35,75.83 185.35,75.66 181.7,72.01 168.59,72.01 167.5,73.1 154.33,73.1 154.16,72.94 150.8,72.94 149.09,71.23 146.39,71.23 145.89,71.73 139.23,71.73 138.4,70.9 135.32,70.9 133.46,69.05 131.33,69.05 129.44,67.16 127.32,67.16 125.42,65.26 120.03,65.26 119.84,65.07 118.66,65.07 118.29,65.44 117.85,65.44 117.34,64.94 116.44,64.94 116.19,65.18 116.19,65.36 116.03,65.52 v4(116.03,65.52)
  IN4 w0.091: v5(116.06,66) 116.2,65.86 116.2,65.68 v4(116.03,65.52)
  GND5 w0.076: v6(115.88,65.63) 116.06,65.81 v5(116.06,66)
  BOTTOM w0.114: v6(115.88,65.63) UH1.C25
