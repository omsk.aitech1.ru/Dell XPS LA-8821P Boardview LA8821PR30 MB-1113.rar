# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SYNC_AUDIO: length 154.2
  TOP w0.122: v2(127.74,70.24) 128.05,69.94 129.22,69.94 130.17,70.89 RH33.1 ; v7(93.42,56.46) 93.42,55.91 92.35,54.84 92.35,54.78 90.54,52.97 88.64,52.97 82.95,47.28 78.5,47.28 78.31,47.09 61.39,47.09 60.36,48.13 58.67,48.13 57.04,46.49 56.26,46.49 55.29,47.46 54.5,47.46 54,47.96 53.17,47.96 52.42,47.2 36.58,47.2 35.87,46.49 32.94,46.49 32.36,47.07 28.35,47.07 27.69,47.73 21.31,47.73 v1(20.61,47.03) 20.61,46.4 20.23,46.01 19.34,46.01 19.26,45.94 v7(19.26,45.81)
  GND1 w0.104: v3(127.18,70.24) v2(127.74,70.24)
  IN1 w0.071: v3(127.18,70.24) 126.68,69.74 126.68,68.39 124.85,66.56 121.37,66.56 119.77,68.16 115.58,68.16 114,66.59 111.59,66.59 111.02,66.02 111.02,65.14 110.67,64.79 110.67,64.27 110.78,64.17 110.78,63.82 110.37,63.41 110.07,63.41 109.5,62.85 109.5,62.38 108.03,60.91 108.03,60.56 107.48,60 107.02,60 106.9,60.12 106.15,60.12 103.39,57.37 95.54,57.37 94.72,56.55 94.33,56.55 94.19,56.69 93.64,56.69 v7(93.42,56.46)
  IN2 w0.094: v7(18.19,23.84) 18.16,23.84 17.06,24.94 17.06,29.56 16.85,29.76 16.85,39.61 17.07,39.83 17.07,40.36 17.7,41 17.7,41.89 18.9,43.08 18.9,45.45 v7(19.26,45.81)
  BOTTOM w0.122: JIOL1.18 18.1,23.93 v7(18.19,23.84)
HDA_SYNC_R: length 5
  TOP w0.122: RH36.1 130.41,69.98 RH33.2 RH275.2 ; RH275.2 131.33,72.28 v1(130.8,72.8) ; RH275.2 131.35,71.87 QH1.3
HUB_OSC_IN: length 4.2
  TOP w0.122: Y2.1 160.81,68.55 C1204.1 160.34,67.36 160.05,67.36 v1(159.66,66.97) 159.52,66.83 159.52,65.85 U636.D8
HUB_OSC_OUT: length 9.9
  TOP w0.076: U636.D7 159.3,65.57 159.3,65.92 159.27,65.95 159.27,66.26
  TOP w0.122: v2(161.37,67.5) 161.81,67.5 C1205.1 162.14,69.73 Y2.3 ; 159.27,66.26 159.27,66.69 158.99,66.97 v2(158.9,66.97)
  GND1 w0.104: v2(161.37,67.5) v3(160.92,67.04) ; v3(159.38,66.93) 158.93,66.93 v2(158.9,66.97)
  IN1 w0.071: v3(160.92,67.04) 159.49,67.04 v3(159.38,66.93)
HWPG: length 10.3
  TOP w0.122: R930.2 143.02,66.83 R933.1 R934.1 R982.1 R931.1 145.85,66.67 v1(145.85,65.44) 145.85,64.47 145.16,63.78 144.64,63.78 144.38,63.51 143.95,63.51 143.74,63.3 143.44,63.3 143.05,62.91 143.05,62.71 142.92,62.59 U34.F1
I2C_INT#: length 2.5
  TOP w0.076: 160.03,66.26 160.03,65.84 U636.E8
  TOP w0.122: T249.1 161.57,67.05 160.77,67.05 160.03,66.31 160.03,66.26
ICOMP: length 1.9
  TOP w0.254: PR35.2 148.69,40.31 v7(148.85,40.47)
  BOTTOM w0.254: v7(148.85,40.47) 148.72,40.35 PU2.5
IN+: length 2.7
  TOP w0.254: PR962.1 127.73,30.87 PC1915.1 127.69,30.81 127.41,30.53 126.85,30.53 126.64,30.74 PU702.4
IN-: length 4.8
  TOP w0.254: PR963.2 128.62,30.85 PC1915.2 128.61,30.52 128.23,30.14 126.5,30.14 125.99,30.65 PU702.5
INIT3_3V#: length 3
  TOP w0.122: T127.1 111.34,57.37 v2(111.34,57.06)
  GND1 w0.104: v3(111.76,57.02) 111.77,57.02 111.77,57.04 111.74,57.04 111.72,57.06 v2(111.34,57.06)
  IN1 w0.071: v4(111.31,57.46) 111.32,57.46 v3(111.76,57.02)
  IN4 w0.071: v5(111.26,57.97) 111.31,57.91 v4(111.31,57.46)
  GND5 w0.104: v5(111.26,57.97) v6(111.26,58.46)
  BOTTOM w0.122: UH1.R6 v6(111.26,58.46)
INV_PWM_R: length 9.1
  TOP w0.122: v7(159.75,78.63) 159.67,78.7 C1151.1 R545.1 159.06,77.03 158.31,76.28 v1(158.31,75.59) 158.39,75.59 159.34,74.64 D73.1 D92.1
  BOTTOM w0.122: JLVDS1.14 v7(159.75,78.63)
ISEN2: length 4.9
  BOTTOM w0.254: PU700.12 26.62,81.94 26.83,82.16 26.83,82.72 27.26,83.15 v1(27.26,84.06) 28.63,85.43 PR736.2
ISEN2G: length 2.3
  BOTTOM w0.254: PR720.2 22.22,84.61 22.22,83.91 22.58,83.55 PU700.3
ISL9519_VDD: length 23.5
  TOP w0.122: v1(151.82,44.69) 151.82,44.33 151.09,43.6 150.81,43.6 150.58,43.37 150.24,43.37 149.98,43.12 149.98,42.29 150.55,41.73 150.55,40.38 151.43,39.5 151.43,37.99 153.33,36.08 v2(153.36,36.08)
  TOP w0.254: PD9.2 150.77,34.8 PC34.1 149.74,35.83 PR32.2 148.76,35.83 147.94,35 v7(147.94,34.43)
  GND1 w0.254: v2(153.36,36.08) v3(152.76,36.08)
  IN1 w0.254: v7(147.94,34.43) 149.59,36.08 v3(152.76,36.08)
  BOTTOM w0.203: v7(147.94,34.43) 147.95,34.44 147.95,35.53 PU2.19
JNTRST: length 29.8
  TOP w0.076: 157.66,63.87 157.73,63.87 157.93,64.07 158.3,64.07 U636.B4
  TOP w0.122: v2(156.7,64.25) 157.08,63.87 157.66,63.87 ; R1098.2 153.47,70.33 v2(153.49,70.32) 153.77,70.04 v1(154.08,70.04)
  GND1 w0.104: v2(156.7,64.25) 156.7,64.48 v2(156.33,64.85) v3(156.33,65.28) ; v3(153.94,70.15) 153.78,70.32 v2(153.49,70.32)
  IN1 w0.071: v4(159.25,65) 158.97,65.28 v3(156.33,65.28) 156.33,65.78 155.9,66.2 155.22,66.2 154.38,67.05 154.38,68.17 153.45,69.09 153.45,69.71 153.89,70.15 v3(153.94,70.15)
  IN4 w0.071: v5(158.49,64.21) 159.25,64.97 v4(159.25,65)
  GND5 w0.104: v5(158.49,64.21) v6(158.06,64.21)
  BOTTOM w0.122: JSATA1.16 166.36,63.22 164.76,61.63 158.11,61.63 157.32,62.42 157.32,63.47 v6(158.06,64.21)
JTCK: length 34.5
  TOP w0.076: U636.B2 158.3,62.57 157.66,62.57
  TOP w0.122: v2(157.58,62.57) 157.58,62.57 157.66,62.57 ; v1(154.69,71.74) 154.82,71.87 v2(154.82,72.2) 154.82,72.35 154.81,72.36 154.81,73.64 155.23,74.06 R1099.2
  GND1 w0.104: v2(154.82,72.2) v3(154.82,71.77) ; v2(157.58,62.57) 157.57,62.57 v3(157.13,62.57)
  IN1 w0.071: v3(154.82,71.77) 154.49,71.43 152.31,71.43 151.89,71.86 150.95,71.86 150.16,71.07 150.16,70.35 151.78,68.72 151.78,66.57 153.42,64.93 153.42,64.45 155,62.86 v4(156.67,62.86) 156.97,62.57 v3(157.13,62.57)
  IN4 w0.071: v5(157.41,62.46) 157.08,62.46 v4(156.67,62.86)
  GND5 w0.104: v6(157.91,62.31) 157.76,62.46 v5(157.41,62.46)
  BOTTOM w0.122: v6(157.91,62.31) 158.35,61.87 164.21,61.87 166.36,64.03 JSATA1.14
JTDI: length 33
  TOP w0.076: U636.C3 158.8,63.07 158.44,63.07 158.44,63.07 158.15,63.07 158.15,63.07 157.94,63.07 157.94,63.07 157.74,63.07 v2(157.68,63)
  TOP w0.122: v2(151.73,72.86) 151.96,73.09 151.96,73.57 R1097.2 v1(152.46,75.2)
  GND1 w0.104: v3(151.65,72.31) 151.73,72.4 v2(151.73,72.86) ; v2(157.68,63) 157.97,62.71 v3(158.01,62.71)
  IN1 w0.071: v4(158.17,63.4) 158.01,63.23 v3(158.01,62.71) 157.56,62.27 155.36,62.27 153.25,64.37 153.25,64.86 151.61,66.5 151.61,68.65 149.98,70.28 149.98,71.16 151.14,72.31 v3(151.65,72.31)
  IN4 w0.071: v4(158.17,63.4) v5(158.72,63.4)
  GND5 w0.104: v5(158.72,63.4) v6(159.23,63.4)
  BOTTOM w0.122: JSATA1.12 166.36,64.82 163.66,62.12 160.5,62.12 v6(159.23,63.4)
JTDO: length 29.7
  TOP w0.122: U636.A4 157.93,63.82 157.73,63.61 156.37,63.61 v2(156.33,63.65) ; v1(154.01,75.15) 153.4,74.54 R1096.2 152.93,73.59 152.93,72.81 152.9,72.79 152.9,70.74 v2(152.89,70.73)
  GND1 w0.104: v3(156.18,64.31) 156.18,63.8 v2(156.33,63.65) ; v2(152.89,70.73) 152.89,70.36 152.79,70.27 v3(152.76,70.27)
  IN1 w0.071: v3(152.76,70.27) 152.76,69.54 154.16,68.14 154.16,66.73 155.21,65.67 155.21,64.58 155.65,64.15 156.02,64.15 v3(156.18,64.31) 156.51,64.64 v4(157.22,64.64)
  IN4 w0.071: v4(157.22,64.64) 157.31,64.73 v5(157.79,64.73)
  GND5 w0.104: v5(157.79,64.73) 157.88,64.64 v6(158.36,64.64)
  BOTTOM w0.122: v6(158.36,64.64) 158.73,64.64 161,62.37 163.55,62.37 166.46,65.28 166.5,65.28 166.85,65.62 JSATA1.10
JTMS: length 31.7
  TOP w0.076: 160.14,61.81 160.14,61.86 159.8,62.21 159.8,63.57 U636.D4
  TOP w0.122: 160.14,61.81 v2(160.59,61.37) ; v1(155.37,75.06) 154.37,74.06 R1095.2 154.34,74.06 153.87,73.59 153.87,72.72 153.92,72.67 153.92,72.25 154.06,72.11 v2(154.06,71.39)
  GND1 w0.104: v3(161.55,61.94) 161.51,61.94 160.94,61.37 v2(160.59,61.37) ; v2(154.06,71.39) v3(154.06,70.95)
  IN1 w0.071: v3(154.06,70.95) 154.53,70.48 154.53,69.51 154.72,69.31 154.72,68.4 156.1,67.02 156.1,66.77 156.29,66.57 157.18,66.57 157.59,66.98 158.87,66.98 159.91,65.94 161.03,65.94 161.87,65.1 161.87,64.17 161.55,63.84 v4(161.55,62.81) v3(161.55,61.94)
  IN4 w0.071: v4(161.55,62.81) 161.96,62.81 v5(162.14,62.99)
  GND5 w0.104: v5(162.14,62.99) v6(162.69,62.99)
  BOTTOM w0.122: JSATA1.8 165.84,66.42 163.94,64.52 163.94,64.24 v6(162.69,62.99)
KB_BL_DET: length 118
  TOP w0.122: v2(175.72,31.08) 175.32,30.67 175.32,29.93 174.86,29.48 174.38,29.48 174.07,29.17 174.07,28.25 174.39,27.94 R945.2 174.32,27.18 R944.1 v1(174.32,25.25)
  GND1 w0.104: v2(175.72,31.08) v3(175.72,30.62)
  IN1 w0.071: v3(175.72,30.62) 175.72,30.67 v4(176.28,31.23)
  IN2 w0.094: v4(176.28,31.23) 176.28,31.84 179.31,34.87 179.31,40.84 179.43,40.96 179.43,43.58 178.12,44.89 177.43,44.89 176.38,45.94 176.38,49.68 174.57,51.49 171.16,51.49 170.87,51.21 170.22,51.21 168.71,49.7 159.39,49.7 158.03,48.35 148.83,48.35 145.69,51.48 145.69,53.59 143.36,55.92 140.78,55.92 140.09,56.62 139.08,56.62 137.36,58.34 136.56,58.34 135.91,58.99 135.55,58.99 135.23,58.67 134.67,58.67 133.83,59.51 129.99,59.51 129.9,59.43 129.24,59.43 128.49,60.17 127.18,60.17 126.73,60.63 126.73,62.13 126.57,62.29 126.57,62.92 124.77,64.71 119.16,64.71 117.75,66.12 113.44,66.12 111.97,67.59 111.97,71.97 112.29,72.3 112.96,72.3 113.47,71.8 115.92,71.8 v4(116.39,72.27)
  IN4 w0.071: v5(116.92,72.5) 116.63,72.5 v4(116.39,72.27)
  GND5 w0.104: v6(117.18,72.91) 116.92,72.66 v5(116.92,72.5)
  BOTTOM w0.122: UH1.A43 116.75,73.34 v6(117.18,72.91)
KB_DET#: length 157.3
  TOP w0.122: v7(145.6,27.83) 145.6,27.36 145.71,27.25 146.01,27.25 146.1,27.33 JKB1.1 ; v2(115.02,75.43) 115.02,75.43 115.84,76.25 v1(116.96,76.25) 117.76,76.25 118.42,76.91 118.42,77.72 RH302.1
  GND1 w0.104: v2(115.02,75.43) 115.17,75.43 v3(115.37,75.63)
  IN1 w0.071: v4(114.79,75.7) 115.3,75.7 v3(115.37,75.63)
  IN2 w0.094: v4(114.79,75.7) 114,75.7 113.44,76.26 112.49,76.26 110.94,74.71 110.94,74.31 109.38,72.75 109.38,71.78 109.15,71.55 109.15,71.19 109.47,70.87 109.47,69.71 109.28,69.51 109.28,68.97 109.47,68.78 109.47,67.04 108.55,66.12 107.98,66.12 107.67,65.8 107.67,64.55 108.1,64.11 108.1,62.98 107.63,62.51 107.63,60.16 107.32,59.86 107.32,59.3 106.69,58.66 106.69,56.96 106.95,56.69 107.08,56.69 107.83,55.94 108.1,55.94 108.98,55.06 120.77,55.06 121.01,55.31 128.51,55.31 128.96,55.77 134.96,55.77 135.76,54.97 136.67,54.97 137.67,53.97 142.52,53.97 143.74,52.75 143.74,50.67 148.02,46.39 158.92,46.39 160.27,47.74 166.7,47.74 167.43,47.02 171.91,47.02 177.13,41.8 177.13,34.39 175.73,32.98 174.75,32.98 173.32,31.56 173.32,31.17 170.14,27.98 157.23,27.98 156.19,26.94 152.13,26.94 151.54,26.35 147.07,26.35 v7(145.6,27.83)
  IN4 w0.071: v4(114.79,75.7) 114.97,75.53 v5(115.45,75.53)
  GND5 w0.104: v5(115.45,75.53) 115.08,75.53 v6(115.02,75.46)
  BOTTOM w0.254: UH1.D48 v6(115.02,75.46)
KB_LED_PWM: length 70.7
  TOP w0.076: U34.M9 139.67,57.85 139.28,57.85 139.12,57.7 v2(138.92,57.7)
  TOP w0.122: Q311.2 175.97,30.61 176.22,30.86 v2(176.22,31.36) 176.08,31.36 v1(175.83,31.61)
  GND1 w0.104: v2(176.22,31.36) 176.31,31.36 v3(176.59,31.64) ; v3(139.48,57.96) 139.21,57.7 v2(138.92,57.7)
  IN1 w0.071: v4(139.42,57.53) 139.48,57.59 v3(139.48,57.96) ; v4(177.12,32.02) 176.74,31.64 v3(176.59,31.64)
  IN2 w0.094: v4(139.42,57.53) 139.68,57.26 140.56,57.26 141.51,56.31 143.52,56.31 146.09,53.75 146.09,51.64 148.99,48.74 157.87,48.74 159.22,50.09 162.66,50.09 163.44,50.86 167.67,50.86 168.15,51.34 169.8,51.34 170.06,51.6 170.71,51.6 171,51.88 174.73,51.88 176.8,49.81 176.8,46.08 177.27,45.61 178.59,45.61 179.63,44.57 179.63,40.88 179.51,40.76 179.51,34.71 178.52,33.72 178.52,32.83 177.71,32.02 v4(177.12,32.02)
KB_LED_PWM#: length 3.2
  TOP w0.122: v1(175.36,27.2) 175.36,27.54 175.32,27.58 Q311.1 174.97,28.35 v7(174.56,28.77)
  BOTTOM w0.122: v7(174.56,28.77) 174.45,28.87 JBL1.1
KB_RST#: length 48.8
  TOP w0.076: v2(138.88,62.32) 138.88,62.23 139.26,61.85 140.17,61.85 U34.L2
  TOP w0.122: v2(110.07,56.81) 110.07,55.38 109.91,55.23 109.91,53.35 110,53.26 110,52.6 RH196.1
  GND1 w0.104: v3(139,62.74) 138.88,62.62 v2(138.88,62.32) ; v3(110.09,57.44) 110.14,57.39 110.14,56.88 v2(110.07,56.81)
  IN1 w0.071: v3(139,62.74) 139.11,62.85 139.11,63.61 138.53,64.2 137.63,64.2 136.94,64.89 131.86,64.89 131.38,64.4 131.38,64.09 130.57,63.28 130,63.28 128.17,61.44 128.17,60.84 127.88,60.55 127.81,60.55 124.67,57.41 123.79,57.41 123.27,57.93 123.27,58.16 122.76,58.67 121.17,58.67 120.73,58.24 118.79,58.24 118.6,58.05 117.71,58.05 115.68,60.08 115.05,60.08 114.92,60.22 113.72,60.22 113.06,60.87 113.06,61.07 112.83,61.3 111.61,61.3 110.17,59.86 110.17,58.66 109.84,58.33 v4(109.84,58) 109.84,57.7 v3(110.09,57.44)
  IN4 w0.071: v5(109.84,58.48) v4(109.84,58)
  GND5 w0.104: v6(109.81,58.03) 109.81,58.46 v5(109.84,58.48)
  BOTTOM w0.122: UH1.U6 v6(109.81,58.03)
KSI0: length 87.4
  TOP w0.122: v2(144.24,58.32) 144.14,58.32 U34.D9 ; JKB1.9 152.5,28.12 152.8,28.42 153.22,28.42 153.27,28.47 153.59,28.47 153.83,28.71 153.83,29.2 154.46,29.83 154.46,30.09 C1190.1 154.92,30.44 154.92,29.65 154.68,29.42 v1(154.68,29.37) v7(154.28,28.96)
  GND1 w0.104: v2(144.24,58.32) 144.24,58.19 v3(144,57.95)
  IN1 w0.071: v3(144,57.95) 144,57.92 144.81,57.11 144.81,56.63 145.3,56.14 146.07,56.14 146.34,56.42 147.25,56.42 147.41,56.57 149.52,56.57 149.78,56.83 151.18,56.83 151.85,56.15 157.94,56.15 158.35,55.74 159.6,55.74 159.61,55.75 162.93,55.75 163.41,55.27 164.26,55.27 167.96,51.57 170.72,51.57 171.19,52.04 174.55,52.04 176.55,50.04 176.55,45.91 177.38,45.08 177.38,38.37 177.71,38.03 177.71,34.43 175.74,32.46 175.74,31.57 171.59,27.41 166.31,27.41 165.78,27.94 155.3,27.94 v7(154.28,28.96)
KSI1: length 86.5
  TOP w0.076: 143.25,55.33 143.35,55.44 143.35,55.8 143.17,55.99 143.17,56.35 U34.E12
  TOP w0.122: JKB1.7 150.9,28.13 151.39,28.63 152.22,28.63 152.42,28.83 152.42,29.2 152.65,29.43 152.65,30.05 C1192.1 v7(153.09,29.86) ; 143.25,55.33 143.2,55.28 143.2,54.7 143.45,54.44 143.99,54.44 v2(144.01,54.47)
  GND1 w0.104: v3(145.21,54.41) 144.07,54.41 v2(144.01,54.47)
  IN1 w0.071: v3(145.21,54.41) 146.27,54.41 147.73,55.88 149.86,55.88 150.08,56.1 150.86,56.1 151.49,55.46 157.65,55.46 158.26,54.85 158.26,54.29 160.7,51.86 162.11,51.86 163.34,50.62 164.56,50.62 165.58,49.6 170.23,49.6 171.38,48.45 173.03,48.45 173.71,47.77 174.15,47.77 174.76,47.16 174.76,44.9 176.64,43.02 176.64,38.13 177.02,37.74 177.02,34.79 173.75,31.52 173.75,30.81 171.1,28.16 166.62,28.16 166.1,28.68 155.92,28.68 154.63,29.97 153.21,29.97 v7(153.09,29.86)
  BOTTOM w0.122: v1(153.73,31.66) 153.09,31.03 v7(153.09,29.86)
KSI2: length 89.7
  TOP w0.122: U34.E13 143.42,55.99 v2(143.64,55.77) ; v8(151.25,29.77) 151.31,29.83 C1186.1 150.79,29.97 150.79,29.62 150.82,29.59 150.82,29.02 150.25,28.45 149.92,28.45 149.66,28.19 149.37,28.19 149.3,28.12 JKB1.5
  GND1 w0.104: v3(143.57,56.36) 143.64,56.29 v2(143.64,55.77)
  IN1 w0.071: v8(151.25,29.77) 151.75,30.26 152.45,30.26 152.62,30.09 152.62,29.66 152.82,29.46 153.69,29.46 153.95,29.72 154.64,29.72 155.86,28.5 166.02,28.5 166.55,27.97 171.18,27.97 173.94,30.73 173.94,31.44 177.19,34.7 177.19,37.82 176.82,38.18 176.82,43.1 174.94,44.98 174.94,50.86 174.32,51.49 171.42,51.49 170.95,51.02 170.26,51.02 169.5,50.25 165.17,50.25 164.63,50.79 163.43,50.79 162.18,52.04 160.79,52.04 159.09,53.74 159.09,55.02 158.9,55.21 158.14,55.21 157.73,55.63 151.58,55.63 150.94,56.27 150.01,56.27 149.79,56.05 147.62,56.05 147.44,55.87 146.53,55.87 146.28,55.62 145.65,55.62 145.53,55.5 144.25,55.5 143.57,56.18 v3(143.57,56.36)
KSI3: length 90.1
  TOP w0.076: v2(143.72,56.95) 143.92,56.75 U34.D12
  TOP w0.122: v7(153.12,28.89) 153.13,28.91 153.16,28.91 154.01,29.76 154.01,30.47 C1191.1 153.72,30.23 153.72,29.82 153.31,29.41 153,29.41 152.67,29.08 152.67,28.73 152.32,28.37 151.86,28.37 151.7,28.21 JKB1.8
  GND1 w0.104: v2(143.72,56.95) 144.09,56.95 v3(144.15,56.88)
  IN1 w0.071: v7(153.12,28.89) 153.11,28.91 153.14,28.94 153.66,28.94 154.07,29.36 154.51,29.36 155.74,28.13 165.87,28.13 166.39,27.6 171.51,27.6 175.56,31.65 175.56,32.54 177.54,34.52 177.54,37.96 177.2,38.29 177.2,44.99 176.36,45.83 176.36,49.96 174.47,51.86 171.26,51.86 170.8,51.39 167.9,51.39 167.3,51.99 162.77,51.99 162.34,52.41 160.94,52.41 159.43,53.92 159.43,55.17 159.04,55.56 158.29,55.56 157.87,55.98 151.76,55.98 151.1,56.64 149.85,56.64 149.61,56.4 147.48,56.4 147.31,56.23 146.4,56.23 146.14,55.97 145.21,55.97 144.29,56.88 v3(144.15,56.88)
  BOTTOM w0.122: v1(152.62,30.45) 152.62,29.39 v7(153.12,28.89)
KSI4: length 86.7
  TOP w0.122: v2(143.58,54.84) 143.58,55.04 143.96,55.42 143.96,56.06 U34.D13 ; 150.38,30.44 149.89,29.96 149.89,28.79 149.57,28.46 148.8,28.46 148.5,28.16 JKB1.4 ; 150.38,30.44 v8(150.38,29.2) ; 150.38,30.44 C1187.1
  GND1 w0.104: v2(143.58,54.84) 143.61,54.81 144.44,54.81 v3(144.51,54.75)
  IN1 w0.071: v3(144.51,54.75) 144.62,54.64 144.62,54.2 145.18,53.65 145.99,53.65 147.88,55.53 150,55.53 150.22,55.75 150.68,55.75 151.32,55.11 157.51,55.11 157.92,54.7 157.92,54.15 160.35,51.72 160.35,51.3 160.87,50.78 162.22,50.78 163.77,49.23 170.08,49.23 171.23,48.08 172.26,48.08 174.24,46.1 174.24,44.9 176.27,42.87 176.27,38.01 176.67,37.6 176.67,34.96 173.38,31.67 173.38,30.96 170.95,28.53 166.78,28.53 166.25,29.06 156.04,29.06 154.46,30.63 151.23,30.63 150.4,29.81 150.4,29.48 150.38,29.45 v8(150.38,29.2)
KSI5: length 87.7
  TOP w0.076: v2(144.29,55.74) 144.17,55.86 144.17,56.35 U34.C12
  TOP w0.122: JKB1.6 150.1,28.14 150.16,28.2 150.35,28.2 150.65,28.49 150.77,28.61 150.77,28.61 151.72,29.57 151.72,30.01 C1193.1 152.2,29.81 152.09,29.69 152.09,29.19 v8(151.98,29.08)
  GND1 w0.104: v2(144.29,55.74) 144.34,55.74 v3(144.66,56.06)
  IN1 w0.071: v3(144.66,56.06) 144.92,55.8 146.21,55.8 146.46,56.05 147.37,56.05 147.55,56.23 149.7,56.23 149.93,56.46 151.02,56.46 151.67,55.8 157.8,55.8 158.22,55.39 158.97,55.39 159.26,55.09 159.26,53.83 160.86,52.23 162.26,52.23 162.68,51.81 167.21,51.81 167.82,51.2 170.87,51.2 171.34,51.67 174.39,51.67 176.18,49.88 176.18,45.75 177.03,44.9 177.03,38.22 177.37,37.89 177.37,34.61 174.12,31.37 174.12,30.65 171.26,27.79 166.47,27.79 165.94,28.31 155.8,28.31 154.58,29.53 154,29.53 153.76,29.29 152.19,29.29 v8(151.98,29.08)
KSI6: length 86.8
  TOP w0.122: v2(144.56,55.38) 144.65,55.47 144.65,55.88 U34.C13 ; v2(149.41,28.82) C1188.1 149.33,29.35 148.72,28.74 148.29,28.74 147.7,28.15 JKB1.3
  TOP w0.127: v1(144.03,54.94) 144.03,55.05 144.36,55.38 v2(144.56,55.38)
  GND1 w0.104: v3(144.92,55.12) 144.83,55.12 v2(144.56,55.38) ; v2(149.41,28.82) v3(149.41,29.25)
  IN1 w0.071: v3(144.92,55.12) 144.92,54.16 145.05,54.03 146.13,54.03 147.81,55.71 149.93,55.71 150.15,55.93 150.77,55.93 151.4,55.29 157.58,55.29 158.09,54.78 158.09,54.22 160.52,51.79 160.52,51.39 160.96,50.95 162.29,50.95 163.83,49.41 170.16,49.41 171.3,48.27 172.34,48.27 174.42,46.18 174.42,44.98 176.45,42.95 176.45,38.07 176.85,37.67 176.85,34.88 173.57,31.6 173.57,30.88 171.02,28.34 166.7,28.34 166.17,28.87 155.98,28.87 154.4,30.45 151.35,30.45 150.82,29.92 150.82,28.99 150.45,28.63 150.03,28.63 v3(149.41,29.25)
KSI7: length 91.4
  TOP w0.076: v2(144.19,57.33) 143.92,57.6 U34.D10
  TOP w0.122: JKB1.2 146.9,28.29 v1(147.5,28.89) 148.04,28.89 148.5,29.35 ; C1189.1 148.5,29.35 ; 148.5,29.35 v7(147.86,29.35)
  GND1 w0.104: v3(144.43,57.92) 144.19,57.68 v2(144.19,57.33)
  IN1 w0.071: v3(144.43,57.92) 144.99,57.37 144.99,56.71 145.39,56.31 146,56.31 146.28,56.6 147.2,56.6 147.34,56.74 149.43,56.74 149.7,57.01 151.25,57.01 151.94,56.32 158.01,56.32 158.42,55.91 159.51,55.91 159.52,55.92 163.01,55.92 163.48,55.44 164.33,55.44 166.17,53.61 168.82,53.61 169.95,52.48 171.89,52.48 172.14,52.23 174.62,52.23 176.74,50.12 176.74,45.99 177.55,45.17 177.55,38.44 177.88,38.1 177.88,34.36 175.91,32.39 175.91,31.48 171.66,27.23 166.23,27.23 165.7,27.76 150.34,27.76 149.94,28.16 149.05,28.16 v7(147.86,29.35)
KSO0: length 65.7
  TOP w0.122: JKB1.18 159.7,28.36 159.91,28.57 160.78,28.57 161.36,29.16 162.05,29.16 v1(162.19,29.3) 162.34,29.3 162.72,29.68 162.72,30.34 C1078.1 163.18,30.19 v7(163.18,29.83) ; v2(141.27,54.83) 141.27,55.66 141.35,55.73 141.35,56.03 U34.J13
  GND1 w0.104: v3(141.92,54.64) 141.46,54.64 v2(141.27,54.83)
  IN1 w0.071: v7(163.18,29.83) 163.18,29.94 163.87,30.63 169.72,30.63 174.14,35.06 174.14,40.48 173.7,40.93 173.7,41.8 171.64,43.86 171.36,43.86 168.09,47.13 163.42,47.13 162.27,48.29 159.33,48.29 158.64,47.6 148.86,47.6 147.22,49.24 147.1,49.24 141.92,54.43 v3(141.92,54.64)
KSO1: length 68.4
  TOP w0.076: U34.J12 141.17,56.35 141.17,55.8 140.98,55.61 140.98,55.33
  TOP w0.122: JKB1.16 158.1,28.24 158.26,28.4 158.73,28.4 159.5,29.16 159.98,29.16 160.06,29.25 v1(160.46,29.25) 160.89,29.68 160.89,30.29 C1195.1 161.35,30.24 v7(161.35,29.86) ; 140.98,55.33 140.98,55.32 140.9,55.24 v2(140.9,55.08)
  GND1 w0.104: v3(141.51,55.8) 141.14,55.43 141.14,55.31 v2(140.9,55.08)
  IN1 w0.071: v3(141.51,55.8) 141.51,55.4 141.26,55.16 141.26,54.32 146.86,48.72 147,48.72 148.65,47.08 158.86,47.08 159.51,47.73 162.09,47.73 163.25,46.57 167.86,46.57 171.13,43.3 171.41,43.3 173.14,41.57 173.14,40.7 173.59,40.25 173.59,35.29 169.49,31.19 162.68,31.19 v7(161.35,29.86)
KSO2: length 67
  TOP w0.122: U34.H12 141.92,56.91 v2(141.82,57.01) ; JKB1.17 158.9,28.17 159.61,28.88 160.66,28.88 161.19,29.41 161.6,29.41 161.81,29.62 161.81,30.31 C1194.1 162.26,30.21 v8(162.26,29.86)
  GND1 w0.104: v2(141.82,57.01) 142.07,56.76 v3(142.07,56.57)
  IN1 w0.071: v8(162.26,29.86) 163.41,31.01 169.57,31.01 173.77,35.21 173.77,40.33 173.32,40.77 173.32,41.65 171.49,43.48 171.21,43.48 167.94,46.76 163.31,46.76 162.15,47.92 159.45,47.92 158.79,47.25 148.72,47.25 147.08,48.89 146.96,48.89 141.45,54.4 141.45,55.1 141.85,55.5 141.85,56.36 v3(142.07,56.57)
KSO3: length 71.8
  TOP w0.122: JKB1.15 157.3,28.2 157.77,28.66 158.64,28.66 159.39,29.41 159.79,29.41 159.98,29.6 159.98,30.26 C1196.1 ; C1196.1 160.43,30.26 v7(160.43,29.86) ; C1196.1 160.65,30.94 160.65,31.97 R1032.2 ; v2(141.83,55.54) 141.92,55.63 U34.H13
  TOP w0.127: v2(141.83,55.54) 141.83,55.11 141.94,54.99 141.94,54.55 141.49,54.09 v1(141.37,54.09)
  GND1 w0.104: v3(141.86,55.11) 141.83,55.14 v2(141.83,55.54)
  IN1 w0.071: v7(160.43,29.86) 160.87,29.43 162.41,29.43 162.74,29.76 162.74,30.01 163.56,30.82 169.64,30.82 173.96,35.13 173.96,40.4 173.51,40.85 173.51,41.72 171.56,43.67 171.28,43.67 168.01,46.94 163.36,46.94 162.21,48.1 159.39,48.1 158.72,47.42 148.79,47.42 147.15,49.07 147.03,49.07 142.67,53.42 141.63,54.47 141.63,54.87 v3(141.86,55.11)
KSO4: length 74.7
  TOP w0.076: 141.54,55.33 141.52,55.35 141.52,55.83 141.67,55.98 141.67,56.71 141.5,56.88 141.5,57.18 U34.H10
  TOP w0.122: v7(156.75,29.83) 156.75,30.39 C1184.1 156.29,30.14 156.29,29.54 155.35,28.6 154.9,28.6 154.57,28.27 154.2,28.27 154.1,28.17 JKB1.11 ; 141.54,55.33 141.54,55.04 141.64,54.94 141.64,54.62 141.46,54.44 v2(141.03,54.44) 141.03,53.35 141.28,53.1 v1(141.28,52.43)
  GND1 w0.104: v3(140.57,54.43) 141.02,54.43 v2(141.03,54.44)
  IN1 w0.071: v3(140.57,54.43) 140.57,53.34 142.45,51.46 143.39,51.46 146.64,48.2 146.79,48.2 148.43,46.56 159.07,46.56 159.69,47.17 161.91,47.17 163.08,46.01 167.64,46.01 170.9,42.74 171.18,42.74 172.58,41.34 172.58,40.47 173.03,40.02 173.03,35.52 169.28,31.77 158.68,31.77 v7(156.75,29.83)
KSO5: length 75.3
  TOP w0.122: v7(155.84,29.83) 155.84,30.42 C1185.1 155.38,30.11 155.38,29.44 154.46,28.52 154.06,28.52 153.76,28.22 153.42,28.22 153.3,28.1 JKB1.10 ; U34.H9 141.71,58.31 141.71,58.83 v2(141.73,58.84)
  GND1 w0.104: v3(141.61,58.18) 141.61,58.18 141.61,58.72 v2(141.73,58.84)
  IN1 w0.071: v3(141.61,58.18) 141.65,58.14 141.65,57.38 140.68,56.41 140.68,55 140.28,54.59 140.28,53.37 142.36,51.28 143.32,51.28 146.57,48.03 146.72,48.03 148.36,46.39 159.15,46.39 159.76,47 161.84,47 163.01,45.83 167.55,45.83 170.82,42.56 171.1,42.56 172.4,41.26 172.4,40.39 172.85,39.94 172.85,35.6 169.2,31.95 158.26,31.95 156.14,29.83 v7(155.84,29.83)
  BOTTOM w0.122: v1(155.29,29.54) 155.58,29.83 v7(155.84,29.83)
KSO6: length 72.2
  TOP w0.122: JKB1.13 155.7,28.15 155.99,28.44 156.51,28.44 157.45,29.38 157.85,29.38 158.15,29.68 158.15,30.21 C1182.1 158.6,30.31 v7(158.6,29.86) ; U34.G9 142.42,58.11 142.03,58.5 v2(142.03,58.53)
  GND1 w0.104: v3(142.17,58.12) 142.17,58.39 v2(142.03,58.53)
  IN1 w0.071: v3(142.17,58.12) 142.29,58 142.29,57.21 141.09,56.02 141.09,54.25 146.79,48.55 146.93,48.55 148.58,46.91 158.93,46.91 159.57,47.54 162.03,47.54 163.21,46.37 167.8,46.37 171.05,43.11 171.33,43.11 172.95,41.49 172.95,40.62 173.4,40.17 173.4,35.37 169.41,31.38 160.12,31.38 v7(158.6,29.86)
  BOTTOM w0.122: v7(158.6,29.86) 158.6,29.53 v1(158.82,29.31)
KSO7: length 71.9
  TOP w0.122: v2(142.14,57.29) 142.42,57.57 U34.G10 ; JKB1.12 154.9,28.11 155.11,28.32 155.44,28.32 155.81,28.69 156.25,28.69 v1(156.67,29.11) 157.23,29.67 157.23,30.19 C1183.1 157.69,30.34 v7(157.69,29.86)
  GND1 w0.104: v3(141.98,57.7) 141.98,57.46 v2(142.14,57.29)
  IN1 w0.071: v7(157.69,29.86) 159.39,31.56 169.34,31.56 173.22,35.44 173.22,40.1 172.77,40.54 172.77,41.42 171.26,42.93 170.98,42.93 167.72,46.18 163.15,46.18 161.97,47.36 159.63,47.36 159,46.73 148.5,46.73 146.86,48.38 146.71,48.38 143.45,51.64 142.54,51.64 140.92,53.27 140.92,56.36 141.98,57.42 v3(141.98,57.7)
KSO8: length 70.4
  TOP w0.122: JKB1.14 156.5,28.06 157.5,29.06 158.44,29.06 v1(158.64,29.26) 159.06,29.68 159.06,30.24 C1197.1 159.52,30.29 v7(159.52,29.86) ; v2(142.43,55.71) 142.43,56.09 U34.G13
  GND1 w0.104: v3(142.32,55.28) 142.44,55.4 142.44,55.71 142.44,55.71 v2(142.43,55.71)
  IN1 w0.071: v3(142.32,55.28) 142.21,55.17 142.21,54.38 147.17,49.41 147.29,49.41 148.93,47.77 158.57,47.77 159.27,48.47 162.32,48.47 163.48,47.31 168.17,47.31 169.08,46.4 171.58,46.4 172.5,45.48 172.5,43.26 173.88,41.88 173.88,41 174.33,40.56 174.33,34.98 169.8,30.45 163.95,30.45 163.68,30.19 163.68,29.76 163.17,29.24 160.14,29.24 v7(159.52,29.86)
KSO9: length 62.6
  TOP w0.076: 142.29,55.33 142.14,55.47 142.14,55.65 142.14,55.65 142.14,55.97 142.17,56 142.17,56.35 U34.G12
  TOP w0.122: 142.29,55.33 142.3,55.32 v2(142.3,54.85) ; JKB1.24 164.5,28.26 164.62,28.38 165.02,28.38 165.19,28.56 165.72,28.56 165.93,28.77 166.38,28.77 166.76,29.15 167.23,29.15 167.28,29.2 167.72,29.2 v1(167.86,29.34) 168.21,29.68 C1180.1 168.66,30.04 v7(168.66,29.88)
  GND1 w0.104: v2(142.3,54.85) 142.3,54.71 v3(142.53,54.48)
  IN1 w0.071: v7(168.66,29.88) 169.04,30.26 169.87,30.26 174.51,34.9 174.51,40.63 174.07,41.08 174.07,41.96 172.68,43.34 172.68,45.56 171.66,46.58 169.16,46.58 168.24,47.5 163.54,47.5 162.38,48.66 159.21,48.66 158.5,47.94 149.01,47.94 147.36,49.59 147.25,49.59 142.53,54.3 v3(142.53,54.48)
KSO10: length 60.3
  TOP w0.122: JKB1.26 166.1,28.21 166.16,28.27 166.59,28.27 166.89,28.57 167.36,28.57 167.47,28.68 169.06,28.68 170.03,29.65 170.03,30.11 169.98,30.16 C1178.1 v8(170.75,30.49) ; v2(143.06,55.68) 142.92,55.82 U34.F13
  GND1 w0.104: v3(142.77,55.3) 142.77,55.38 v2(143.06,55.68)
  IN1 w0.071: v3(142.77,55.3) 142.82,55.24 142.82,54.26 147.32,49.76 147.43,49.76 149.08,48.12 158.43,48.12 159.15,48.84 162.44,48.84 163.6,47.68 168.32,47.68 169.24,46.77 171.73,46.77 172.87,45.63 172.87,43.41 174.25,42.03 174.25,41.16 174.7,40.71 174.7,34.83 170.75,30.87 v8(170.75,30.49)
KSO11: length 63.5
  TOP w0.076: U34.F12 142.67,56.35 142.67,55.88 142.73,55.83 142.73,55.33
  TOP w0.122: JKB1.25 165.3,28.2 165.41,28.31 165.82,28.31 166.03,28.52 166.49,28.52 166.79,28.82 167.26,28.82 167.37,28.93 168.34,28.93 169.12,29.71 169.12,29.98 169.09,30.01 C1179.1 169.12,30.49 169.58,30.04 v7(169.58,29.86) ; 142.73,55.33 142.73,55 142.82,54.9 v2(142.82,54.81) 142.82,54.5 v1(142.64,54.32)
  GND1 w0.104: v2(142.82,54.81) 143.11,54.52 v3(143.11,54.42)
  IN1 w0.071: v3(143.11,54.42) 143.11,54.21 147.39,49.93 147.51,49.93 149.15,48.29 158.36,48.29 159.1,49.03 162.5,49.03 163.66,47.87 168.4,47.87 169.31,46.95 171.81,46.95 173.13,45.64 173.13,44.44 175.16,42.41 175.16,41.59 174.89,41.32 174.89,34.75 171.58,31.45 171.58,30.75 170.7,29.86 v7(169.58,29.86)
KSO12: length 73.3
  TOP w0.122: JKB1.19 160.5,28.22 160.59,28.31 160.87,28.31 161.44,28.88 162.44,28.88 162.74,29.18 163.16,29.18 163.63,29.65 163.63,30.37 C1177.1 164.09,30.16 v7(164.09,29.86) ; U34.F10 142.7,57.38 v2(142.7,57.29)
  GND1 w0.104: v2(142.7,57.29) 142.81,57.4 143.07,57.4 v3(143.28,57.61)
  IN1 w0.071: v7(164.09,29.86) 164.5,30.26 165.18,30.26 165.46,29.98 165.46,29.71 165.74,29.43 166.42,29.43 166.95,28.9 170.79,28.9 173.01,31.12 173.01,31.83 175.63,34.44 175.63,36.34 176.23,36.94 176.23,37.55 175.9,37.89 175.9,42.72 173.87,44.75 173.87,45.95 172.11,47.71 171.07,47.71 169.92,48.86 163.65,48.86 162.74,49.77 158.84,49.77 158.05,48.98 149.44,48.98 147.79,50.62 147.68,50.62 144.02,54.28 144.02,54.68 143.59,55.11 143.59,55.65 143.1,56.14 143.1,57.43 v3(143.28,57.61)
  BOTTOM w0.122: v1(163.95,30.59) 164.09,30.45 v7(164.09,29.86)
KSO13: length 71
  TOP w0.122: v2(142.11,58.99) 142.37,58.72 142.37,58.55 142.82,58.1 U34.F9 ; JKB1.22 162.9,28.13 163.19,28.42 163.59,28.42 164.05,28.88 164.52,28.88 164.77,29.13 165.45,29.13 v1(165.59,29.27) 165.63,29.31 166.03,29.31 166.38,29.65 166.38,30.44 C1174.1 166.83,30.09 v7(166.83,29.86)
  GND1 w0.104: v2(142.11,58.99) 142.41,58.69 142.41,58.31 v3(142.58,58.14)
  IN1 w0.071: v3(142.58,58.14) 142.48,58.04 142.48,57.37 142.76,57.09 142.76,56 143.25,55.51 143.25,54.97 143.66,54.56 143.66,54.15 147.53,50.28 147.65,50.28 149.29,48.63 158.2,48.63 158.96,49.4 162.62,49.4 163.53,48.48 169.21,48.48 169.41,48.29 169.41,47.59 169.67,47.33 171.96,47.33 173.5,45.79 173.5,44.59 175.53,42.56 175.53,37.77 175.89,37.41 175.89,37.09 175.26,36.46 175.26,34.6 172.64,31.98 172.64,31.27 170.64,29.27 167.42,29.27 v7(166.83,29.86)
KSO14: length 67.6
  TOP w0.122: U34.E10 143.31,57.6 143.03,57.33 143.03,57.04 v2(143.01,57.01) ; JKB1.23 163.7,28.16 164.17,28.63 164.92,28.63 165.09,28.81 165.62,28.81 165.83,29.02 166.28,29.02 166.68,29.42 167.03,29.42 167.29,29.68 167.29,30.47 C1181.1 167.75,30.06 v7(167.75,29.88)
  GND1 w0.104: v2(143.01,57.01) 142.96,56.96 v3(142.45,56.96)
  IN1 w0.071: v3(142.45,56.96) 142.45,56.05 143.07,55.44 143.07,54.89 143.47,54.5 143.47,54.1 147.46,50.1 147.58,50.1 149.22,48.46 158.28,48.46 159.04,49.21 162.56,49.21 163.68,48.1 168.43,48.1 169.39,47.14 171.89,47.14 173.31,45.72 173.31,44.51 175.34,42.48 175.34,41.53 175.07,41.26 175.07,34.67 172.46,32.06 172.46,31.35 170.56,29.45 168.18,29.45 v7(167.75,29.88)
  BOTTOM w0.122: v7(167.75,29.88) 167.75,30.45 167.8,30.51 v1(167.8,30.62)
KSO15: length 73.2
  TOP w0.076: U34.E9 143.39,58.1 v2(143.01,58.48)
  TOP w0.122: JKB1.21 162.1,28.25 162.2,28.35 162.67,28.35 163,28.68 163.49,28.68 163.95,29.13 164.35,29.13 164.62,29.4 165.18,29.4 165.46,29.68 165.46,30.42 C1175.1 165.92,30.11 v7(165.92,29.83)
  GND1 w0.104: v2(143.01,58.48) 142.89,58.37 142.89,57.85 v3(142.77,57.72)
  IN1 w0.071: v3(142.77,57.72) 142.93,57.56 142.93,56.07 143.42,55.58 143.42,55.04 143.85,54.61 143.85,54.21 147.6,50.45 147.72,50.45 149.36,48.81 158.13,48.81 158.9,49.58 162.68,49.58 163.59,48.67 169.85,48.67 171.01,47.51 172.04,47.51 173.68,45.87 173.68,44.67 175.71,42.64 175.71,37.83 176.06,37.48 176.06,37.02 175.44,36.4 175.44,34.52 172.83,31.9 172.83,31.19 170.72,29.08 167.02,29.08 166.28,29.83 v7(165.92,29.83)
  BOTTOM w0.122: v1(167.66,28.07) 167.1,28.07 165.92,29.25 v7(165.92,29.83)
KSO16: length 76.3
  TOP w0.076: U34.E8 143.67,58.35 143.67,57.5 143.67,57.49 v2(143.39,57.21)
  TOP w0.122: JKB1.20 161.3,28.21 161.69,28.6 162.56,28.6 162.89,28.93 163.34,28.93 163.82,29.41 164.28,29.41 164.55,29.68 164.55,30.39 C1176.1 165.01,30.14 v7(165.01,29.86)
  GND1 w0.104: v3(143.58,57.95) 143.61,57.92 143.61,57.43 v2(143.39,57.21)
  IN1 w0.071: v3(143.58,57.95) 143.58,57.43 143.27,57.12 143.27,56.21 143.76,55.72 143.76,55.19 144.22,54.73 144.22,54.33 146.22,52.32 147.67,52.32 148.79,51.2 148.79,49.9 149.53,49.15 157.98,49.15 158.79,49.95 162.8,49.95 163.71,49.04 170,49.04 171.15,47.89 172.18,47.89 174.05,46.02 174.05,44.82 176.08,42.79 176.08,37.95 176.41,37.63 176.41,36.87 175.81,36.28 175.81,34.37 173.2,31.75 173.2,31.04 170.87,28.71 166.87,28.71 166.34,29.24 165.62,29.24 v7(165.01,29.86)
  BOTTOM w0.122: v1(164.03,28.07) 164.03,28.61 165.01,29.59 v7(165.01,29.86)
LCD_TEST: length 47.1
  TOP w0.122: v7(148.44,69.05) v1(147.93,68.54) 147.66,68.26 147.66,65.11 147.17,64.63 147.17,63.92 146.23,62.98 146.23,61.48 145.92,61.16 145.48,61.16 U34.A3
  IN2 w0.094: v7(148.44,69.05) 148.44,69.25 149.06,69.87 151.4,69.87 153.07,71.54 153.07,72.71 156.99,76.63 167.93,76.63 171.67,80.37 178.39,80.37 178.87,80.86 v7(178.87,80.99)
  BOTTOM w0.122: v7(178.87,80.99) 178.87,80.56 178.74,80.43 JLVDS2.14
LDO_EN: length 14.3
  TOP w0.254: PC215.1 183.05,55.38 PR211.2 184.53,55.38 PR210.2 184.89,54.66 185.47,54.09 v9(185.94,54.09) 186.37,54.09 186.54,54.27 189.48,54.27 189.86,53.89 190.74,53.89 191.25,53.37 v7(192.71,53.37) 192.74,53.4 192.74,53.55 193.14,53.96 PU501.12
  BOTTOM w0.254: v7(192.71,53.37) 192.56,53.37 192.26,53.67 192.26,54.55 192.41,54.7 PR212.1
LG_3V: length 2.9
  IN3 w1.016: 189.41,54.93 189.11,54.93 187.89,56.15 187.89,56.98
  vias: v7(187.23,58.24) v7(187.89,58.24) v7(190.23,54.78) v7(190.86,54.78)
LG_5V: length 12.6
  GND1 w0.254: v3(205.19,63.13) 205.16,63.16 v2(204.73,63.16)
  IN1 w0.508: v4(205.19,62.62) v3(205.19,63.13)
  IN3 w1.016: v4(205.19,62.62) 204.1,61.53 199.85,61.53 198,59.68 198,56.5
  vias: v7(196.02,54.8) v7(196.65,54.8)
LG_+V1.05S_VCCPP: length 7.8
  IN4 w1.016: 117.33,48.91 121.3,44.93 123.49,44.93
  vias: v7(116.39,49.42) v7(116.39,48.78) v7(123.35,44.06) v7(123.98,44.06)
LGATE: length 8.3
  TOP w0.122: PT2.1 140.37,33.64 139.35,32.63 v7(139.33,32.63)
  IN4 w1.016: 145.78,35.01 142.04,35.01 140.19,33.16
  vias: v7(138.69,32.63) v7(146.26,35.83) v7(146.64,35.29)
LGATE1: length 14.1
  IN2 w1.016: 25.74,75.53 25.81,75.45 26.53,75.45 28.15,73.83 28.15,66.79 26.47,65.11 26.17,65.11
  BOTTOM w0.254: v7(24.9,76.9) 24.58,77.22 PU700.23
  vias: v7(24.75,64.99) v7(25.23,76.34) v7(25.38,64.99)
LGATE1G: length 10.8
  IN2 w1.016: 21.19,79.62 21.19,75.7 21.9,74.99 23.17,74.99 24.44,73.72 24.44,70.9
  vias: v7(19.5,79.63) v7(20.04,80.05) v7(23.71,69.61) v7(24.42,69.71)
LID_SW_IN#: length 175.4
  TOP w0.122: U34.H1 141.88,62.14 141.88,62.35 141.88,62.35 141.88,62.57 142.09,62.78 142.09,63.06 142.42,63.39 142.79,63.39 143.21,63.8 143.48,63.8 R603.2 144.39,64.72 144.39,65.66 v7(144.18,65.87) ; v7(23.04,46.47) 23.43,46.85 27.33,46.85 27.99,46.19 32,46.19 32.58,45.62 36.23,45.62 36.94,46.33 55.19,46.33 55.9,45.62 57.4,45.62 58.29,46.51 60.14,46.51 v1(60.6,46.05) 60.9,45.75 80.21,45.75 80.6,46.14 83.4,46.14 89.11,51.85 91.16,51.85 93.66,54.34 v2(93.66,54.7)
  GND1 w0.104: v2(93.66,54.7) 93.66,55.13 v3(93.73,55.21)
  IN1 w0.071: v4(133.3,64.13) 133.3,63.2 132.63,62.53 130.32,62.53 129.55,61.75 129.55,60.8 127.43,58.69 127.32,58.69 124.98,56.35 121.6,56.35 121.23,55.98 121.23,55.66 120.88,55.31 118.51,55.31 117.56,56.26 115.34,56.26 114.12,55.05 112.3,55.05 112.2,55.15 109.13,55.15 108.95,55.33 107.77,55.33 107.18,55.92 107.18,55.92 106.98,56.11 105.47,56.11 105.46,56.12 105.44,56.12 105.21,56.35 95.86,56.35 94.72,55.21 93.76,55.21 93.76,55.21 v3(93.73,55.21)
  IN2 w0.094: v7(144.18,65.87) 143.77,65.47 136.41,65.47 134.69,63.75 133.67,63.75 133.3,64.13 v4(133.3,64.13) ; v7(18.45,21.53) 18.04,21.93 18.04,22.39 18.62,22.97 18.62,24.02 18.36,24.28 18.21,24.28 17.4,25.09 17.4,29.7 17.2,29.91 17.2,39.47 17.42,39.68 17.42,40.22 18.05,40.85 18.05,41.74 19.25,42.94 19.25,45.05 20.52,46.32 21.4,46.32 22.21,45.5 22.46,45.5 23.04,46.09 v7(23.04,46.47)
  BOTTOM w0.122: v7(18.45,21.53) 18.47,21.53 18.93,21.98 20.01,21.98 20.6,21.4 JIOL1.27
LPC_AD0: length 106.2
  TOP w0.122: v2(138.95,60.77) 138.95,60.73 139,60.68 139.24,60.68 139.31,60.6 U34.N4 ; v7(180.47,31.79) 180.45,31.81 179.3,31.81 R1016.2 ; v1(158.22,51) 158.45,50.77 U652.26 161.66,50.77 162.67,51.78 v7(162.67,52.92)
  GND1 w0.104: v3(138.56,61.51) 138.56,61.46 138.95,61.07 v2(138.95,60.77)
  IN1 w0.071: v4(138.34,61.07) 138.35,61.07 138.35,61.25 138.56,61.47 v3(138.56,61.51)
  IN2 w0.094: v4(117.71,69.89) 117.74,69.89 118.35,69.28 118.85,69.28 121.85,66.28 127.33,66.28 127.7,65.91 127.7,64.21 127.74,64.16 127.74,62.82 128.33,62.23 129.48,62.23 131.03,60.68 135.03,60.68 135.22,60.5 136.74,60.5 137.49,61.24 138.17,61.24 v4(138.34,61.07) 139.41,61.07 139.73,60.75 140.57,60.75 140.99,61.17 142.2,61.17 144.65,58.72 144.65,58.18 146.63,56.21 157.79,56.21 158.31,55.68 159.66,55.68 160.64,54.7 160.64,54.37 161.03,53.97 161.75,53.97 162.36,53.37 162.36,53.23 v7(162.67,52.92) 162.79,52.8 163.29,52.8 164.08,53.6 168.67,53.6 170.56,55.49 172.8,55.49 173.18,55.1 173.18,54.13 173.73,53.58 175.09,53.58 179.6,49.07 179.6,45.71 180.41,44.9 180.41,40.55 180.29,40.43 180.29,34.13 180.75,33.67 180.75,32.06 v7(180.47,31.79)
  IN4 w0.071: v4(117.71,69.89) 117.25,70.35 v5(117.15,70.35)
  GND5 w0.104: v6(116.75,70.51) 116.99,70.51 v5(117.15,70.35)
  BOTTOM w0.122: UH1.A37 v6(116.75,70.51)
LPC_AD1: length 112.3
  TOP w0.076: v2(140.57,59.93) 140.75,59.93 U34.K5
  TOP w0.122: v1(180.68,30.72) 180.58,30.82 v2(179.25,30.82) 178.82,30.38 R1015.2 ; U652.23 160.5,52.72 160.85,52.38 161.49,52.38 162.21,53.1 162.21,53.51 v7(162.64,53.94)
  GND1 w0.104: v3(140.13,60.64) 140.13,60.38 v2(140.57,59.93) ; v3(179.76,30.82) v2(179.25,30.82)
  IN1 w0.071: v4(181.41,31.61) 181.06,31.61 180.27,30.82 v3(179.76,30.82) ; v4(140.38,61.54) 140.27,61.43 140.27,60.78 v3(140.13,60.64)
  IN2 w0.094: v4(118.02,71.11) 118.02,71.09 119.36,69.75 120.2,69.75 120.62,70.17 120.62,70.68 122.46,72.52 124.78,72.52 127.4,69.9 127.4,66.76 128.09,66.08 128.09,64.5 128.84,63.75 128.84,62.84 129,62.67 130.56,62.67 131.31,61.93 131.31,61.77 132.01,61.08 135.19,61.08 135.38,60.89 136.5,60.89 137.93,62.31 138.56,62.31 139.21,61.66 140.27,61.66 v4(140.38,61.54) 140.74,61.54 140.94,61.75 142.17,61.75 145.04,58.88 145.04,58.35 146.79,56.6 157.97,56.6 158.49,56.07 160.86,56.07 161.65,55.28 161.65,54.93 v7(162.64,53.94) 162.7,53.99 168.51,53.99 170.39,55.88 173.26,55.88 173.81,55.33 173.81,54.38 174.17,54.01 176.15,54.01 179.1,51.06 179.1,51.06 180.02,50.14 180.02,45.84 180.8,45.06 180.8,40.39 180.69,40.28 180.69,34.39 181.21,33.87 181.21,31.81 v4(181.41,31.61)
  IN4 w0.071: v5(117.48,71.01) 117.58,71.11 v4(118.02,71.11)
  GND5 w0.104: v6(117.15,71.34) v5(117.48,71.01)
  BOTTOM w0.122: UH1.A39 116.76,71.73 v6(117.15,71.34)
LPC_AD2: length 104.5
  TOP w0.076: U34.M4 139.67,60.35 v2(139.12,60.35)
  TOP w0.122: U652.20 160.94,54.67 v7(161.07,54.55) ; R1014.2 179.25,29.74 v2(179.25,29.86)
  GND1 w0.104: v2(179.25,29.86) v3(179.25,30.31) ; v3(139.45,60.85) 139.45,60.69 v2(139.12,60.35)
  IN1 w0.071: v4(139.88,61.13) 139.73,61.13 v3(139.45,60.85) ; v3(179.25,30.31) v4(179.76,30.31)
  IN2 w0.094: v4(118.27,70.07) 118.57,70.07 122.14,66.5 127.39,66.5 127.89,65.99 127.89,64.37 128.64,63.62 128.64,62.75 128.93,62.47 130.49,62.47 131.12,61.84 131.12,61.69 131.93,60.88 135.11,60.88 135.3,60.69 136.63,60.69 137.39,61.45 139.56,61.45 v4(139.88,61.13) 140.07,60.94 140.49,60.94 140.91,61.37 142.28,61.37 144.85,58.8 144.85,58.27 146.71,56.4 157.87,56.4 158.39,55.88 159.74,55.88 v7(161.07,54.55) 161.45,54.55 162.47,53.53 162.82,53.53 163.09,53.8 168.59,53.8 170.47,55.68 173.06,55.68 173.46,55.28 173.46,54.28 173.96,53.78 176.1,53.78 179.83,50.05 179.83,45.75 180.6,44.98 180.6,40.47 180.48,40.35 180.48,34.32 180.75,34.05 180.96,33.85 180.96,31.51 v4(179.76,30.31)
  IN4 w0.071: v5(115.89,70.92) 116.33,70.92 116.57,70.68 117.66,70.68 v4(118.27,70.07)
  GND5 w0.104: v6(115.88,71.32) 115.88,70.92 v5(115.89,70.92)
  BOTTOM w0.122: UH1.C39 v6(115.88,71.32)
LPC_AD3: length 107.7
  TOP w0.122: U34.N3 139.28,61.1 139.15,61.24 138.4,61.24 v2(138.26,61.1) ; v2(179.25,28.84) 179.25,28.72 R1013.2 178.05,28.28 177.52,27.75 v1(177.52,27.25) ; v7(161.12,53.45) 161.53,53.86 161.53,55.56 160.46,56.62 U652.17
  GND1 w0.104: v2(179.25,28.84) 179.63,28.84 179.66,28.81 179.66,28.82 v3(179.71,28.87) ; v3(137.93,61.38) 138.21,61.1 v2(138.26,61.1)
  IN1 w0.071: v4(137.78,60.83) 137.78,61.23 v3(137.93,61.38) ; v3(179.71,28.87) 179.71,29.35 v4(179.43,29.63)
  IN2 w0.094: v4(179.43,29.63) 179.36,29.71 179.36,30.54 179.84,31.03 179.84,34.02 180.09,34.26 180.09,40.51 180.21,40.63 180.21,44.82 179.4,45.63 179.4,48.99 175.06,53.33 169.05,53.33 169.04,53.34 168.78,53.34 168.72,53.4 164.18,53.4 163.29,52.51 162.49,52.51 162.08,52.92 162.08,53.36 161.84,53.61 161.27,53.61 v7(161.12,53.45) 160.94,53.64 160.94,53.79 160.44,54.29 160.44,54.62 159.57,55.49 158.23,55.49 157.7,56.01 146.55,56.01 144.45,58.1 144.45,58.64 142.11,60.98 141.07,60.98 140.6,60.5 139.38,60.5 139.26,60.62 137.99,60.62 v4(137.78,60.83) 137.5,60.83 136.97,60.3 135.14,60.3 134.95,60.49 130.87,60.49 129.36,62 128.29,62 127.55,62.74 127.55,63.97 125.46,66.07 121.65,66.07 118.71,69 117.13,69 116.04,70.1 v4(116.03,70.1)
  IN4 w0.071: v4(116.03,70.1) 116.03,70.23 116.31,70.51 v5(116.31,70.51)
  GND5 w0.104: v5(116.31,70.51) v6(115.88,70.51)
  BOTTOM w0.122: UH1.C37 v6(115.88,70.51)
LPC_FRAME#: length 108.9
  TOP w0.076: v2(140.57,60.4) 140.77,60.6 U34.K4
  TOP w0.122: v7(161.12,52.82) 160.56,53.37 U652.22 ; R1012.2 179.25,27.71 v2(179.25,27.83)
  GND1 w0.104: v3(140.95,60.86) 140.57,60.48 v2(140.57,60.4) ; v3(179.96,27.55) 179.61,27.9 179.33,27.9 v2(179.25,27.83)
  IN1 w0.071: v3(179.96,27.55) 179.96,28.05 179.97,28.05 v4(179.97,28.05) ; v4(141.17,60.52) 141.17,60.64 v3(140.95,60.86)
  IN2 w0.094: v4(113.27,71.11) 112.96,70.81 112.96,69.76 114.51,68.21 119.16,68.21 121.53,65.85 125.25,65.85 127.35,63.75 127.35,62.66 128.25,61.76 129.29,61.76 130.76,60.29 134.87,60.29 135.15,60.02 138.28,60.02 138.68,60.41 139.19,60.41 139.3,60.3 140.96,60.3 v4(141.17,60.52) 141.43,60.78 142.03,60.78 144.26,58.55 144.26,58.02 146.47,55.82 157.62,55.82 158.14,55.29 159.49,55.29 160.25,54.54 160.25,54.21 160.67,53.78 160.67,53.26 v7(161.12,52.82) 161.64,52.3 163.35,52.3 164.07,53.01 164.07,53.02 166.88,53.02 167.48,52.41 169.04,52.41 169.77,53.14 174.98,53.14 179.21,48.91 179.21,45.55 180.02,44.74 180.02,40.71 179.9,40.6 179.9,34.35 179.57,34.02 179.57,31.05 179.03,30.51 179.03,28.38 179.36,28.05 v4(179.97,28.05)
  IN4 w0.071: v4(113.27,71.11) 113.27,71.21 113.29,71.23 113.29,71.43 v5(113.57,71.7)
  GND5 w0.104: v6(113.13,71.7) v5(113.57,71.7)
  BOTTOM w0.122: UH1.K40 v6(113.13,71.7)
LX_3V: length 5.1
  IN1 w1.016: 188.87,57.04 188.87,59.64 190.43,61.2 190.74,61.2
  vias: v1(191.87,61.2) v7(190.25,55.61) v7(190.89,55.61) v7(191.54,63.55) v7(191.54,62.92) v7(191.54,62.28) v7(191.54,61.65) v7(192.17,63.55) v7(192.17,62.92) v7(192.17,62.28) v7(192.17,61.65)
LX_5V: length 1.6
  IN1 w1.016: 198.95,56.64 200.08,57.77
  vias: v7(196.2,55.54) v7(196.83,55.54) v7(199.37,59.63) v7(199.37,58.99) v7(200.03,59.6) v7(200.03,58.97) v7(200.67,59.6) v7(200.67,58.97) v7(201.3,59.6) v7(201.3,58.97) v7(201.94,59.6) v7(201.94,58.97) v9(197.54,66.64)
M_CLK_DDR0: length 173.3
  TOP w0.076: UD4.F7 97.64,29.37 97.64,29.17 97.56,29.08 97.28,29.08 97.07,29.29 96.69,29.29 96.39,28.99 96.23,28.99 v10(96.01,29.21) ; UD2.F7 108.69,29.37 108.69,29.17 108.61,29.08 108.33,29.08 108.12,29.29 107.74,29.29 107.44,28.99 107.28,28.99 v10(107.06,29.21) ; v10(73.91,29.21) 74.13,28.99 74.29,28.99 74.59,29.29 74.98,29.29 75.18,29.08 75.46,29.08 75.55,29.17 75.55,29.37 UD8.F7 ; UD6.F7 86.6,29.37 86.6,29.17 86.51,29.08 86.23,29.08 86.02,29.29 85.64,29.29 85.34,28.99 85.18,28.99 v10(84.96,29.21)
  TOP w0.16: RD35.1 118.51,33.29 118.26,33.29 117.92,32.95 117.34,32.95 v2(117.3,32.98)
  GND1 w0.102: v2(117.3,32.98) 116.9,32.98 v3(116.87,33.01)
  IN1 w0.127: v3(116.87,33.01) 116.73,32.87 116.53,32.87 v4(116.36,33.03)
  IN3 w0.122: v10(64.46,62.3) 64.64,62.12 64.9,62.12 65.25,61.77 65.25,61.27 64.8,60.82 63.93,60.82 63.31,60.2 63.31,59.78 62.21,58.68 62.21,57.46 61.55,56.8 61.55,49.74 61.31,49.49 59.88,49.49 59.78,49.39 59.78,48.96 59.88,48.86 63.49,48.86 63.71,48.64 63.71,48.07 63.46,47.82 62.93,47.82 62.75,47.63 62.75,46.75 62.54,46.54 61.96,46.54 61.7,46.8 61.7,47.69 61.6,47.79 61.12,47.79 61.02,47.69 61.02,45.06 60.8,44.84 59.91,44.84 59.76,44.69 59.76,43.88 59.53,43.65 58.05,43.65 57.92,43.52 57.92,43.12 58.03,43.01 59.53,43.01 59.75,42.79 59.75,41.49 59.85,41.39 60.32,41.39 60.43,41.5 60.43,43.96 60.65,44.18 61.25,44.18 61.48,43.96 61.48,42.85 61.58,42.74 62.03,42.74 62.14,42.84 62.14,45.71 62.34,45.91 62.96,45.91 63.18,45.69 63.18,43.66 63.31,43.52 63.73,43.52 63.84,43.63 63.84,45.68 64.09,45.94 64.63,45.94 64.88,45.69 64.88,43.65 64.98,43.55 65.45,43.55 66.77,42.23 67.58,42.23 68.74,41.07 68.74,36.25 68.61,36.12 68.61,35.41 67.6,34.39 67.6,31.17 66.63,30.21 66.63,28.8 66.77,28.66 67.06,28.66 v8(67.37,28.97)
  IN4 w0.091: v4(116.36,33.03) 116.13,32.8 115.69,32.8 114.7,31.8 112.31,31.8 111.03,30.52 110.54,30.52 109.08,29.06 107.21,29.06 v10(107.06,29.21) 106.84,28.99 106.77,28.99 106.53,29.23 105.88,29.23 105.01,28.36 103.56,28.36 102.93,27.72 102.63,27.72 102.47,27.88 102.47,28.71 102.25,28.93 101.82,28.93 101.6,28.71 101.6,27.73 101.44,27.57 100.93,27.57 100.82,27.68 100.82,28.07 100.55,28.34 100.16,28.34 99.94,28.12 99.94,27.96 99.71,27.73 98.23,27.73 96.94,29.02 96.2,29.02 96.01,29.21 v10(96.01,29.21) 95.8,28.99 95.69,28.99 95.48,29.21 94.63,29.21 93.44,28.01 92.33,28.01 91.21,29.13 90.85,29.13 90.66,29.33 90.66,32.16 90.36,32.46 90,32.46 89.7,32.16 89.7,29.2 89.54,29.04 88.53,29.04 88.31,28.82 88.31,27.88 88.15,27.72 87.45,27.72 87.29,27.88 87.29,28.78 87.04,29.03 85.41,29.03 85.31,28.93 85.24,28.93 v10(84.96,29.21) 84.79,29.03 84.63,29.03 84.45,29.21 83.76,29.21 82.91,28.36 81.46,28.36 80.83,27.72 80.53,27.72 80.37,27.88 80.37,28.71 80.15,28.93 79.72,28.93 79.5,28.71 79.5,27.73 79.34,27.57 78.89,27.57 78.74,27.72 78.74,28.14 78.54,28.34 78.11,28.34 77.86,28.09 77.86,27.85 77.7,27.7 76.06,27.7 75.17,28.59 75.17,28.7 74.84,29.02 74.14,29.02 73.95,29.21 v10(73.91,29.21) 73.71,29.01 73.58,29.01 73.38,29.21 72.77,29.21 72.53,28.97 72.53,27.73 72.37,27.57 71.75,27.57 71.59,27.73 71.59,28.35 71.38,28.56 70.97,28.56 70.75,28.34 70.47,28.34 70.25,28.56 69.9,28.56 69.68,28.34 69.68,27.68 69.54,27.53 69.15,27.53 68.74,27.11 68.44,27.11 68.22,27.33 68.22,27.64 68.82,28.25 68.82,28.56 68.45,28.93 68.14,28.93 67.84,28.63 67.76,28.55 67.55,28.55 67.37,28.72 v8(67.37,28.97)
  BOTTOM w0.076: v10(96.01,29.21) 95.82,29.01 95.7,29.01 95.42,29.29 94.99,29.29 94.78,29.07 94.51,29.07 94.38,29.2 94.38,29.37 UD3.F7 ; UD5.F7 83.33,29.37 83.33,29.2 83.46,29.07 83.73,29.07 83.94,29.29 84.38,29.29 84.65,29.01 84.77,29.01 v10(84.96,29.21) ; UD7.F7 72.29,29.37 72.29,29.2 72.41,29.07 72.68,29.07 72.89,29.29 73.33,29.29 73.6,29.01 73.72,29.01 v10(73.91,29.21) ; UD1.F7 105.43,29.37 105.43,29.2 105.56,29.07 105.83,29.07 106.04,29.29 106.47,29.29 106.75,29.01 106.87,29.01 v10(107.06,29.21)
  BOTTOM w0.16: CD121.1 66.64,28.68 67.08,28.68 v8(67.37,28.97) ; v10(64.46,62.3) 64.46,62.06 64.63,61.89 64.83,61.89 UCPU1.AU36
M_CLK_DDR2: length 172.1
  TOP w0.076: UD16.F7 26.91,34.45 26.91,34.25 26.82,34.16 26.54,34.16 26.33,34.37 25.95,34.37 25.65,34.07 25.49,34.07 v10(25.27,34.29) ; v10(36.32,34.29) 36.54,34.07 36.7,34.07 37,34.37 37.38,34.37 37.59,34.16 37.87,34.16 37.95,34.25 37.95,34.45 UD14.F7 ; v10(47.37,34.29) 47.59,34.07 47.75,34.07 48.05,34.37 48.43,34.37 48.64,34.16 48.92,34.16 49,34.25 49,34.45 UD12.F7 ; UD10.F7 60.05,34.45 60.05,34.25 59.96,34.16 59.68,34.16 59.48,34.37 59.1,34.37 58.8,34.07 58.64,34.07 v10(58.42,34.29)
  IN1 w0.091: v8(19.47,34.27) 19.47,34.14 19.67,33.94 20.36,33.94 20.67,33.63 22.77,33.63 23.44,34.29 24.75,34.29 24.96,34.08 25.06,34.08 v10(25.27,34.29) 25.27,34.21 25.39,34.08 26.22,34.08 27.48,32.82 29.05,32.82 29.2,32.96 29.2,33.2 29.42,33.42 29.88,33.42 30.11,33.19 30.11,32.83 30.29,32.65 30.7,32.65 30.86,32.81 30.86,33.79 31.08,34.01 31.51,34.01 31.73,33.79 31.73,32.96 31.89,32.8 32.19,32.8 32.82,33.44 34.27,33.44 35.12,34.29 35.79,34.29 36,34.08 36.11,34.08 v10(36.32,34.29) 36.49,34.12 37.23,34.12 37.57,33.78 37.57,33.28 37.55,33.26 37.55,33.04 37.77,32.81 39.83,32.81 40.31,33.29 40.31,34.14 40.52,34.35 40.85,34.35 41.06,34.56 41.06,37.49 41.28,37.72 41.77,37.72 41.99,37.49 41.99,34.79 42.18,34.59 43.62,33.16 44.81,33.16 45.94,34.29 46.86,34.29 47.08,34.07 47.15,34.07 v10(47.37,34.29) 47.52,34.14 48.26,34.14 49.59,32.8 51.14,32.8 51.3,32.96 51.3,33.2 51.52,33.42 51.98,33.42 52.22,33.18 52.22,32.82 52.39,32.65 52.8,32.65 52.96,32.81 52.96,33.76 53.18,33.98 53.61,33.98 53.83,33.76 53.83,32.96 53.99,32.8 54.29,32.8 54.59,33.11 56.04,33.11 57.19,34.26 57.92,34.26 58.11,34.07 58.2,34.07 v10(58.42,34.29) 58.51,34.29 58.68,34.12 62.32,34.12 63.63,32.81 64.1,32.81 64.26,32.97 64.26,33.19 63.47,33.98 63.47,35.72 63.69,35.94 64.22,35.94 64.44,35.72 64.44,34.27 64.6,34.11 65.04,34.11 v7(65.44,34.52)
  IN2 w0.122: v7(65.44,34.52) 65.44,34.26 65.28,34.09 64.72,34.09 64.54,34.27 64.54,36.56 65.49,37.5 65.49,38.39 66.02,38.92 66.02,41.09 66.13,41.19 66.13,42.3 65.68,42.75 63.72,44.7 49.99,44.7 49.84,44.86 49.84,45.2 49.99,45.35 53.84,45.35 54.08,45.6 54.08,46.15 53.84,46.39 50.07,46.39 49.94,46.52 49.94,46.9 50.07,47.03 52.69,47.03 53.02,47.36 53.02,48.5 53.14,48.63 54.78,48.63 55.02,48.87 55.02,49.37 54.78,49.62 54.27,49.62 54.08,49.8 54.08,50.8 53.42,51.46 53.42,52.98 53.15,53.25 52.4,53.25 52.15,53.01 52.15,50.11 52.02,49.97 51.65,49.97 51.52,50.1 51.52,53.76 51.65,53.89 64.4,53.89 65.29,54.77 65.29,56.08 64.55,56.82 64.55,57.14 65.08,57.67 65.08,58.28 64.75,58.61 64.75,59.44 64.84,59.53 64.84,60.12 65.02,60.31 65.39,60.31 65.51,60.19 v10(65.51,59.99)
  BOTTOM w0.076: v10(58.42,34.29) 58.22,34.09 58.11,34.09 57.83,34.37 57.4,34.37 57.19,34.15 56.92,34.15 56.79,34.28 56.79,34.45 UD9.F7 ; UD11.F7 45.74,34.45 45.74,34.28 45.87,34.15 46.14,34.15 46.35,34.37 46.78,34.37 47.06,34.09 47.18,34.09 v10(47.37,34.29) ; UD13.F7 34.69,34.45 34.69,34.28 34.82,34.15 35.09,34.15 35.3,34.37 35.73,34.37 36.01,34.09 36.13,34.09 v10(36.32,34.29) ; UD15.F7 23.64,34.45 23.64,34.28 23.77,34.15 24.04,34.15 24.25,34.37 24.69,34.37 24.96,34.09 25.08,34.09 v10(25.27,34.29)
  BOTTOM w0.16: v8(19.47,34.27) 19.25,34.05 19.1,34.05 18.77,34.38 18.27,34.38 17.8,34.84 RD36.1 ; v10(65.51,59.99) 65.51,60.17 65.63,60.3 65.88,60.3 66,60.17 UCPU1.BA34 ; CD122.1 66.17,34.32 66.16,34.32 66.01,34.18 65.78,34.18 v7(65.44,34.52)
M_CLK_DDR#0: length 172.9
  TOP w0.076: v10(107.06,28.62) 107.26,28.82 107.51,28.82 107.81,29.12 108.05,29.12 108.26,28.92 108.54,28.92 108.67,28.79 UD2.G7 ; UD4.G7 97.62,28.79 97.49,28.92 97.21,28.92 97,29.12 96.76,29.12 96.46,28.82 96.21,28.82 v10(96.01,28.62) ; UD8.G7 75.52,28.79 75.39,28.92 75.11,28.92 74.91,29.12 74.66,29.12 74.36,28.82 74.11,28.82 v10(73.91,28.62) ; v10(84.96,28.62) 85.16,28.82 85.41,28.82 85.71,29.12 85.96,29.12 86.16,28.92 86.44,28.92 86.57,28.79 UD6.G7
  TOP w0.16: RD37.1 118.56,33.01 118.37,33.01 118.04,32.67 117.5,32.67 117.38,32.55 v2(117.3,32.55)
  GND1 w0.102: v2(117.3,32.55) 116.9,32.55 v3(116.87,32.52)
  IN1 w0.127: v3(116.87,32.52) 116.75,32.65 116.57,32.65 v4(116.36,32.45)
  IN3 w0.122: v10(64.46,61.48) 64.37,61.58 64.37,61.79 64.48,61.89 64.63,61.89 64.65,61.91 64.82,61.91 65.04,61.69 65.04,61.35 64.72,61.02 63.85,61.02 63.11,60.28 63.11,59.87 62.01,58.76 62.01,57.54 61.35,56.88 61.35,49.82 61.22,49.7 59.8,49.7 59.57,49.47 59.57,48.88 59.8,48.65 63.41,48.65 63.51,48.55 63.51,48.15 63.37,48.02 62.85,48.02 62.54,47.71 62.54,46.83 62.46,46.75 62.04,46.75 61.91,46.88 61.91,47.77 61.69,47.99 61.04,47.99 60.81,47.77 60.81,45.15 60.71,45.05 59.82,45.05 59.55,44.78 59.55,43.96 59.44,43.85 57.97,43.85 57.72,43.6 57.72,43.04 57.94,42.81 59.44,42.81 59.54,42.71 59.54,41.41 59.77,41.19 60.41,41.19 60.64,41.41 60.64,43.88 60.74,43.98 61.17,43.98 61.27,43.88 61.27,42.76 61.5,42.53 62.12,42.53 62.34,42.75 62.34,45.62 62.42,45.71 62.87,45.71 62.97,45.61 62.97,43.57 63.23,43.32 63.81,43.32 64.04,43.55 64.04,45.6 64.18,45.73 64.55,45.73 64.68,45.61 64.68,43.57 64.9,43.35 65.36,43.35 66.68,42.02 67.49,42.02 68.54,40.98 68.54,36.34 68.41,36.21 68.41,35.49 67.39,34.47 67.39,31.25 66.43,30.29 66.43,28.71 66.68,28.46 67.02,28.46 67.14,28.34 67.14,28.33 v8(67.37,28.11)
  IN4 w0.091: v4(116.36,32.45) 116.18,32.63 115.76,32.63 114.76,31.64 112.38,31.64 111.09,30.35 110.61,30.35 109.15,28.89 107.33,28.89 v10(107.06,28.62) 106.85,28.83 106.7,28.83 106.46,29.07 105.95,29.07 105.07,28.19 103.63,28.19 102.99,27.56 102.56,27.56 102.31,27.82 102.31,28.64 102.18,28.77 101.89,28.77 101.76,28.64 101.76,27.66 101.51,27.41 100.86,27.41 100.66,27.61 100.66,28 100.48,28.17 100.23,28.17 100.1,28.05 100.1,27.89 99.78,27.57 98.16,27.57 96.87,28.86 96.24,28.86 v10(96.01,28.62) 95.83,28.8 95.65,28.8 95.43,29.02 94.68,29.02 93.5,27.85 92.26,27.85 91.14,28.97 90.79,28.97 90.49,29.26 90.49,32.09 90.29,32.3 90.06,32.3 89.86,32.09 89.86,29.13 89.61,28.88 88.6,28.88 88.48,28.75 88.48,27.81 88.22,27.56 87.38,27.56 87.13,27.81 87.13,28.71 86.98,28.87 85.48,28.87 85.37,28.76 85.1,28.76 v10(84.96,28.62) 84.77,28.82 84.61,28.82 84.38,29.04 83.83,29.04 82.98,28.19 81.53,28.19 80.9,27.56 80.46,27.56 80.21,27.82 80.21,28.64 80.08,28.77 79.79,28.77 79.66,28.64 79.66,27.66 79.41,27.41 78.82,27.41 78.58,27.65 78.58,28.07 78.47,28.17 78.17,28.17 78.02,28.02 78.02,27.78 77.77,27.53 75.99,27.53 75,28.52 75,28.63 74.78,28.86 74.14,28.86 v10(73.91,28.62) 73.91,28.65 73.72,28.84 73.51,28.84 73.31,29.05 72.83,29.05 72.69,28.9 72.69,27.66 72.43,27.41 71.69,27.41 71.43,27.66 71.43,28.28 71.32,28.4 71.04,28.4 70.82,28.18 70.4,28.18 70.19,28.4 69.97,28.4 69.84,28.27 69.84,27.61 69.6,27.37 69.22,27.37 68.8,26.95 68.37,26.95 68.05,27.27 68.05,27.71 68.66,28.31 68.66,28.49 68.39,28.76 68.21,28.76 67.83,28.38 67.55,28.38 67.37,28.21 v8(67.37,28.11)
  BOTTOM w0.076: UD3.G7 94.42,28.6 94.42,28.76 94.56,28.91 94.85,28.91 95.06,29.12 95.36,29.12 95.64,28.84 95.79,28.84 v10(96.01,28.62) ; v10(73.91,28.62) 73.69,28.84 73.54,28.84 73.26,29.12 72.96,29.12 72.75,28.91 72.46,28.91 72.32,28.76 UD7.G7 ; UD1.G7 105.47,28.6 105.47,28.76 105.61,28.91 105.89,28.91 106.11,29.12 106.41,29.12 106.69,28.84 106.84,28.84 v10(107.06,28.62) ; UD5.G7 83.37,28.6 83.37,28.76 83.51,28.91 83.8,28.91 84.01,29.12 84.31,29.12 84.59,28.84 84.74,28.84 v10(84.96,28.62)
  BOTTOM w0.16: UCPU1.AV36 64.82,61.61 64.59,61.61 v10(64.46,61.48) ; CD121.2 66.65,28.4 67.08,28.4 v8(67.37,28.11)
