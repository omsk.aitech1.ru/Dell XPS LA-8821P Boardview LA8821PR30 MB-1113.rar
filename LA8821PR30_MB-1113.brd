# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA13: length 185.1
  TOP w0.076: UD6.N3 83.29,23.88 83.13,23.88 82.86,23.6 82.86,22 83.67,21.19 84.63,21.19 84.76,21.06 84.76,20.58 v10(84.66,20.48) ; UD2.N3 105.39,23.88 105.23,23.88 104.96,23.6 104.96,22 105.77,21.19 106.73,21.19 106.85,21.06 106.85,20.58 v10(106.75,20.48) ; v10(73.61,20.48) 73.71,20.58 73.71,21.06 73.58,21.19 72.62,21.19 71.81,22 71.81,23.6 72.08,23.88 72.24,23.88 UD8.N3 ; UD4.N3 94.34,23.88 94.18,23.88 93.91,23.6 93.91,22 94.72,21.19 95.68,21.19 95.81,21.06 95.81,20.58 v10(95.7,20.48)
  TOP w0.16: v2(115.15,23.56) 115.15,23.57 R1066.1
  GND1 w0.102: v3(114.69,23.56) v2(115.15,23.56)
  IN1 w0.127: v3(114.69,23.56) v4(114.18,23.56)
  IN2 w0.122: v4(61.37,40.35) 61.27,40.25 61.27,39.77 61.6,39.44 62.01,39.44 62.22,39.22 62.23,39.22 62.47,38.98 62.47,38.97 63.26,38.18 63.26,32.31 64.09,31.48 64.09,31.31 63.89,31.1 63.89,30.9 64.03,30.76 64.23,30.76 64.44,30.96 64.61,30.96 64.78,30.79 64.78,30.62 64.56,30.4 64.56,30.2 64.71,30.05 64.91,30.05 65.13,30.27 65.3,30.27 65.82,29.75 65.82,29.29 65.67,29.14 64.18,29.14 64.04,29 64.04,28.8 64.18,28.65 65.67,28.65 65.82,28.51 65.82,28.31 65.67,28.17 64.18,28.17 64.04,28.02 64.04,27.82 64.18,27.68 65.67,27.68 65.82,27.53 65.82,27.31 65.7,27.19 65.53,27.19 65.41,27.07 65.41,25.46 65.92,24.96 67.14,24.96 69.65,22.44 71.1,22.44 73.07,20.48 v10(73.61,20.48) 73.61,20.19 74.15,19.65 75.67,19.65 75.8,19.77 75.8,19.98 75.93,20.1 81.89,20.1 82.01,20.23 82.01,21.31 82.14,21.44 82.57,21.44 82.7,21.31 82.7,20.63 82.83,20.5 83.41,20.5 83.54,20.37 83.54,19.41 83.66,19.28 83.99,19.28 84.12,19.41 84.12,20.37 84.25,20.5 84.63,20.5 v10(84.66,20.48) 84.66,19.27 84.78,19.14 86.8,19.14 86.93,19.27 86.93,20.41 87.05,20.54 88.17,20.54 88.3,20.41 88.3,19.32 88.42,19.19 89.26,19.19 89.39,19.32 89.39,21.58 89.52,21.7 90.23,21.7 90.35,21.58 90.35,19.26 90.48,19.14 91.88,19.14 91.98,19.24 91.98,20.35 92.11,20.48 v10(95.7,20.48) 95.7,20.14 96.2,19.65 97.34,19.65 97.67,19.98 103.69,19.98 104.11,20.4 104.11,21.31 104.24,21.44 104.67,21.44 104.8,21.31 104.8,20.63 104.92,20.5 105.51,20.5 105.64,20.37 105.64,19.41 105.76,19.28 106.09,19.28 106.22,19.41 106.22,20.37 106.35,20.5 106.73,20.5 v10(106.75,20.48) 107.2,20.03 108.53,20.03 108.6,20.1 109.94,21.43 112.05,21.43 v4(114.18,23.56)
  IN3 w0.122: v4(62.45,60.33) 61.98,60.33 60.74,59.09 60.74,58.25 60.46,57.98 59.29,57.98 59.11,57.8 59.11,57.14 59.23,57.02 60.06,57.02 60.18,56.9 60.18,56.66 60.06,56.53 59.23,56.53 59.11,56.41 59.11,56.17 59.23,56.05 60.06,56.05 60.18,55.92 60.18,55.68 60.06,55.56 59.23,55.56 59.11,55.44 59.11,55.19 59.23,55.07 60.06,55.07 60.18,54.95 60.18,54.71 60.06,54.58 59.23,54.58 59.11,54.46 59.11,54.22 59.23,54.1 60.06,54.1 60.18,53.97 60.18,53.73 60.06,53.61 59.23,53.61 59.11,53.49 59.11,53.24 59.23,53.12 60.06,53.12 60.18,53 60.18,52.76 60.06,52.63 59.23,52.63 59.11,52.51 59.11,52.46 58.48,51.82 58.48,51.31 58.6,51.19 58.91,51.19 59.03,51.07 59.03,50.83 58.91,50.71 58.6,50.71 58.48,50.58 58.48,48.13 58.6,48.01 58.91,48.01 59.03,47.88 59.03,47.64 58.91,47.52 58.6,47.52 58.48,47.4 58.48,47.12 58.6,47 58.94,47 59.09,46.86 59.09,46.66 58.94,46.51 58.6,46.51 58.48,46.39 58.48,45.07 58.38,44.97 56.64,44.97 56.54,44.87 56.54,41.16 56.64,41.06 57.39,41.06 57.49,40.96 57.49,40.17 57.59,40.07 57.86,40.07 57.99,40.19 57.99,40.71 58.13,40.86 58.33,40.86 58.47,40.71 58.47,40.19 58.6,40.07 59.83,40.07 60.11,39.79 61.27,39.79 61.34,39.86 61.34,40.32 v4(61.37,40.35)
  IN4 w0.091: v4(62.45,60.33) 62.45,61.01 v5(62.61,61.17)
  GND5 w0.102: v5(62.61,61.17) 62.38,60.94 v6(62.2,60.94)
  BOTTOM w0.076: v10(84.66,20.48) 84.66,20.55 85.29,21.19 86.57,21.19 86.94,21.56 86.94,23.43 UD5.N3 ; v10(95.7,20.48) 95.7,20.55 96.34,21.19 97.62,21.19 97.99,21.56 97.99,23.43 UD3.N3 ; v10(106.75,20.48) 106.75,20.55 107.39,21.19 108.67,21.19 109.04,21.56 109.04,23.43 UD1.N3 ; v10(73.61,20.48) 73.61,20.55 74.24,21.19 75.52,21.19 75.89,21.56 75.89,23.43 UD7.N3
  BOTTOM w0.16: UCPU1.AW41 62.41,61.15 v6(62.2,60.94)
DDR_A_MA14: length 177.7
  TOP w0.076: v10(96.34,21.87) 96.34,21.69 96.59,21.44 97.36,21.44 97.62,21.7 97.62,23.8 UD4.N7 ; UD2.N7 108.67,23.8 108.67,21.7 108.4,21.44 107.64,21.44 107.39,21.69 v10(107.39,21.87) ; v10(85.29,21.87) 85.29,21.69 85.54,21.44 86.31,21.44 86.57,21.7 86.57,23.8 UD6.N7 ; v10(74.24,21.87) 74.24,21.69 74.5,21.44 75.26,21.44 75.52,21.7 75.52,23.8 UD8.N7
  TOP w0.16: R1060.1 114.66,26.84 v2(114.59,26.76)
  GND1 w0.102: v2(114.59,26.76) 114.59,26.75 114.28,26.44 v3(114.28,26.31)
  IN1 w0.127: v3(114.28,26.31) 113.94,25.97 v4(113.9,25.97)
  IN3 w0.122: v4(68.59,60.84) 69.18,61.43 71.19,61.43 71.66,60.96 71.66,60.84 71.67,60.83 71.67,60.51 71.66,60.5 71.66,59.46 72.91,58.21 73.94,58.21 80.07,52.08 80.07,51.33 83.71,47.7 83.71,46.72 84.19,46.24 84.19,40.3 83.39,39.5 79.87,39.5 79.02,40.35 79.02,42.28 78.42,42.89 v4(78.34,42.89)
  IN4 w0.091: v4(78.34,42.89) 78.24,42.79 75.04,42.79 74.53,42.28 67.19,42.28 66.43,41.51 66.43,40.89 65.54,40 65.54,37.29 64.36,36.11 64.36,34.59 61.96,32.18 61.96,31.43 61.6,31.08 61.6,29.91 61.97,29.54 62.42,29.54 63.89,28.08 63.89,25.59 67.09,22.38 73.98,22.38 74.24,22.12 v10(74.24,21.87) 74.24,21.06 74.37,20.93 75.38,20.93 75.77,20.55 81.1,20.55 81.23,20.68 81.23,21.06 81.35,21.19 81.61,21.19 81.73,21.06 81.73,20.68 81.86,20.55 82.11,20.55 82.24,20.68 82.24,20.98 82.37,21.11 82.62,21.11 82.75,20.98 82.75,20.68 82.88,20.55 83.23,20.55 83.36,20.68 83.36,22.33 83.49,22.46 84.71,22.46 v10(85.29,21.87) 85.29,21.87 85.16,21.75 85.16,21.06 85.29,20.93 86.28,20.93 86.41,20.81 86.41,20.09 86.28,19.97 84.66,19.97 84.53,19.84 84.53,19.36 84.53,19.12 84.74,18.91 93.88,18.91 94.41,19.43 94.41,22.1 94.77,22.46 95.75,22.46 v10(96.34,21.87) 96.34,21.06 96.47,20.93 97.48,20.93 97.86,20.55 103.2,20.55 103.32,20.68 103.32,21.06 103.45,21.19 103.7,21.19 103.83,21.06 103.83,20.68 103.96,20.55 104.21,20.55 104.34,20.68 104.34,20.98 104.47,21.11 104.72,21.11 104.85,20.98 104.85,20.68 104.97,20.55 105.33,20.55 105.46,20.68 105.46,22.33 105.58,22.46 106.8,22.46 v10(107.39,21.87) 107.39,21.52 107.59,21.31 109.92,21.31 112.73,24.13 112.73,24.8 v4(113.9,25.97) ; v4(68.59,60.84) 68.28,61.15 v5(68.17,61.15)
  GND5 w0.102: v6(68.22,60.47) 68.22,61.09 v5(68.17,61.15)
  BOTTOM w0.076: v10(85.29,21.87) 85.29,22.11 85.12,22.28 84.27,22.28 84.2,22.2 83.51,22.2 83.37,22.35 UD5.N7 ; v10(96.34,21.87) 96.34,22.11 96.17,22.28 95.32,22.28 95.25,22.2 94.56,22.2 94.42,22.35 94.42,23.8 UD3.N7 ; v10(107.39,21.87) 107.39,22.11 107.22,22.28 106.37,22.28 106.3,22.2 105.61,22.2 105.47,22.35 UD1.N7 ; v10(74.24,21.87) 74.24,22.11 74.07,22.28 73.23,22.28 73.15,22.2 72.46,22.2 72.32,22.35 72.32,23.8 UD7.N7
  BOTTOM w0.16: UCPU1.AY28 v6(68.22,60.47)
DDR_A_MA15: length 172.3
  TOP w0.076: v10(106.27,26.45) 106.27,26.46 106.91,27.11 107.17,27.11 108.56,27.11 UD2.J7 ; UD6.J7 86.46,27.11 86.42,27.11 86.42,27.11 85.07,27.11 84.81,27.11 84.17,26.46 v10(84.17,26.45) ; UD8.J7 75.41,27.11 75.37,27.11 75.37,27.11 74.02,27.11 74.02,27.11 73.76,27.11 73.12,26.46 v10(73.12,26.45) ; UD4.J7 97.51,27.11 97.47,27.11 97.47,27.11 96.12,27.11 96.12,27.11 95.86,27.11 95.22,26.46 v10(95.22,26.45)
  TOP w0.16: v2(118.12,30.06) 118.55,30.49 R1038.1
  GND1 w0.102: v2(118.12,30.06) 117.81,30.06 v3(117.69,30.19)
  IN1 w0.127: v3(117.69,30.19) 117.66,30.16 v4(117.08,30.16)
  IN3 w0.122: v4(78.34,42.3) 78.44,42.3 78.75,42 78.75,39.35 78.88,39.23 79.53,39.23 79.65,39.1 79.65,38.36 79.78,38.24 80.02,38.24 80.14,38.36 80.14,39.1 80.26,39.23 84.2,39.23 84.46,39.49 84.46,46.35 83.98,46.83 83.98,47.81 80.35,51.45 80.35,52.2 74.11,58.43 73.09,58.43 71.99,59.53 71.99,60.95 70.82,62.12 v4(70.47,62.12)
  IN4 w0.091: v4(70.47,62.12) 70.27,62.12 v5(69.98,62.41) ; v4(117.08,30.16) 117.08,30.14 115.91,28.97 112.78,28.97 111.06,27.25 109.79,27.25 108.39,25.84 107.93,25.84 107.76,26.01 106.7,26.01 v10(106.27,26.45) 106.07,26.45 105.13,25.5 103.12,25.5 102.99,25.38 102.99,25.1 102.87,24.97 101.8,24.97 101.68,24.85 101.68,24.59 101.81,24.46 102.65,24.46 102.78,24.34 102.78,24.03 102.65,23.9 101.6,23.9 100.91,24.59 99.39,24.59 98.61,25.37 97.36,25.37 96.71,26.01 95.65,26.01 v10(95.22,26.45) 95.03,26.45 94.08,25.5 92.07,25.5 91.94,25.38 91.94,25.12 91.79,24.97 90.85,24.97 90.73,24.84 90.73,24.59 90.85,24.46 91.82,24.46 91.94,24.34 91.94,24.03 91.82,23.9 91.56,23.9 91.46,23.8 91.46,23.27 91.34,23.14 91.03,23.14 90.9,23.27 90.9,23.4 90.78,23.52 90.5,23.52 90.37,23.4 90.37,22.13 90.29,22.05 89.71,22.05 89.61,22.15 89.61,22.66 89.48,22.79 88.29,22.79 88.16,22.91 88.16,23.55 88.34,23.73 88.34,24.59 88.08,24.84 88.08,25.25 87.97,25.37 86.31,25.37 85.66,26.01 84.6,26.01 v10(84.17,26.45) 83.98,26.45 83.04,25.5 81.02,25.5 80.9,25.38 80.9,25.1 80.77,24.97 79.7,24.97 79.59,24.85 79.59,24.59 79.71,24.46 80.55,24.46 80.68,24.34 80.68,24.03 80.55,23.9 79.5,23.9 78.81,24.59 77.29,24.59 76.51,25.37 75.26,25.37 74.67,25.96 73.57,25.96 73.12,26.42 v10(73.12,26.45) 72.93,26.45 71.99,25.5 69.25,25.5 69.06,25.69 67.78,25.69 65.95,27.53 65.95,31.13 66.78,31.96 66.78,34.86 68.18,36.26 68.18,37.1 68.48,37.4 68.48,38.1 68.83,38.44 69.74,38.44 70.07,38.77 71.59,38.77 72.91,37.45 73.29,37.45 73.42,37.58 73.42,38.7 73.62,38.9 74.18,38.9 75.04,39.76 77.44,39.76 77.56,39.89 77.56,40.4 77.69,40.53 77.94,40.53 78.07,40.4 78.07,39.83 78.22,39.69 78.43,39.69 78.58,39.83 78.58,40.63 78.73,40.78 78.94,40.78 79.09,40.63 79.09,39.89 79.21,39.76 79.56,39.76 79.69,39.89 79.69,41.12 79.56,41.25 79.1,41.25 78.98,41.38 78.98,41.63 79.1,41.76 79.56,41.76 79.69,41.88 79.69,42.18 79.48,42.38 78.42,42.38 v4(78.34,42.3)
  GND5 w0.102: v5(69.98,62.41) 69.97,62.41 v6(69.97,61.99)
  BOTTOM w0.076: UD1.J7 105.35,27 105.26,27.09 105.26,27.35 105.41,27.49 105.71,27.49 105.84,27.36 105.84,26.98 105.97,26.85 106.38,26.85 106.5,26.73 106.5,26.57 106.38,26.45 v10(106.27,26.45) ; v10(84.17,26.45) 84.28,26.45 84.4,26.57 84.4,26.73 84.28,26.85 83.87,26.85 83.74,26.98 83.74,27.36 83.61,27.49 83.31,27.49 83.17,27.35 83.17,27.09 83.26,27 UD5.J7 ; v10(73.12,26.45) 73.23,26.45 73.35,26.57 73.35,26.73 73.23,26.85 72.82,26.85 72.69,26.98 72.69,27.36 72.56,27.49 72.26,27.49 72.12,27.35 72.12,27.09 72.21,27 UD7.J7 ; UD3.J7 94.3,27 94.22,27.09 94.22,27.35 94.36,27.49 94.66,27.49 94.79,27.36 94.79,26.98 94.92,26.85 95.33,26.85 95.45,26.73 95.45,26.57 95.33,26.45 v10(95.22,26.45)
  BOTTOM w0.16: UCPU1.AU26 v6(69.97,61.99)
DDR_A_RAS#: length 173.9
  TOP w0.076: v10(85.67,30.98) 85.29,31.36 84.34,31.36 84.11,31.13 84.11,30.8 84.16,30.75 84.16,30.48 84.15,30.47 84.15,30.46 83.92,30.24 83.92,30.24 83.37,29.69 UD6.F3 ; v10(96.72,30.98) 96.34,31.36 95.38,31.36 95.16,31.13 95.16,30.8 95.21,30.75 95.21,30.48 95.2,30.47 95.2,30.46 94.97,30.24 94.97,30.24 94.42,29.69 UD4.F3 ; UD8.F3 72.32,29.69 72.87,30.24 72.88,30.24 73.1,30.46 73.1,30.47 73.11,30.48 73.11,30.75 73.06,30.8 73.06,31.13 73.29,31.36 74.24,31.36 v10(74.63,30.98) ; v10(107.77,30.98) 107.39,31.36 106.43,31.36 106.2,31.13 106.2,30.8 106.26,30.75 106.26,30.48 106.25,30.47 106.25,30.46 106.02,30.24 106.01,30.24 105.47,29.69 UD2.F3
  TOP w0.16: R1070.1 v2(116.77,35.04)
  GND1 w0.102: v2(116.77,35.04) 116.67,35.04 v3(116.42,34.79)
  IN1 w0.127: v4(115.93,34.73) 116.36,34.73 v3(116.42,34.79)
  IN2 w0.122: v4(70.91,37.77) 77.3,37.77 77.43,37.9 77.43,38.75 77.55,38.87 81.01,38.87 81.13,38.75 81.13,34.96 81.01,34.84 79.53,34.84 79.41,34.71 79.41,34.43 79.28,34.3 79.03,34.3 78.91,34.42 78.91,34.71 78.78,34.84 78.55,34.84 78.42,34.71 78.42,34.42 78.3,34.3 77.27,34.3 77.14,34.18 77.14,33.57 77.02,33.44 76.16,33.44 75.98,33.62 75.67,33.62 75.55,33.49 75.55,32.8 74.63,31.88 v10(74.63,30.98) 74.65,30.95 76.89,30.95 77.02,31.08 77.02,32.19 77.43,32.6 78.01,32.6 78.34,32.93 78.34,33.39 78.44,33.49 79.03,33.49 79.15,33.36 79.15,33.06 79.28,32.93 79.86,32.93 79.99,33.06 79.99,33.77 80.12,33.9 81.53,33.9 81.66,33.77 81.66,32.74 81.78,32.62 82.33,32.62 82.35,32.63 83.29,32.63 83.31,32.6 83.95,32.6 84.16,32.4 84.16,31.97 84.36,31.76 84.89,31.76 v10(85.67,30.98) 86.24,31.54 86.24,32.33 86.6,32.69 86.6,33.85 88.65,35.9 91.43,35.9 91.55,35.78 91.55,34.63 91.68,34.51 91.96,34.51 92.09,34.63 92.09,35.27 92.21,35.39 92.58,35.39 92.71,35.27 92.71,32.74 92.83,32.62 93.67,32.62 94.52,33.46 95.56,33.46 95.92,33.11 96.4,33.11 96.75,32.76 96.75,31 v10(96.72,30.98) 96.82,30.88 98.74,30.88 98.97,31.1 98.97,32.21 99.53,32.78 100.28,32.78 100.44,32.93 100.44,32.95 100.44,32.96 100.44,33.19 100.57,33.31 102.22,33.31 102.34,33.44 102.34,33.85 102.47,33.97 103.53,33.97 103.76,33.74 103.76,32.74 103.88,32.62 104.85,32.62 105.75,33.52 106.56,33.52 106.97,33.11 107.06,33.11 107.06,33.11 107.41,33.11 107.42,33.11 107.5,33.11 107.77,32.84 v10(107.77,30.98) 107.92,30.83 109.51,30.83 111.71,33.03 111.71,33.53 113.14,34.96 113.75,34.96 113.98,34.73 v4(115.93,34.73)
  IN3 w0.122: v4(70.91,37.77) 70.76,37.77 70.66,37.87 70.66,38.13 70.41,38.38 70.41,39.36 70.66,39.61 70.66,41.38 70.39,41.64 70.39,42.05 69.84,42.6 69.06,42.6 68.98,42.52 68.81,42.52 68.56,42.77 68.56,42.96 68.67,43.07 69.76,43.07 69.88,43.2 69.88,43.78 69.88,43.78 69.88,43.84 69.59,44.12 68.16,44.12 68.03,44.25 68.03,44.62 67.93,44.72 67.47,44.72 67.37,44.82 67.37,46.22 67.27,46.32 65.82,46.32 65.69,46.45 65.69,46.68 65.82,46.8 70.58,46.8 70.7,46.93 70.7,47.74 70.6,47.84 65.54,47.84 65.41,47.97 65.41,48.22 65.54,48.35 70.54,48.35 70.67,48.48 70.67,48.72 70.54,48.85 69.93,48.85 69.83,48.96 69.83,49.23 69.93,49.34 70.53,49.34 70.65,49.46 70.65,49.71 70.53,49.83 69.96,49.83 69.83,49.95 69.83,50.19 69.96,50.31 70.53,50.31 70.65,50.44 70.65,50.69 70.53,50.81 68.3,50.81 68.18,50.69 68.18,50.05 68.07,49.95 67.79,49.95 67.69,50.05 67.69,50.69 67.57,50.81 65.99,50.81 65.89,50.71 65.89,50.05 65.79,49.95 65.5,49.95 65.4,50.05 65.4,50.69 65.28,50.81 62.81,50.81 62.71,50.91 62.71,55.81 64.02,57.11 64.02,58.08 v4(63.57,58.52)
  IN4 w0.091: v5(63.3,58.98) 63.57,58.71 v4(63.57,58.52)
  GND5 w0.102: v6(63.74,58.98) v5(63.3,58.98)
  BOTTOM w0.076: v10(85.67,30.98) 85.68,30.98 86.26,30.4 86.26,30.04 86.57,29.72 UD5.F3 ; UD3.F3 97.62,29.72 97.31,30.04 97.31,30.4 96.73,30.98 v10(96.72,30.98) ; v10(74.63,30.98) 74.63,30.98 75.21,30.4 75.21,30.04 75.52,29.72 UD7.F3 ; UD1.F3 108.67,29.72 108.35,30.04 108.35,30.4 107.78,30.98 v10(107.77,30.98)
  BOTTOM w0.16: UCPU1.BD39 v6(63.74,58.98)
DDR_A_WE#: length 164.8
  TOP w0.076: v10(85.62,28.45) 85.37,28.2 83.94,28.2 83.55,27.8 UD6.H3 ; UD8.H3 72.5,27.8 72.9,28.2 74.32,28.2 v10(74.57,28.45) ; v10(107.72,28.45) 107.47,28.2 106.04,28.2 105.65,27.8 UD2.H3 ; v10(96.67,28.45) 96.42,28.2 94.99,28.2 94.6,27.8 UD4.H3
  TOP w0.16: R1076.1 v2(114.1,30.8)
  GND1 w0.102: v3(114.1,30.37) v2(114.1,30.8)
  IN1 w0.127: v4(113.8,29.68) 114.1,29.98 v3(114.1,30.37)
  IN2 w0.122: v4(113.8,29.68) 112.77,29.68 112.04,28.95 108.22,28.95 v10(107.72,28.45) 107.72,29.18 107.28,29.61 105.5,29.61 105.05,30.06 104.74,30.06 103.78,29.1 103.47,29.1 102.27,30.29 101.23,30.29 99.88,28.94 99.17,28.94 98.93,29.18 98.93,29.69 98.81,29.81 97.06,29.81 96.84,29.59 96.84,28.62 v10(96.67,28.45) 96.44,28.68 96.44,29.42 96.25,29.61 95.3,29.61 95.07,29.84 93.29,29.84 92.69,30.44 92.69,31 92.31,31.38 91.88,31.38 90.69,32.58 89.34,32.58 89.21,32.45 89.21,30.82 89.66,30.38 89.66,29.52 89.43,29.29 88.27,29.29 88.15,29.16 88.15,29.12 88.02,28.99 87.71,28.99 87.59,29.12 87.59,29.78 87.46,29.91 86.09,29.91 85.96,29.78 85.96,29.25 86.09,29.12 86.95,29.12 87.08,28.99 87.08,28.71 86.95,28.58 85.75,28.58 v10(85.62,28.45) 85.51,28.56 85.51,29.28 85.17,29.61 84.38,29.61 84.11,29.88 82.47,29.88 81.73,29.15 81.32,29.15 80.38,30.09 78.92,30.09 77.96,29.12 77.12,29.12 77,29.24 77,29.65 76.88,29.78 76.64,29.78 76.52,29.65 76.52,29.24 76.39,29.12 76.15,29.12 76.03,29.24 76.03,29.53 75.9,29.65 75.67,29.65 75.54,29.53 75.54,29.24 75.42,29.12 75.13,29.12 74.78,28.77 74.78,28.66 v10(74.57,28.45) 74.35,28.67 74.35,29.39 74.13,29.61 73.48,29.61 73.34,29.76 73.34,30.02 73.19,30.16 70.71,30.16 70.57,30.31 70.57,33.82 71.02,34.28 73.06,34.28 73.55,34.76 75.95,34.76 76.08,34.89 76.08,35.05 76.08,35.49 76.08,35.49 76.08,35.81 76.21,35.93 76.52,35.93 79.93,35.93 80.06,36.06 80.06,37.66 79.94,37.78 79.1,37.78 79,37.68 79,36.81 78.87,36.69 74.15,36.69 73.62,36.16 70.19,36.16 69.37,35.34 68.2,35.34 66.25,33.39 66.25,32.62 65.92,32.3 65.92,32.29 65.62,31.99 64.35,31.99 63.81,32.54 63.81,38.86 62.75,39.92 62.6,39.92 62.58,39.91 v4(62.59,39.91)
  IN3 w0.122: v4(62.59,39.91) 62.54,39.91 62.54,39.87 62.36,39.69 62.34,39.69 62.1,39.45 61.58,39.45 61.58,39.46 60.05,39.46 59.72,39.79 56.37,39.79 56.27,39.89 56.27,45.15 56.37,45.25 58.1,45.25 58.21,45.35 58.21,51.94 58.83,52.57 58.83,58.74 59.34,59.25 59.34,59.63 60.99,61.28 61.65,61.28 62.68,62.31 v4(62.68,62.51)
  IN4 w0.091: v4(62.68,62.51) 62.75,62.45 v5(62.75,62.01)
  GND5 w0.102: v6(62.28,62.11) 62.65,62.11 v5(62.75,62.01)
  BOTTOM w0.076: v10(85.62,28.45) 85.57,28.5 85.37,28.5 85.29,28.42 85.29,28.14 85.41,28.01 85.88,28.01 85.93,27.97 85.93,27.66 86.05,27.54 86.3,27.54 UD5.H3 ; UD3.H3 97.35,27.54 97.1,27.54 96.97,27.66 96.97,27.97 96.93,28.01 96.46,28.01 96.34,28.14 96.34,28.42 96.42,28.5 96.62,28.5 v10(96.67,28.45) ; UD7.H3 75.26,27.54 75,27.54 74.88,27.66 74.88,27.97 74.83,28.01 74.37,28.01 74.24,28.14 74.24,28.42 74.32,28.5 74.52,28.5 v10(74.57,28.45) ; v10(107.72,28.45) 107.67,28.5 107.46,28.5 107.39,28.42 107.39,28.14 107.51,28.01 107.98,28.01 108.02,27.97 108.02,27.66 108.15,27.54 108.4,27.54 UD1.H3
  BOTTOM w0.16: v6(62.28,62.11) 62.61,62.44 UCPU1.AT41
DDR_B_BS0: length 171.3
  TOP w0.076: UD12.J2 45.29,32.39 45.73,32.39 46.44,33.1 46.93,33.1 v10(47.32,32.71) ; UD14.J2 34.24,32.39 34.68,32.39 35.39,33.1 35.88,33.1 v10(36.27,32.71) ; v10(25.22,32.71) 24.83,33.1 24.34,33.1 23.63,32.39 23.19,32.39 UD16.J2 ; UD10.J2 56.34,32.39 56.78,32.39 57.48,33.1 57.98,33.1 v10(58.37,32.71)
  TOP w0.16: v7(18.5,35.5) 18.4,35.39 R1081.1
  IN2 w0.122: v4(64.82,38.77) 64.83,38.77 65.29,39.22 65.29,41.39 65.39,41.5 65.39,41.92 63.47,43.84 49.38,43.84 49.07,44.14 49.07,47.09 49.87,47.88 49.87,48.15 49.99,48.27 50.4,48.27 50.53,48.15 50.53,47.89 50.65,47.76 50.98,47.76 51.11,47.89 51.11,48.53 51.24,48.65 51.57,48.65 51.7,48.53 51.7,47.89 51.82,47.76 52.15,47.76 52.28,47.89 52.28,49.11 52.15,49.24 49.55,49.24 49.42,49.36 49.42,49.7 49.55,49.82 50.66,49.82 50.79,49.95 50.79,50.66 50.49,50.96 49.89,50.96 49.77,51.09 49.77,51.42 49.89,51.55 50.65,51.55 50.78,51.68 50.78,52.53 50.65,52.66 49.89,52.66 49.77,52.79 49.77,53.73 49.89,53.86 50.59,53.86 51.34,54.62 64.1,54.62 64.55,55.07 64.55,55.76 64.07,56.24 v4(64.07,56.42)
  IN3 w0.122: v7(18.5,35.5) 19.85,35.5 21.28,34.07 21.93,34.07 22.31,33.69 23.21,33.69 23.76,33.14 24.79,33.14 v10(25.22,32.71) 25.63,33.12 26.24,33.12 26.39,33.28 26.39,33.71 26.51,33.83 26.74,33.83 26.86,33.71 26.86,33.48 26.98,33.36 27.23,33.36 27.35,33.48 27.35,33.71 27.47,33.83 29.34,33.83 30.33,34.83 31.59,34.83 32.13,34.29 32.13,33.76 32.25,33.63 33.8,33.63 33.93,33.76 33.93,34.45 34.04,34.55 34.75,34.55 34.88,34.43 34.88,33.29 35.01,33.16 35.82,33.16 v10(36.27,32.71) 36.68,33.12 37.28,33.12 37.44,33.28 38.35,33.28 39.13,34.06 40.97,34.06 41.37,34.47 41.37,35.48 41.29,35.56 41.29,35.57 40.9,35.96 40.9,36.82 41.03,36.94 41.92,36.94 42.04,36.82 42.04,36.21 42.4,35.85 42.4,35.85 42.64,35.61 42.64,35.61 42.9,35.35 42.9,33.73 43.02,33.61 43.41,33.61 43.53,33.73 43.53,34.01 43.66,34.14 44.02,34.14 44.14,34.01 44.14,33.76 44.27,33.63 44.85,33.63 44.98,33.76 44.98,34.45 45.09,34.55 45.56,34.55 45.67,34.45 45.67,33.33 45.83,33.16 46.84,33.16 47.29,32.71 v10(47.32,32.71) 47.73,33.12 48.33,33.12 48.55,33.34 48.55,34.3 49.21,34.96 49.78,34.96 50.11,34.63 50.11,34.07 50.63,33.54 51.14,33.54 52.43,34.83 53.69,34.83 54.23,34.29 54.23,33.39 54.38,33.24 56.81,33.24 56.86,33.19 57.89,33.19 v10(58.37,32.71) 58.78,33.12 59.17,33.12 60.38,31.92 60.38,30.54 60.76,30.16 60.76,29.25 61.07,28.94 62.69,28.94 62.82,29.07 62.82,29.53 62.69,29.65 61.73,29.65 61.6,29.78 61.6,31.18 61.73,31.31 63.02,31.31 63.15,31.18 63.15,30.57 63.28,30.44 63.79,30.44 63.91,30.57 63.91,32.83 63.79,32.96 63.35,32.96 63.23,32.83 63.23,32.02 63.1,31.89 62.67,31.89 62.54,32.02 62.54,34.81 63.18,35.45 63.18,35.85 62.82,36.21 62.82,36.45 63.73,37.37 63.73,37.76 63.86,37.88 64.24,37.88 64.37,38.01 64.37,38.29 64.24,38.42 64.12,38.42 63.99,38.54 63.99,38.72 64.15,38.87 64.37,38.87 64.51,38.72 64.73,38.72 64.78,38.77 v4(64.82,38.77)
  IN4 w0.091: v5(63.53,56.31) 63.64,56.42 v4(64.07,56.42)
  GND5 w0.102: v6(63.64,56.72) 63.53,56.61 v5(63.53,56.31)
  BOTTOM w0.076: v10(36.27,32.71) 36.27,32.64 36.6,32.3 37.68,32.3 37.78,32.4 38.41,32.4 UD13.J2 ; UD9.J2 60.51,32.4 59.87,32.4 59.78,32.3 58.7,32.3 58.37,32.64 v10(58.37,32.71) ; v10(47.32,32.71) 47.32,32.64 47.65,32.3 48.73,32.3 48.83,32.4 49.46,32.4 UD11.J2 ; UD15.J2 27.36,32.4 26.73,32.4 26.63,32.3 25.55,32.3 25.22,32.64 v10(25.22,32.71)
  BOTTOM w0.16: UCPU1.BG39 v6(63.64,56.72)
DDR_B_BS1: length 173.4
  TOP w0.076: UD14.K8 38.28,31.73 37.84,31.73 37.66,31.91 36.55,31.91 v10(36.17,31.53) ; UD10.K8 60.38,31.73 59.94,31.73 59.76,31.91 58.65,31.91 v10(58.26,31.53) ; UD12.K8 49.33,31.73 48.89,31.73 48.71,31.91 47.31,31.91 47.22,31.82 v10(47.22,31.53) ; v10(25.12,31.53) 25.5,31.91 26.61,31.91 26.79,31.73 27.23,31.73 UD16.K8
  TOP w0.16: R1077.1 v7(18.47,33.62)
  IN2 w0.122: v4(62.77,58.47) 62.46,58.47 61.7,57.72 61.7,57.28 60.7,56.28 49.7,56.28 47.78,54.36 47.78,48.98 47.17,48.37 47.17,47.89 46.95,47.67 42.76,47.67 42.27,47.18 42.27,46.65 42.12,46.49 40.36,46.49 39.43,45.56 39.43,44.1 40.22,43.31 40.22,42.12 40.77,41.57 50.74,41.57 51.35,42.18 52.11,42.18 52.9,41.39 54.31,41.39 55.1,42.18 62.66,42.18 63.04,41.8 63.04,40.93 63.78,40.2 64.42,40.2 64.74,40.52 64.74,41.05 64.68,41.12 64.68,41.15 v4(64.67,41.15)
  IN3 w0.122: v4(64.67,41.15) 64.68,41.15 64.68,41.16 64.65,41.14 64.68,41.14 65.31,40.5 65.31,36.85 65.91,36.24 65.91,35.88 65.67,35.63 65.22,35.63 64.98,35.4 64.98,32.15 64.47,31.64 64.47,27.66 64.35,27.54 61.41,27.54 60.03,28.92 60.03,29.77 58.27,31.53 v10(58.26,31.53) 57.81,31.08 54.69,31.08 53.64,32.13 53.17,32.13 53.04,32.26 53.04,33.46 52.92,33.59 52.03,33.59 51.9,33.46 51.9,32.93 51.13,32.16 49.6,32.16 49.45,32.01 49.45,31.42 49.32,31.3 49.02,31.3 48.89,31.42 48.89,31.83 48.77,31.96 47.54,31.96 47.22,31.63 47.22,31.53 v10(47.22,31.53) 46.57,32.17 45.62,32.17 44.8,33 42.97,33 42.85,32.88 42.85,32.62 42.98,32.49 43.2,32.49 43.33,32.36 43.33,31.75 43.23,31.65 42.49,31.65 42.36,31.77 42.36,32.88 42.24,33 42,33 41.88,32.88 41.88,31.77 41.75,31.65 41.51,31.65 41.39,31.77 41.39,33.27 41.26,33.4 40.97,33.4 40.84,33.27 40.84,31.85 40.69,31.7 39.9,31.7 39.44,32.16 38.63,32.16 38.4,31.93 38.4,31.42 38.27,31.3 37.97,31.3 37.84,31.42 37.84,31.83 37.72,31.96 36.5,31.96 36.17,31.63 36.17,31.53 v10(36.17,31.53) 35.52,32.17 34.58,32.17 33.75,33 32.54,33 32.06,32.52 32.06,32.26 31.93,32.13 31.07,32.13 30.94,32.26 30.94,33.46 30.82,33.59 29.93,33.59 29.8,33.46 29.8,32.93 29.03,32.16 27.51,32.16 27.35,32.01 27.35,31.42 27.23,31.3 26.92,31.3 26.79,31.42 26.79,31.83 26.67,31.96 25.45,31.96 25.12,31.63 25.12,31.53 v10(25.12,31.53) 24.47,32.17 23.53,32.17 22.72,32.98 20.51,32.98 20.4,32.88 19.57,32.88 18.83,33.62 v7(18.47,33.62)
  IN4 w0.091: v4(62.77,58.47) 62.66,58.59 v5(62.26,58.59)
  GND5 w0.102: v5(62.26,58.59) 62.15,58.47 v6(62.15,58.19)
  BOTTOM w0.076: UD15.K8 22.88,31.39 23.19,31.7 23.74,31.7 24.35,31.09 24.87,31.09 25.12,31.34 v10(25.12,31.53) ; UD9.K8 56.03,31.39 56.33,31.7 56.89,31.7 57.5,31.09 58.02,31.09 58.26,31.34 v10(58.26,31.53) ; v10(36.17,31.53) 36.17,31.34 35.92,31.09 35.4,31.09 34.79,31.7 34.24,31.7 33.93,31.39 UD13.K8 ; v10(47.22,31.53) 47.22,31.34 46.97,31.09 46.45,31.09 45.84,31.7 45.29,31.7 44.98,31.39 UD11.K8
  BOTTOM w0.16: v6(62.15,58.19) 62.42,58.46 UCPU1.BD42
DDR_B_BS2: length 170.3
  TOP w0.076: v10(35.61,32.71) 35.61,32.15 35.06,31.6 34.54,31.6 34.41,31.73 34.41,31.95 34.54,32.08 34.73,32.08 UD14.J3 ; v10(24.56,32.71) 24.56,32.15 24.01,31.6 23.49,31.6 23.36,31.73 23.36,31.95 23.49,32.08 23.68,32.08 UD16.J3 ; v10(46.66,32.71) 46.66,32.15 46.11,31.6 45.59,31.6 45.46,31.73 45.46,31.95 45.59,32.08 45.78,32.08 UD12.J3 ; v10(57.71,32.71) 57.71,32.15 57.16,31.6 56.64,31.6 56.51,31.73 56.51,31.95 56.64,32.08 56.82,32.08 UD10.J3
  TOP w0.16: R1079.1 18.12,34.51 v7(18.47,34.86)
  IN2 w0.122: v4(65.49,36.05) 65.63,36.18 65.63,36.22 65.79,36.39 65.79,36.66 66.22,37.1 66.43,37.1 66.88,36.64 68.21,36.64 68.64,37.07 68.64,37.96 68.64,37.97 68.64,37.97 68.97,38.29 69.89,38.29 70.49,38.9 73.18,38.9 73.31,39.02 73.31,39.87 73.44,39.99 75.44,39.99 76.18,39.26 76.41,39.26 77.11,39.95 79.54,39.95 79.71,40.12 79.71,40.32 79.48,40.55 78.82,40.55 77.91,41.46 77.91,43.22 78.09,43.4 78.47,43.4 78.61,43.54 78.61,44.37 79.86,45.63 79.86,45.91 79.48,46.29 79.48,46.8 77.97,48.31 77.97,51.77 77.45,52.29 77.45,55.6 78.87,57.02 78.87,57.95 79.2,58.28 79.2,58.71 78.87,59.04 77.43,59.04 76.78,59.69 75.92,59.69 75.62,59.98 75.39,59.98 75.1,59.69 74.85,59.69 74.23,60.31 74.23,60.85 74.83,61.45 74.83,61.63 74.38,62.09 74.2,62.09 73.79,61.68 73.08,61.68 72.89,61.87 72.89,62.2 72.73,62.37 71.99,62.37 v4(71.94,62.42)
  IN3 w0.122: v4(65.49,36.05) 64.18,36.05 64.06,36.18 64.06,36.51 64.18,36.64 64.91,36.64 65.03,36.77 65.03,37.25 64.91,37.38 64.7,37.38 64.47,37.6 64.14,37.6 64.01,37.48 64.01,37.25 63.2,36.45 63.2,36.21 63.45,35.97 63.45,35.62 63.58,35.5 64.58,35.5 64.71,35.37 64.71,35.06 64.58,34.94 63.08,34.94 62.95,34.81 62.95,34.51 63.08,34.38 64.58,34.38 64.71,34.25 64.71,33.95 64.58,33.82 62.95,33.82 62.82,33.69 62.82,33.39 62.95,33.26 64.58,33.26 64.71,33.13 64.71,32.75 64.58,32.63 64.32,32.63 64.2,32.5 64.2,30.29 64.07,30.16 63.18,30.16 63.05,30.04 63.05,29.71 63.18,29.58 64.07,29.58 64.2,29.45 64.2,29.12 64.07,28.99 63.18,28.99 63.05,28.87 63.05,28.54 63.18,28.41 64.07,28.41 64.19,28.28 64.19,27.94 64.07,27.81 61.69,27.81 60.38,29.12 60.38,29.91 59.98,30.31 59.98,31.53 59.39,32.12 58.27,32.12 57.71,32.68 ; 57.71,32.68 v10(57.71,32.71) ; 57.71,32.68 57.71,32.55 57.56,32.4 56.69,32.4 56.17,32.92 53.58,32.92 53.45,33.05 53.45,33.67 53.58,33.79 53.69,33.79 53.82,33.92 53.82,34.27 53.69,34.39 52.39,34.39 51.47,33.48 51.47,33.05 51.34,32.92 51.05,32.92 50.93,32.8 50.93,32.61 50.81,32.49 50.56,32.49 50.37,32.68 50.02,32.68 49.83,32.49 49.59,32.49 49.47,32.61 49.47,32.8 49.34,32.92 48.87,32.92 48.23,32.28 47.06,32.28 46.66,32.68 v10(46.66,32.71) 45.7,32.71 45.1,33.31 41.86,33.31 41.73,33.43 41.73,33.66 41.86,33.79 42.47,33.79 42.59,33.91 42.59,34.22 42.47,34.34 42.19,34.34 42.06,34.47 42.06,34.75 42.19,34.88 42.41,34.88 42.54,35 42.54,35.23 42.31,35.46 41.86,35.46 41.68,35.28 41.68,34.27 41.17,33.76 40.64,33.76 40.51,33.63 40.51,32.64 40.38,32.51 40.15,32.51 40.03,32.64 40.03,32.85 39.9,32.97 39.56,32.97 39.44,32.85 39.44,32.56 39.32,32.44 39.08,32.44 38.95,32.56 38.95,32.85 38.83,32.97 38.61,32.97 38.48,32.85 38.48,32.46 38.3,32.28 38.04,32.28 37.92,32.4 37.92,32.82 37.79,32.95 37.56,32.95 37.43,32.82 37.43,32.4 37.31,32.28 35.87,32.28 35.61,32.54 v10(35.61,32.71) 34.65,32.71 34.05,33.31 32.46,33.31 32.07,32.92 31.48,32.92 31.35,33.05 31.35,33.67 31.48,33.79 31.59,33.79 31.72,33.92 31.72,34.27 31.59,34.39 30.29,34.39 29.37,33.48 29.37,33.05 29.24,32.92 28.95,32.92 28.83,32.8 28.83,32.61 28.71,32.49 28.46,32.49 28.23,32.73 27.97,32.73 27.73,32.49 27.49,32.49 27.37,32.61 27.37,32.8 27.25,32.92 26.77,32.92 26.13,32.28 24.96,32.28 24.56,32.68 v10(24.56,32.71) 23.6,32.71 23,33.31 22.24,33.31 21.8,33.74 21.21,33.74 20.1,34.86 v7(18.47,34.86)
  IN4 w0.091: v5(71.38,62.39) 71.91,62.39 v4(71.94,62.42)
  GND5 w0.102: v6(70.94,62.39) v5(71.38,62.39)
  BOTTOM w0.076: v10(46.66,32.71) 46.66,32.68 47.32,32.02 48.92,32.02 UD11.J3 ; v10(24.56,32.71) 24.56,32.68 25.22,32.02 26.82,32.02 UD15.J3 ; v10(35.61,32.71) 35.61,32.68 36.27,32.02 37.87,32.02 UD13.J3 ; v10(57.71,32.71) 57.71,32.68 58.37,32.02 59.97,32.02 UD9.J3
  BOTTOM w0.16: UCPU1.AT22 v6(70.94,62.39)
DDR_B_CAS#: length 177.5
  TOP w0.076: v10(24.8,36.04) 24.8,35.62 24.31,35.14 24.31,34.56 23.68,33.92 UD16.G3 ; UD10.G3 56.82,33.92 57.14,34.24 57.14,34.43 57.22,34.51 57.41,34.51 57.47,34.57 57.47,34.68 57.3,34.86 57.3,34.98 58.08,35.76 58.08,35.9 v10(57.94,36.04) ; v10(46.9,36.04) 46.9,35.62 46.41,35.14 46.41,34.56 45.78,33.92 UD12.G3 ; UD14.G3 34.73,33.92 35.36,34.56 35.36,35.14 35.85,35.62 v10(35.85,36.04)
  TOP w0.16: R1073.1 18.39,38.37 v7(18.52,38.37)
  IN1 w0.091: v4(62.35,41.48) 62.32,41.52 60.21,41.52 59.06,40.37 59.06,37.86 59.11,37.81 59.11,36.89 58.69,36.48 58.38,36.48 v10(57.94,36.04) 57.64,36.34 57.64,37.5 57.46,37.68 56.88,37.68 56.83,37.73 56.17,37.73 55.95,37.52 55.49,37.52 55,38.01 55,38.87 54.74,39.13 53.65,39.13 53.42,38.9 53.42,37.71 53.17,37.45 51.7,37.45 51.55,37.6 50.51,37.6 50.36,37.44 50.36,36.03 50.17,35.85 49.31,35.85 48.42,36.74 47.91,36.74 47.74,36.57 47.43,36.57 v10(46.9,36.04) 46.11,36.83 45.57,36.83 45.53,36.87 45.17,36.87 44.94,37.1 44.94,37.63 45.88,38.57 45.88,39.65 44.34,41.19 39.42,41.19 38.53,40.29 38.53,40.26 38.51,40.25 38.51,38.5 38.77,38.25 38.77,36.33 38.46,36.02 37.94,36.02 37.75,36.21 37.75,36.64 37.65,36.74 36.83,36.74 36.64,36.54 36.35,36.54 v10(35.85,36.04) 35.15,36.74 34.7,36.74 34.57,36.87 34.04,36.87 32.9,38.01 32.9,38.87 32.65,39.13 30,39.13 29.88,39 29.88,37.79 29.75,37.66 28.18,37.66 27.99,37.48 27.99,36.19 27.59,35.79 27.17,35.79 26.35,36.61 25.37,36.61 v10(24.8,36.04) 24.8,36.01 24.08,36.73 23.69,36.73 23.55,36.87 21.98,36.87 21.53,37.33 20.68,37.33 19.44,38.57 18.73,38.57 v7(18.52,38.37)
  IN2 w0.122: v4(61.59,61.88) 61.59,59.62 61.12,59.14 61.12,57.52 60.43,56.83 49.48,56.83 47.23,54.59 47.23,53 47.11,52.87 46.64,52.87 46.51,52.74 46.51,52.44 46.64,52.31 47.11,52.31 47.23,52.18 47.23,51.85 47.11,51.73 45.07,51.73 44.94,51.6 44.94,51.27 45.07,51.14 47.11,51.14 47.23,51.02 47.23,50.69 47.11,50.56 45.07,50.56 44.94,50.43 44.94,50.1 45.07,49.97 47.1,49.97 47.23,49.85 47.23,49.51 47.1,49.39 43.36,49.39 43.24,49.26 43.24,48.93 43.36,48.81 44.63,48.81 44.76,48.68 44.76,48.34 44.63,48.22 42.53,48.22 41.72,47.41 41.72,47.22 41.55,47.04 40.13,47.04 38.88,45.79 38.88,43.87 39.67,43.08 39.67,41.9 40.54,41.02 43.31,41.02 43.49,40.85 54.54,40.85 55.33,41.63 57.49,41.63 57.79,41.33 58.14,41.33 58.26,41.45 58.26,41.5 58.38,41.62 58.63,41.62 58.75,41.5 58.75,41.45 58.87,41.33 59.12,41.33 59.24,41.45 59.24,41.5 59.36,41.62 59.6,41.62 59.73,41.5 59.73,41.45 59.85,41.33 60.09,41.33 60.21,41.45 60.21,41.5 60.34,41.62 60.58,41.62 60.7,41.5 60.7,41.45 60.82,41.33 61.07,41.33 61.19,41.45 61.19,41.5 61.31,41.62 61.55,41.62 61.68,41.5 61.68,41.45 61.8,41.33 62.2,41.33 v4(62.35,41.48)
  IN4 w0.091: v4(61.59,61.88) 61.59,61.88 v5(61.17,62.29)
  GND5 w0.102: v5(61.17,62.29) 61.17,61.93 v6(61.11,61.87)
  BOTTOM w0.076: UD9.G3 59.84,33.68 59.34,34.18 59.34,35.24 59.09,35.5 58.94,35.5 58.91,35.52 58.4,35.52 57.94,35.98 v10(57.94,36.04) ; v10(35.85,36.04) 35.85,35.98 36.3,35.52 36.81,35.52 36.84,35.5 36.99,35.5 37.24,35.24 37.24,34.18 37.74,33.68 UD13.G3 ; v10(24.8,36.04) 24.8,35.98 25.25,35.52 25.76,35.52 25.79,35.5 25.94,35.5 26.19,35.24 26.19,34.18 26.69,33.68 UD15.G3 ; UD11.G3 48.79,33.68 48.29,34.18 48.29,35.24 48.04,35.5 47.89,35.5 47.86,35.52 47.35,35.52 46.9,35.98 v10(46.9,36.04)
  BOTTOM w0.16: UCPU1.AV43 v6(61.11,61.87)
DDR_B_CKE0: length 187
  TOP w0.076: v10(58.28,35.1) 58.28,35.1 58.28,35.1 58.34,35.1 58.74,35.5 59.37,35.5 59.71,35.15 59.96,34.9 60.06,34.9 60.42,34.54 60.42,34.31 60.66,34.07 61.23,34.07 UD10.G9 ; v10(25.14,35.1) 25.14,35.1 25.2,35.1 25.6,35.5 25.96,35.5 25.97,35.5 26.22,35.5 26.57,35.15 26.75,34.97 26.75,34.97 26.82,34.9 26.92,34.9 27.28,34.54 27.28,34.31 27.52,34.07 28.08,34.07 UD16.G9 ; v10(36.19,35.1) 36.18,35.1 36.18,35.1 36.24,35.1 36.65,35.5 37.01,35.5 37.01,35.5 37.27,35.5 37.62,35.15 37.87,34.9 37.96,34.9 38.33,34.54 38.33,34.31 38.56,34.07 39.13,34.07 UD14.G9 ; v10(47.23,35.1) 47.23,35.1 47.29,35.1 47.69,35.5 48.06,35.5 48.06,35.5 48.32,35.5 48.66,35.15 48.85,34.97 48.85,34.97 48.91,34.9 49.01,34.9 49.37,34.54 49.37,34.31 49.61,34.07 50.18,34.07 UD12.G9
  TOP w0.188: v8(18.45,36.79) 18.07,37.17 R1069.1
  IN1 w0.104: v4(69.18,37.75) 69.18,38.82 69.14,38.86 69.14,40.46 69.18,40.5 69.18,40.73 67.69,42.22 65.8,42.22 65.4,41.82 65.4,40.9 65.03,40.53 64.57,40.53 64.37,40.32 63.94,40.32 63.68,40.58 63.56,40.58 63.35,40.37 63.35,39.46 63.35,39.1 63.48,38.97 63.48,37.15 63.35,37.02 63.02,37.02 62.9,37.15 62.9,38.67 62.77,38.8 61.98,38.8 61.86,38.93 61.86,39.2 61.02,40.04 60.78,40.04 60.36,39.62 60.36,38.85 60.92,38.29 60.92,37.83 61.04,37.71 61.81,37.71 61.93,37.58 61.93,37.25 61.81,37.12 61.04,37.12 60.92,37 60.92,36.66 61.04,36.54 61.78,36.54 61.91,36.41 61.91,36.08 61.78,35.95 60,35.95 59.87,35.83 59.87,35.47 60,35.34 61.48,35.34 61.6,35.22 61.6,34.86 61.48,34.73 59.16,34.73 59.03,34.61 58.75,34.61 58.28,35.07 v10(58.28,35.1) 58.05,34.86 56.95,34.86 55.79,33.7 55.24,33.7 54.28,34.67 53.57,34.67 52.99,35.24 52.28,35.24 52.15,35.12 52.15,34.14 52.03,34.01 50.47,34.01 50.32,34.16 50.32,34.84 50.18,34.99 49.88,34.99 49.73,34.84 49.73,34.16 49.59,34.01 49.24,34.01 48.71,34.55 47.75,34.55 47.23,35.06 v10(47.23,35.1) 47.05,34.91 44.6,34.91 43.95,34.27 43.48,34.27 43.2,34.55 43.2,36.45 42.93,36.72 42.93,37.27 42.58,37.63 42.58,39.71 42.35,39.94 39.58,39.94 39.37,39.74 39.37,38.83 39.63,38.58 39.63,35.99 38.25,34.6 36.66,34.6 36.62,34.65 36.61,34.65 36.37,34.89 36.37,34.89 36.19,35.08 v10(36.19,35.1) 35.97,34.89 33.52,34.89 32.91,34.27 32.66,34.27 31.81,35.11 31.2,35.11 31.07,35.24 31.07,36.23 30.94,36.36 30.61,36.36 30.49,36.23 30.49,34.64 29.86,34.01 29.17,34.01 29.08,33.92 27.42,33.92 26.81,34.53 25.67,34.53 25.14,35.06 v10(25.14,35.1) 24.93,34.89 23.19,34.89 23.19,34.89 22.48,34.89 21.86,34.27 21.41,34.27 19.95,35.73 19.77,35.73 18.7,36.79 v8(18.45,36.79)
  IN2 w0.14: v4(71.57,63.04) 72.49,63.04 72.65,62.88 73,62.88 73.36,63.23 73.67,63.23 73.8,63.37 73.8,64.02 73.93,64.15 74.38,64.15 74.51,64.02 74.51,63.31 74.63,63.18 75.1,63.18 75.27,63.02 75.27,61.1 75.72,60.64 76.31,60.64 76.66,60.29 76.99,60.29 77.35,60.64 77.35,61 78.29,61.94 78.82,61.94 79.05,62.17 79.56,62.17 80.01,61.72 80.01,57.39 77.99,55.38 77.99,52.51 78.51,51.99 78.51,48.53 79.76,47.28 80.08,47.28 80.4,46.95 80.4,45.4 79.15,44.15 79.15,41.68 80.86,39.97 80.86,39.61 80.66,39.41 77.33,39.41 76.89,38.97 76.89,38.44 76.76,38.32 75.67,38.32 75.55,38.44 75.55,39.13 75.37,39.31 74.58,39.31 73.63,38.36 70.72,38.36 70.1,37.75 v4(69.18,37.75)
  IN4 w0.104: v4(71.57,63.04) 71.55,63.04 v5(71.18,63.41)
  GND5 w0.102: v5(71.18,63.41) 71.18,63.28 70.94,63.05 v6(70.94,63.04)
  BOTTOM w0.076: v10(58.28,35.1) 58.06,34.88 56.62,34.88 56.37,34.62 56.37,33.46 56.11,33.2 55.8,33.2 55.65,33.35 55.65,33.61 55.58,33.68 UD9.G9 ; v10(36.19,35.1) 35.96,34.88 34.53,34.88 34.27,34.62 34.27,33.46 34.01,33.2 33.7,33.2 33.55,33.35 33.55,33.61 33.48,33.68 UD13.G9 ; v10(25.14,35.1) 24.92,34.88 23.48,34.88 23.22,34.62 23.22,33.46 22.96,33.2 22.65,33.2 22.5,33.35 22.5,33.61 22.43,33.68 22.08,33.68 UD15.G9
  BOTTOM w0.188: UCPU1.AR22 v6(70.94,63.04) ; UD11.G9 44.37,33.68 44.79,33.26 45.17,33.26 45.37,33.46 45.37,34.67 45.56,34.86 47,34.86 v10(47.23,35.1)
DDR_B_CS0#: length 180.1
  TOP w0.076: UD12.H2 44.98,32.88 45.19,32.88 45.5,33.19 45.99,33.19 46.26,33.46 46.25,33.47 46.26,33.48 46.26,33.83 46.51,34.07 46.54,34.07 47.15,34.68 47.45,34.68 v10(47.84,35.06) ; v10(36.79,35.06) 36.41,34.68 36.1,34.68 35.49,34.07 35.46,34.07 35.22,33.83 35.22,33.48 35.2,33.47 35.21,33.46 34.94,33.19 34.46,33.19 34.14,32.88 33.93,32.88 UD14.H2 ; UD10.H2 56.03,32.88 56.24,32.88 56.55,33.19 57.04,33.19 57.31,33.46 57.3,33.47 57.31,33.48 57.31,33.83 57.56,34.07 57.59,34.07 58.2,34.68 58.5,34.68 v10(58.88,35.06) ; v10(25.74,35.06) 25.36,34.68 25.05,34.68 24.44,34.07 24.41,34.07 24.17,33.83 24.17,33.48 24.15,33.47 24.16,33.46 23.89,33.19 23.41,33.19 23.1,32.88 22.88,32.88 UD16.H2
  TOP w0.188: R1071.1 18.16,38.06 v7(18.52,37.7)
  IN1 w0.104: v4(64.17,40.76) 64.17,40.76 64.17,40.81 64.1,40.88 63.27,40.88 63.05,40.65 63.05,39.59 62.92,39.46 62.31,39.46 62.16,39.61 62.16,39.73 62.16,39.73 62.16,40.08 62.16,40.08 62.16,40.14 62.11,40.2 62.11,40.42 61.65,40.88 61.2,40.88 60.05,39.74 60.05,37.78 59.57,37.3 59.57,35.75 v10(58.88,35.06) 58.88,35.14 58.59,35.44 58.53,35.44 58.48,35.5 58.42,35.5 58.4,35.52 57.76,35.52 57.46,35.22 56.22,35.22 56,35.44 56,36.03 55.62,36.41 55.23,36.41 55.13,36.31 55.13,35.55 54.9,35.32 53.45,35.32 53.07,35.7 53.07,36.72 52.89,36.89 52.41,36.89 52.16,36.65 52.16,35.76 51.98,35.58 50.76,35.58 50.48,35.3 48.07,35.3 v10(47.84,35.06) 47.84,35.14 47.54,35.44 47.49,35.44 47.43,35.5 47.37,35.5 47.35,35.52 46.71,35.52 46.41,35.22 44.38,35.22 44.13,35.47 44.13,39.51 43.09,40.55 39.66,40.55 39.07,39.97 39.07,38.71 39.27,38.51 39.31,38.47 39.31,36.1 39.27,36.06 38.49,35.28 37.01,35.28 v10(36.79,35.06) 36.79,35.14 36.49,35.44 36.44,35.44 36.38,35.5 36.32,35.5 36.31,35.52 35.66,35.52 35.36,35.22 33.28,35.22 33,35.5 33,36.11 32.71,36.41 32.04,36.41 31.91,36.54 31.91,37.43 31.5,37.83 30.72,37.83 30.07,37.18 30.07,35.73 29.94,35.6 28.32,35.6 28.2,35.47 28.2,35.45 28.07,35.32 26.83,35.32 26.58,35.06 v10(25.74,35.06) 25.74,35.14 25.44,35.44 25.39,35.44 25.33,35.5 25.27,35.5 25.26,35.52 24.61,35.52 24.33,35.23 22.3,35.23 22.27,35.27 20.83,35.27 19.84,36.26 19.67,36.26 18.52,37.41 v7(18.52,37.7)
  IN2 w0.14: v4(62.69,57.9) 62.65,57.9 62.24,57.49 62.24,57.06 60.92,55.75 49.93,55.75 48.32,54.14 48.32,48.76 47.78,48.22 47.78,47.31 47.61,47.13 42.98,47.13 42.86,47 42.86,46.65 42.98,46.52 47.84,46.52 47.97,46.38 47.97,46.08 47.84,45.95 40.58,45.95 39.97,45.34 39.97,44.32 40.76,43.54 40.76,42.35 40.99,42.11 41.56,42.11 41.7,42.25 41.7,42.34 41.84,42.48 42.12,42.48 42.26,42.34 42.26,42.25 42.4,42.11 42.79,42.11 42.93,42.25 42.93,42.62 43.07,42.76 43.35,42.76 43.49,42.62 43.49,42.25 43.63,42.11 43.91,42.11 44.05,42.25 44.05,42.62 44.19,42.76 44.47,42.76 44.61,42.62 44.61,42.25 44.75,42.11 45.72,42.11 45.89,42.27 45.89,42.62 46,42.74 46.28,42.74 46.42,42.6 46.42,42.25 46.56,42.11 50.52,42.11 51.13,42.72 52.34,42.72 53.12,41.93 54.09,41.93 54.88,42.72 62.89,42.72 63.58,42.02 63.58,41.15 63.95,40.78 64.14,40.78 64.17,40.75 64.17,40.76 v4(64.17,40.76)
  IN4 w0.104: v5(62.49,57.44) 62.69,57.64 v4(62.69,57.9)
  GND5 w0.102: v6(62.12,57.78) 62.15,57.78 v5(62.49,57.44)
  BOTTOM w0.076: UD9.H2 60.64,32.88 60.59,32.93 60.59,33.15 60.54,33.19 59.67,33.19 59.51,33.35 59.51,33.75 59.29,33.97 59.08,33.97 59,34.05 59,34.95 v10(58.88,35.06) ; UD13.H2 38.42,33.19 38.06,33.19 37.72,33.19 37.68,33.24 37.53,33.24 37.41,33.35 37.41,33.68 36.9,34.2 36.9,34.95 v10(36.79,35.06) ; UD15.H2 27.37,33.19 27.01,33.19 26.75,33.19 26.75,33.19 26.68,33.19 26.63,33.24 26.48,33.24 26.36,33.35 26.36,33.68 25.85,34.2 25.85,34.95 v10(25.74,35.06) ; v10(47.84,35.06) 47.95,34.95 47.95,34.2 48.46,33.68 48.46,33.35 48.58,33.24 48.73,33.24 48.77,33.19 48.85,33.19 48.85,33.19 49.11,33.19 49.47,33.19 UD11.H2
  BOTTOM w0.188: UCPU1.BE41 62.41,57.78 v6(62.12,57.78)
DDR_B_D0: length 61.1
  IN4 w0.071: v5(80.32,65.16) 80.32,64.91 80.45,64.78 80.96,64.78 81.08,64.91 81.08,65.27 81.39,65.57 82.73,65.57 82.86,65.7 83.48,65.7 85.51,63.67 85.51,51.39 81.61,47.49 81.41,47.49 80.99,47.9 80.82,47.9 80.69,47.78 80.69,47.6 81.11,47.18 81.11,46.99 80.67,46.55 80.47,46.55 80.07,46.95 79.82,46.95 79.42,46.55 79.42,46.38 79.86,45.94 79.86,45.74 79.42,45.3 79.23,45.3 78.81,45.72 78.63,45.72 78.51,45.59 78.51,45.41 78.92,45 78.92,44.8 78.41,44.28 78.24,44.28 77.79,44.73 77.62,44.73 77.49,44.6 77.49,44.42 77.83,44.08 77.83,43.9 77.7,43.77 74.01,43.77 73.78,43.54 66.67,43.54 65.36,42.24 64.28,42.24 63.69,41.64 63.69,40.68 63.79,40.58 63.95,40.43 63.95,37.76 62.77,36.58 62.77,35.66 v10(62.74,35.62)
  GND5 w0.104: v5(80.32,65.16) 80.32,65.54 v6(80.42,65.64)
  BOTTOM w0.104: v10(62.74,35.62) 60.18,35.62 60.03,35.47 UD9.E3
  BOTTOM w0.122: UCPU1.AL4 v6(80.42,65.64)
DDR_B_D1: length 60.8
  IN4 w0.071: v5(82.99,65.36) 83.49,65.36 85.27,63.57 85.27,51.49 81.6,47.82 81.42,47.82 81.09,48.14 80.72,48.14 80.46,47.88 80.46,47.5 80.78,47.18 80.78,47 80.65,46.88 80.48,46.88 80.16,47.19 79.72,47.19 79.19,46.65 79.19,46.28 79.58,45.89 79.58,45.79 79.4,45.61 79.25,45.61 78.83,46.04 78.62,46.04 78.27,45.69 78.27,45.32 78.59,44.99 78.59,44.82 78.46,44.68 78.28,44.68 77.88,45.07 77.61,45.07 77.22,44.68 77.22,44.36 77.4,44.18 77.4,44.08 77.32,44.01 73.91,44.01 73.68,43.78 66.57,43.78 65.26,42.47 64.19,42.47 63.46,41.74 63.46,40.58 63.62,40.41 63.71,40.33 63.71,37.86 62.47,36.61 62.16,36.61 61.93,36.39 61.93,35.52 61.78,35.37 59.7,35.37 59.56,35.51 58.14,35.51 57.61,34.99 56.85,34.99 56.42,35.42 v10(56.42,35.67)
  GND5 w0.104: v5(82.99,65.36) 82.86,65.23 v6(82.56,65.23)
  BOTTOM w0.104: UD9.E7 56.81,35.28 v10(56.42,35.67)
  BOTTOM w0.122: v6(82.56,65.23) 82.56,65.24 82.55,65.23 UCPU1.AL1
DDR_B_D2: length 60.7
  IN4 w0.071: v10(61.4,39.03) 61.45,39.03 62.14,39.71 62.14,40.09 61.93,40.3 61.93,41.88 63.7,43.65 64.78,43.65 66.09,44.97 73.21,44.97 73.42,45.19 74.09,45.19 74.33,45.43 74.33,45.75 74.55,45.96 76.89,48.31 77.78,49.2 78.53,49.2 79.18,48.55 79.41,48.55 80.04,49.19 80.04,49.49 80.3,49.75 80.65,49.75 81.06,49.34 81.46,49.34 82.3,50.18 82.3,50.43 81.39,51.35 81.39,51.53 81.79,51.93 81.95,51.93 82.91,50.97 83.09,50.97 83.55,51.43 83.55,51.6 82.61,52.54 82.61,52.72 82.74,52.84 82.91,52.84 83.67,52.08 83.84,52.08 84.1,52.34 84.1,53.19 83.98,53.3 83.73,53.3 83.61,53.42 83.52,53.51 83.52,53.63 83.61,53.72 84,53.72 84.1,53.83 84.1,54.08 84.01,54.16 83.81,54.16 83.73,54.25 83.73,54.5 83.81,54.58 84.01,54.58 84.1,54.67 84.1,54.92 84.01,55 83.81,55 83.73,55.08 83.73,55.34 83.81,55.42 84.01,55.42 84.1,55.5 84.1,55.76 84.01,55.84 83.81,55.84 83.73,55.92 83.73,56.17 83.81,56.26 84.01,56.26 84.1,56.34 84.1,56.59 84.01,56.68 83.81,56.68 83.73,56.76 83.73,57.01 83.81,57.1 84.01,57.1 84.1,57.18 84.1,57.43 84.01,57.52 83.81,57.52 83.73,57.6 83.73,57.85 83.81,57.93 84.01,57.93 84.1,58.02 84.1,58.27 84.01,58.35 83.81,58.35 83.73,58.44 83.73,58.69 83.81,58.77 84.01,58.77 84.1,58.86 84.1,59.11 84.01,59.19 83.81,59.19 83.73,59.28 83.73,59.53 83.81,59.61 83.99,59.61 84.08,59.7 84.08,59.83 83.9,60.01 83.82,60.01 83.71,60.11 83.71,61.22 83.8,61.3 83.98,61.3 84.08,61.4 84.08,61.63 83.98,61.73 83.82,61.73 83.71,61.84 83.71,62.06 83.82,62.17 83.99,62.17 84.1,62.27 84.1,62.5 83.99,62.6 83.82,62.6 83.71,62.7 83.71,62.93 83.9,63.12 83.9,63.27 83.01,64.16 v5(81.45,64.16)
  GND5 w0.104: v6(81.7,63.79) 81.7,63.79 81.45,64.04 v5(81.45,64.16)
  BOTTOM w0.104: v10(61.4,39.03) 61.65,39.03 61.98,38.7 61.98,37.4 61.83,37.25 61.19,37.25 UD9.C2
  BOTTOM w0.122: UCPU1.AN3 v6(81.7,63.79)
DDR_B_D3: length 60.1
  IN4 w0.071: v10(59.64,38.07) 59.64,38.26 60.1,38.72 60.36,38.72 60.49,38.86 60.49,39.15 60.39,39.26 60.28,39.26 60.18,39.36 60.18,39.61 60.28,39.71 60.39,39.71 60.49,39.81 60.49,40.04 60.39,40.14 60.26,40.14 60.16,40.25 60.16,40.47 60.26,40.58 60.39,40.58 60.49,40.68 60.49,40.82 61.18,41.51 61.18,42.14 63.4,44.36 64.48,44.36 65.8,45.68 66.52,45.68 66.61,45.76 66.61,45.86 66.71,45.96 66.93,45.96 67.03,45.86 67.03,45.76 67.11,45.68 67.36,45.68 67.45,45.76 67.45,46.03 67.53,46.11 67.78,46.11 67.87,46.03 67.87,45.76 67.95,45.68 68.2,45.68 68.29,45.76 68.29,46.03 68.37,46.11 68.62,46.11 68.7,46.03 68.7,45.76 68.79,45.68 69.04,45.68 69.12,45.76 69.12,46.03 69.21,46.11 69.46,46.11 69.54,46.03 69.54,45.76 69.63,45.68 69.88,45.68 69.96,45.76 69.96,46.03 70.05,46.11 70.3,46.11 70.38,46.03 70.38,45.76 70.46,45.68 70.72,45.68 70.8,45.76 70.8,46.03 70.88,46.11 71.13,46.11 71.22,46.03 71.22,45.76 71.3,45.68 71.55,45.68 71.64,45.76 71.64,46.03 71.72,46.11 71.97,46.11 72.06,46.03 72.06,45.78 72.16,45.68 72.42,45.68 72.52,45.78 72.52,46.32 73.81,47.6 73.95,47.6 74.12,47.44 74.12,47.3 72.96,46.14 72.96,46.01 73.07,45.9 73.32,45.9 78.52,51.1 79.13,51.1 79.23,51.21 79.23,51.63 79.33,51.73 79.99,51.73 80.09,51.63 80.09,51.19 80.19,51.09 80.48,51.09 80.59,51.19 80.59,51.73 81.95,53.09 81.95,53.25 81.78,53.42 81.78,53.56 81.88,53.66 82.07,53.66 82.18,53.76 82.18,53.99 82.07,54.09 81.87,54.09 81.77,54.19 81.77,54.42 81.87,54.52 82.05,54.52 82.15,54.62 82.15,54.85 82.05,54.95 81.87,54.95 81.77,55.05 81.77,55.28 81.87,55.38 82.05,55.38 82.15,55.49 82.15,55.66 82.25,55.77 82.48,55.77 82.58,55.66 82.58,54.15 82.68,54.05 82.9,54.05 83.01,54.15 83.01,62.77 82.35,63.42 v5(80.78,63.42)
  GND5 w0.104: v5(80.78,63.42) 80.73,63.42 80.46,63.7 v6(80.39,63.7)
  BOTTOM w0.104: UD9.B3 v10(59.64,38.07)
  BOTTOM w0.122: UCPU1.AR4 v6(80.39,63.7)
DDR_B_D4: length 62
  IN4 w0.071: v5(80.75,66) 80.95,65.8 82.63,65.8 82.76,65.93 83.58,65.93 85.75,63.77 85.75,51.29 78.9,44.44 78.06,43.61 77.99,43.61 77.92,43.53 74.11,43.53 73.88,43.31 66.77,43.31 65.4,41.94 65.4,41.32 64.72,40.63 64.61,40.63 64.18,40.2 64.18,37.64 63.16,36.61 63.16,36.05 63.16,35.46 62.18,34.48 59.29,34.48 59.1,34.67 58.16,34.67 57.87,34.38 57.13,34.38 56.01,35.49 56.01,36.08 55.99,36.11 55.99,36.87 v10(56.42,37.31)
  GND5 w0.104: v5(80.75,66) 80.79,66 81.08,65.71 v6(81.1,65.71)
  BOTTOM w0.104: v10(56.42,37.31) 56.83,36.9 UD9.C7
  BOTTOM w0.122: UCPU1.AK4 80.82,65.99 v6(81.1,65.71)
DDR_B_D5: length 61.6
  IN4 w0.071: v5(81.38,66.13) 82.63,66.13 82.67,66.17 83.68,66.17 85.98,63.86 85.98,51.19 78.16,43.37 78.09,43.37 78.01,43.3 74.2,43.3 73.98,43.07 66.86,43.07 65.64,41.84 65.64,41.22 64.82,40.4 64.71,40.4 64.42,40.1 64.42,37.54 63.39,36.51 63.39,36.15 63.39,35.37 61.92,33.89 60.92,33.89 60.16,33.13 57.69,33.13 56.06,34.76 56.06,35.09 55.57,35.58 v10(55.57,35.69)
  GND5 w0.104: v6(81.21,66.51) 81.21,66.41 81.38,66.24 v5(81.38,66.13)
  BOTTOM w0.104: UD9.E8 55.98,35.28 v10(55.57,35.69)
  BOTTOM w0.122: v6(81.21,66.51) 81.38,66.35 UCPU1.AK3
DDR_B_D6: length 60.2
  IN4 w0.071: v5(80.8,64.07) 81.12,63.75 83.08,63.75 83.48,63.36 83.48,53.95 83.19,53.67 83.19,53.51 83.86,52.84 83.86,52.55 83.77,52.45 83.64,52.45 82.9,53.19 82.72,53.19 82.27,52.73 82.27,52.55 83.21,51.61 83.21,51.44 83.08,51.31 82.9,51.31 81.98,52.24 81.76,52.24 81.06,51.53 81.06,51.34 82.02,50.38 82.02,50.24 81.36,49.58 81.16,49.58 80.75,49.98 80.2,49.98 79.81,49.59 79.81,49.28 79.38,48.86 79.21,48.86 78.63,49.44 77.69,49.44 76.73,48.48 74.38,46.13 74.09,45.84 74.09,45.53 73.99,45.42 73.32,45.42 73.11,45.21 66,45.21 64.68,43.89 63.6,43.89 61.65,41.94 61.65,41.31 60.97,40.63 60.97,40.02 61.12,39.87 61.27,39.87 61.37,39.76 61.37,39.56 61.27,39.46 61.12,39.46 60.97,39.31 60.97,38.47 61.15,38.29 61.7,38.29 61.83,38.42 61.83,39.07 62.29,39.54 62.43,39.54 62.53,39.43 62.53,38.43 v10(62.44,38.34)
  GND5 w0.104: v6(81.07,63.73) 81.07,63.74 80.8,64.01 v5(80.8,64.07)
  BOTTOM w0.104: v10(62.44,38.34) 62.68,38.1 62.68,36.86 62.43,36.6 61.91,36.6 61.84,36.53 61.28,36.53 UD9.D2
  BOTTOM w0.122: UCPU1.AN4 80.79,64.01 v6(81.07,63.73)
DDR_B_D7: length 59.8
  IN4 w0.071: v5(82.94,63.43) 83.07,63.43 83.24,63.26 83.24,54.05 80.82,51.63 80.82,51.24 81.08,50.98 81.08,50.86 80.99,50.77 80.99,50.68 81.18,50.49 81.32,50.49 81.37,50.54 81.51,50.54 81.67,50.38 81.67,50.23 81.32,49.89 81.18,49.89 80.63,50.43 80.5,50.43 80.29,50.22 80.1,50.22 79.82,49.94 79.67,49.94 79.52,50.09 79.52,50.24 79.68,50.4 79.68,50.54 79.52,50.7 79.37,50.7 79.23,50.56 79.08,50.56 78.77,50.87 78.62,50.87 78.17,50.42 78.17,50.27 78.35,50.1 78.49,50.1 78.59,50.2 78.8,50.2 79.51,49.49 79.51,49.34 79.36,49.19 79.21,49.19 78.73,49.68 78.16,49.68 77.88,49.95 77.7,49.95 73.86,46.1 73.86,45.79 73.72,45.66 73.23,45.66 73.01,45.44 65.9,45.44 64.58,44.12 63.5,44.12 61.42,42.04 61.42,41.41 60.73,40.73 60.73,38.59 60.61,38.47 60.24,38.47 60.07,38.3 60.07,37.95 59.6,37.48 59.6,36.97 59.7,36.87 59.7,36.49 59.6,36.39 59.34,36.39 59.24,36.49 59.24,36.66 59.14,36.77 58.91,36.77 58.81,36.66 58.81,36.41 58.71,36.31 58.43,36.31 58.33,36.41 58.33,36.79 58.22,36.89 57.97,36.89 57.84,37.02 57.64,37.02 57.54,36.92 57.54,35.92 57.61,35.85 57.61,35.39 57.51,35.29 56.93,35.29 56.83,35.39 56.83,36.36 56.73,36.46 v10(56.42,36.46)
  GND5 w0.104: v5(82.94,63.43) 82.94,63.41 82.69,63.17 v6(82.69,63.06)
  BOTTOM w0.104: UD9.C8 56.03,36.85 v10(56.42,36.46)
  BOTTOM w0.122: v6(82.69,63.06) 82.69,63.07 82.51,63.25 UCPU1.AR1
DDR_B_D8: length 44.7
  TOP w0.076: v10(58.59,37.76) 58.73,37.62 58.73,37.6 59.7,36.63 59.7,35.93 59.95,35.67 60.08,35.67 60.47,35.28 60.82,35.28 UD10.E8
  IN4 w0.071: v10(58.59,37.76) 58.59,38.02 58.06,38.56 58.06,39.72 60.21,41.88 60.21,42.51 63.01,45.3 64.09,45.3 65.85,47.06 71.85,47.06 73.34,48.55 74.62,48.55 78.76,52.69 80.21,52.69 80.82,53.3 80.82,55.69 82.06,56.93 82.06,61.19 81.54,61.71 v5(81.49,61.71)
  GND5 w0.104: v5(81.49,61.71) 81.46,61.73 v6(81.08,61.73)
  BOTTOM w0.122: UCPU1.AU4 80.78,62.04 v6(81.08,61.73)
DDR_B_D9: length 44.4
  TOP w0.104: UD10.C8 61.25,37.3 61.25,38.54 60.94,38.85 59.65,38.85 v10(59.53,38.74)
  IN4 w0.071: v5(82.46,62.32) 82.77,62 82.77,56.64 81.53,55.4 81.53,53.01 80.51,51.98 79.07,51.98 74.93,47.84 73.64,47.84 72.14,46.35 66.14,46.35 64.38,44.59 63.31,44.59 60.92,42.21 60.92,41.59 59.35,40.01 59.35,39.86 59.44,39.76 59.75,39.76 59.93,39.59 59.93,39.13 v10(59.53,38.74)
  GND5 w0.104: v6(82.13,62.61) 82.13,62.61 82.42,62.32 v5(82.46,62.32)
  BOTTOM w0.122: v6(82.13,62.61) 82.04,62.7 UCPU1.AT2
DDR_B_D10: length 42.3
  TOP w0.104: v10(54.57,38.54) 54.85,38.27 54.85,37.4 54.97,37.27 55.63,37.27 UD10.C2
  IN4 w0.071: v5(80.31,61.56) 80.5,61.37 80.5,60.54 80.33,60.37 80.33,60.13 80.12,59.92 80.12,57.67 78.88,56.43 78.88,55.58 74.46,51.17 73.27,51.17 71.06,48.96 64,48.96 57.27,42.23 57.07,42.23 55.9,41.06 55.9,40.19 54.57,38.85 v10(54.57,38.54)
  GND5 w0.104: v6(80.38,61.14) 80.33,61.18 80.33,61.54 v5(80.31,61.56)
  BOTTOM w0.122: UCPU1.AV4 80.62,61.38 v6(80.38,61.14)
DDR_B_D11: length 42.6
  TOP w0.104: v10(54.36,37.96) 54.11,37.71 54.11,36.66 54.31,36.46 55.64,36.46 UD10.D2
  IN4 w0.071: v5(80.42,59.8) 80.41,59.79 80.41,57.62 79.11,56.32 79.11,55.49 74.55,50.92 73.36,50.92 71.16,48.72 64.1,48.72 58.54,43.17 58.54,42.55 57.59,41.61 56.78,41.61 56.14,40.97 56.14,40.09 55.02,38.97 55.02,38.36 54.62,37.96 v10(54.36,37.96)
  GND5 w0.104: v5(80.42,59.8) 80.74,59.49 v6(80.74,59.46)
  BOTTOM w0.122: UCPU1.BA4 v6(80.74,59.46)
DDR_B_D12: length 43.5
  TOP w0.104: UD10.C7 60.02,36.9 59.09,37.83 59.09,38.14 58.6,38.62 v10(58.59,38.62)
  IN4 w0.071: v10(58.59,38.62) 58.73,38.62 58.88,38.77 58.88,40.21 60.45,41.78 60.45,42.41 63.11,45.07 64.19,45.07 65.95,46.83 71.95,46.83 73.44,48.32 74.73,48.32 78.87,52.46 80.31,52.46 81.06,53.2 81.06,55.59 82.3,56.83 82.3,61.36 82.23,61.43 82.23,61.44 81.66,62.01 v5(80.78,62.01)
  GND5 w0.104: v6(81.01,62.4) 81.01,62.24 80.78,62.01 v5(80.78,62.01)
  BOTTOM w0.122: v6(81.01,62.4) 81.26,62.14 UCPU1.AU3
