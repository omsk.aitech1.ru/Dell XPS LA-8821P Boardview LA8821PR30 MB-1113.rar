# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CLK_DDR#2: length 171.1
  TOP w0.076: v10(36.32,33.7) 36.52,33.9 36.77,33.9 37.07,34.2 37.31,34.2 37.52,34 37.8,34 37.93,33.87 UD14.G7 ; v10(58.42,33.7) 58.62,33.9 58.87,33.9 59.17,34.2 59.41,34.2 59.62,34 59.9,34 60.02,33.87 UD10.G7 ; UD16.G7 26.88,33.87 26.75,34 26.47,34 26.27,34.2 26.02,34.2 25.72,33.9 25.47,33.9 v10(25.27,33.7) ; v10(47.37,33.7) 47.57,33.9 47.82,33.9 48.12,34.2 48.36,34.2 48.57,34 48.85,34 48.98,33.87 UD12.G7
  IN1 w0.091: v8(65.44,33.68) 65.17,33.95 64.54,33.95 64.28,34.2 64.28,35.65 64.15,35.78 63.76,35.78 63.63,35.65 63.63,34.05 64.42,33.26 64.42,32.91 64.17,32.65 63.56,32.65 62.25,33.96 58.68,33.96 v10(58.42,33.7) 58.22,33.91 58.05,33.91 57.85,34.1 57.26,34.1 56.1,32.94 54.66,32.94 54.35,32.64 53.92,32.64 53.66,32.9 53.66,33.69 53.54,33.82 53.25,33.82 53.12,33.69 53.12,32.74 52.87,32.49 52.32,32.49 52.05,32.75 52.05,33.11 51.91,33.25 51.59,33.25 51.46,33.13 51.46,32.9 51.21,32.64 49.53,32.64 48.2,33.97 47.64,33.97 v10(47.37,33.7) 47.16,33.91 47.01,33.91 46.8,34.13 46.01,34.13 44.88,33 43.55,33 43.49,33.06 42.07,34.48 41.83,34.72 41.83,37.43 41.7,37.55 41.35,37.55 41.22,37.43 41.22,34.49 40.91,34.19 40.58,34.19 40.47,34.07 40.47,33.22 39.9,32.65 37.7,32.65 37.39,32.97 37.39,33.32 37.41,33.35 37.41,33.71 37.16,33.96 36.58,33.96 v10(36.32,33.7) 36.11,33.92 35.93,33.92 35.72,34.13 35.19,34.13 34.34,33.27 32.89,33.27 32.26,32.64 31.82,32.64 31.57,32.9 31.57,33.72 31.44,33.85 31.15,33.85 31.02,33.72 31.02,32.74 30.77,32.49 30.23,32.49 29.95,32.77 29.95,33.12 29.82,33.25 29.49,33.25 29.36,33.13 29.36,32.9 29.11,32.64 27.43,32.64 26.15,33.92 25.49,33.92 v10(25.27,33.7) 25.1,33.7 24.68,34.13 23.51,34.13 22.84,33.46 20.61,33.46 20.29,33.78 19.67,33.78 v7(19.47,33.58)
  IN2 w0.122: v10(65.51,60.72) 65.51,60.71 65.3,60.51 64.94,60.51 64.64,60.21 64.64,59.62 64.55,59.52 64.55,58.53 64.88,58.2 64.88,57.76 64.35,57.22 64.35,56.73 65.08,55.99 65.08,54.85 64.32,54.09 51.56,54.09 51.32,53.84 51.32,50.02 51.56,49.77 52.1,49.77 52.36,50.03 52.36,52.92 52.48,53.05 53.07,53.05 53.22,52.9 53.22,51.37 53.88,50.71 53.88,49.72 54.19,49.42 54.69,49.42 54.82,49.29 54.82,48.96 54.69,48.83 53.06,48.83 52.81,48.59 52.81,47.44 52.6,47.23 49.99,47.23 49.74,46.99 49.74,46.44 49.99,46.19 53.75,46.19 53.88,46.06 53.88,45.68 53.75,45.55 49.91,45.55 49.64,45.28 49.64,44.77 49.91,44.5 63.64,44.5 65.59,42.54 65.59,42.54 65.92,42.22 65.92,41.28 65.81,41.17 65.81,39 65.29,38.48 65.29,37.59 64.34,36.64 64.34,34.18 64.63,33.89 65.24,33.89 65.44,33.68 v8(65.44,33.68)
  BOTTOM w0.076: UD13.G7 34.73,33.68 34.73,33.84 34.87,33.99 35.16,33.99 35.37,34.2 35.67,34.2 35.95,33.92 36.1,33.92 v10(36.32,33.7) ; UD9.G7 56.83,33.84 56.82,33.84 56.97,33.99 57.25,33.99 57.47,34.2 57.76,34.2 58.05,33.92 58.2,33.92 v10(58.42,33.7) ; UD11.G7 45.78,33.68 45.78,33.84 45.92,33.99 46.2,33.99 46.42,34.2 46.72,34.2 47,33.92 47.15,33.92 v10(47.37,33.7) ; UD15.G7 23.68,33.68 23.68,33.84 23.82,33.99 24.11,33.99 24.32,34.2 24.62,34.2 24.9,33.92 25.05,33.92 v10(25.27,33.7)
  BOTTOM w0.16: CD122.2 66.17,33.65 65.93,33.9 65.64,33.9 65.44,33.7 v8(65.44,33.68) ; v10(65.51,60.72) 65.64,60.59 65.88,60.59 66,60.72 UCPU1.AY34 ; v7(19.47,33.58) 19.29,33.77 18.98,33.77 18.65,34.1 17.91,34.1 RD38.1
M_ODT0: length 184.6
  TOP w0.076: v10(96.15,30.83) 96.15,30.83 95.31,29.99 95.31,29.4 94.73,28.82 94.73,28.47 94.55,28.29 93.28,28.29 92.97,28.6 UD4.G1 ; v10(107.2,30.83) 106.36,29.99 106.36,29.4 105.78,28.82 105.78,28.47 105.59,28.29 104.33,28.29 104.02,28.6 UD2.G1 ; v10(74.05,30.83) 74.05,30.83 73.21,29.99 73.21,29.4 72.63,28.82 72.63,28.47 72.45,28.29 71.19,28.29 70.88,28.6 UD8.G1 ; UD6.G1 81.92,28.6 82.24,28.29 83.5,28.29 83.68,28.47 83.68,28.82 84.26,29.4 84.26,29.99 v10(85.1,30.83)
  TOP w0.188: v2(113.55,34.47) RD33.1
  GND1 w0.102: v3(114,34.48) 113.99,34.47 v2(113.55,34.47)
  IN1 w0.147: v4(113.44,34.4) 113.52,34.48 v3(114,34.48)
  IN2 w0.14: v4(113.44,34.4) 113.34,34.4 112.24,33.31 112.24,31.35 111.52,30.62 110.06,30.62 109.7,30.27 108.37,30.27 108.13,30.51 107.52,30.51 v10(107.2,30.83) 107.2,31.01 106.61,31.6 105.42,31.6 105.23,31.79 103.95,31.79 103.44,32.3 101.94,32.3 101.81,32.17 101.81,30.98 101.68,30.86 101.33,30.86 101.2,30.98 101.2,31.94 101.07,32.07 100.74,32.07 100.62,31.94 100.62,31 99.96,30.34 97.02,30.34 96.88,30.49 96.49,30.49 v10(96.15,30.83) 96.08,30.9 96.08,31.21 95.82,31.47 94.5,31.47 94.18,31.79 92.78,31.79 92.04,32.52 91.55,32.52 90.89,33.19 90.89,35.1 90.76,35.23 90.35,35.23 90.23,35.1 90.23,33.3 90.1,33.17 89.62,33.17 89.49,33.3 89.49,34.42 89.36,34.55 88.69,34.55 88.17,34.03 88.17,30.84 87.81,30.48 85.45,30.48 v10(85.1,30.83) 85.1,30.98 84.63,31.45 83.48,31.45 83.14,31.79 81.85,31.79 81.34,32.3 79.84,32.3 79.71,32.17 79.71,30.98 79.59,30.85 79.15,30.85 79.03,30.98 79.03,32.14 78.9,32.27 78.47,32.27 78.34,32.14 78.34,30.84 77.89,30.39 76.4,30.39 76.39,30.39 75.03,30.39 74.93,30.5 74.39,30.5 v10(74.05,30.83) 74.05,31.03 73.55,31.53 73.17,31.53 72.92,31.78 72.53,31.78 72.53,31.79 71.51,31.79 71.36,31.94 71.36,32.52 71.51,32.68 72.14,32.68 72.27,32.8 72.27,33.39 72.4,33.52 73.51,33.52 73.64,33.64 73.64,34.1 73.77,34.23 76.49,34.23 76.61,34.35 76.61,35.27 76.74,35.39 80.47,35.39 80.6,35.52 80.6,38.19 80.47,38.32 78.14,38.32 78.01,38.19 78.01,37.35 77.88,37.22 71.56,37.22 71.43,37.1 71.43,36.82 71.3,36.7 70.54,36.7 70.42,36.82 70.42,37.33 70.29,37.45 69.98,37.45 69.86,37.33 69.86,37.02 69.58,36.74 69.07,36.74 68.43,36.11 66.66,36.11 66.5,36.26 66.5,36.26 66.45,36.31 v4(66.45,36.31)
  IN3 w0.14: v4(66.45,36.31) 66.45,36.36 66.45,36.37 66.45,36.47 65.84,37.07 65.84,40.32 66.02,40.5 66.02,41.74 64.98,42.79 64.04,42.79 64.03,42.78 63.15,42.78 62.85,42.48 62.85,42.12 62.7,41.97 62.05,41.97 61.91,41.83 61.91,41.1 61.76,40.96 61.18,40.96 60.57,40.35 60.31,40.35 60.03,40.63 59.27,40.63 58.99,40.91 58.99,42.15 58.88,42.25 57.99,42.25 57.84,42.11 57.84,41.77 57.7,41.62 57.33,41.62 57.18,41.77 57.18,44.33 57.28,44.43 58.16,44.43 58.91,44.43 59.02,44.54 59.02,45.49 59.11,45.59 60.15,45.59 60.25,45.69 60.25,46.8 60.1,46.95 59.72,46.95 59.57,47.1 59.57,48.12 59.04,48.66 59.04,49.77 59.52,50.25 60.62,50.25 60.76,50.4 60.76,51.26 60.62,51.4 60.15,51.4 60,51.54 60,51.81 60.15,51.96 60.62,51.96 60.76,52.1 60.76,56.88 61.53,57.65 61.53,57.98 61.07,58.43 61.07,58.74 61.37,59.04 61.74,59.04 62.87,60.17 62.87,60.81 v4(63.07,61)
  IN4 w0.104: v4(63.07,61) 63,60.93 v5(63,60.52)
  GND5 w0.102: v6(63.57,60.63) 63.46,60.52 v5(63,60.52)
  BOTTOM w0.076: UD1.G1 109.93,28.6 109.56,28.97 108.4,28.97 108.18,29.2 108.18,30.22 107.8,30.59 107.65,30.59 107.62,30.62 107.4,30.62 107.2,30.83 v10(107.2,30.83) ; v10(96.15,30.83) 96.15,30.83 96.35,30.62 96.58,30.62 96.6,30.59 96.76,30.59 97.13,30.22 97.13,29.2 97.36,28.97 98.51,28.97 98.88,28.6 UD3.G1 ; UD5.G1 87.83,28.6 87.46,28.97 86.31,28.97 86.08,29.2 86.08,30.22 85.71,30.59 85.55,30.59 85.53,30.62 85.3,30.62 85.1,30.83 v10(85.1,30.83) ; UD7.G1 76.78,28.6 76.41,28.97 75.26,28.97 75.03,29.2 75.03,30.22 74.66,30.59 74.5,30.59 74.48,30.62 74.26,30.62 74.05,30.83 v10(74.05,30.83)
  BOTTOM w0.188: UCPU1.AY40 63.18,60.82 63.37,60.63 v6(63.57,60.63)
M_ODT2: length 191.6
  TOP w0.076: UD14.G1 33.28,33.68 33.59,33.37 34.86,33.37 35.04,33.55 35.04,33.9 35.62,34.48 35.62,35.07 36.46,35.91 v10(36.46,35.91) ; v10(47.51,35.91) 46.67,35.07 46.67,34.48 46.09,33.9 46.09,33.55 45.9,33.37 44.64,33.37 44.33,33.68 UD12.G1 ; v10(58.56,35.91) 58.56,35.91 57.72,35.07 57.72,34.48 57.14,33.9 57.14,33.55 56.95,33.37 55.69,33.37 55.38,33.68 UD10.G1 ; UD16.G1 22.23,33.68 22.55,33.37 23.81,33.37 23.99,33.55 23.99,33.9 24.57,34.48 24.57,35.07 v10(25.41,35.91)
  TOP w0.188: RD34.1 17.83,39.84 v7(18.65,39.02)
  IN2 w0.14: v4(64.12,41.34) 63.91,41.55 63.91,42.11 63.01,43.01 54.76,43.01 53.97,42.22 53.25,42.22 52.46,43.01 51.01,43.01 50.4,42.4 46.97,42.4 46.74,42.63 46.74,43.73 46.49,43.98 45.36,43.98 45.22,43.84 45.22,43.13 45.08,42.99 44.8,42.99 44.66,43.13 44.66,43.84 44.52,43.98 42.87,43.98 42.73,43.84 42.73,42.88 42.59,42.74 42.31,42.74 42.17,42.88 42.17,43.84 42.03,43.98 41.75,43.98 41.61,43.84 41.61,42.88 41.47,42.74 41.19,42.74 41.05,42.88 41.05,43.84 40.91,43.98 40.73,43.98 40.26,44.44 40.26,45.22 40.7,45.66 47.97,45.66 48.26,45.96 48.26,47.42 48.61,47.77 48.61,54.02 50.05,55.45 61.04,55.45 63.15,57.57 63.15,58.34 63.17,58.36 63.17,59.55 63.02,59.7 63.02,60.39 62.13,61.28 62.13,62.32 61.93,62.52 v4(61.63,62.52)
  IN3 w0.14: v4(64.12,41.34) 64.02,41.34 63.58,40.91 63.58,40.4 63.62,40.36 63.62,39.5 62.92,38.79 62.92,37.93 62.8,37.81 62.44,37.81 61.17,36.54 61.17,33.79 61.04,33.67 60.66,33.67 60.54,33.79 60.54,35.9 60.41,36.03 60.05,36.03 59.93,35.9 59.93,34.7 59.8,34.57 59.47,34.57 59.34,34.7 59.34,35.34 59.21,35.47 59,35.47 v10(58.56,35.91) 58.56,36.07 58.13,36.5 56.96,36.5 56.57,36.89 55.29,36.89 54.8,37.38 53.3,37.38 53.17,37.25 53.17,36.06 53.04,35.93 52.61,35.93 52.48,36.06 52.48,37.22 52.36,37.35 51.92,37.35 51.8,37.22 51.8,35.92 51.65,35.77 48.83,35.77 48.58,35.52 47.9,35.52 v10(47.51,35.91) 47.51,36.13 47.09,36.55 45.86,36.55 45.54,36.87 44.26,36.87 43.53,37.6 42.86,37.6 42.25,38.21 42.25,40.17 42.12,40.3 41.71,40.3 41.59,40.17 41.59,38.77 41.46,38.65 41.03,38.65 40.9,38.77 40.9,39.71 40.77,39.84 39.65,39.84 39.53,39.71 39.53,35.8 39.15,35.42 37.5,35.42 37.39,35.53 36.84,35.53 v10(36.46,35.91) 36.46,36.04 35.94,36.56 34.81,36.56 34.49,36.87 33.21,36.87 32.7,37.38 31.2,37.38 31.07,37.25 31.07,36.06 30.94,35.93 30.51,35.93 30.39,36.06 30.39,37.22 30.26,37.35 29.83,37.35 29.7,37.22 29.7,35.92 29.3,35.52 25.79,35.52 25.41,35.91 v10(25.41,35.91) 25.41,36.03 24.91,36.53 24.59,36.53 24.25,36.86 23.89,36.86 23.89,36.87 22.59,36.87 21.95,37.5 20.28,37.5 18.76,39.02 v7(18.65,39.02)
  IN4 w0.104: v4(61.63,62.52) 62.01,62.52 v5(62.39,62.9)
  GND5 w0.102: v5(62.39,62.9) 62.39,62.9 62.18,62.69 v6(62.18,62.52)
  BOTTOM w0.076: UD11.G1 50.21,34.05 48.71,34.05 48.49,34.28 48.49,35.3 48.11,35.67 47.96,35.67 47.93,35.7 47.71,35.7 47.51,35.91 v10(47.51,35.91) ; UD9.G1 61.44,33.68 61.37,33.75 61.37,33.94 61.26,34.05 59.76,34.05 59.53,34.28 59.53,35.3 59.16,35.67 59.01,35.67 58.98,35.7 58.67,35.7 58.55,35.81 58.55,35.91 v10(58.56,35.91) ; v10(25.41,35.91) 25.41,35.91 25.61,35.7 25.84,35.7 25.86,35.67 26.02,35.67 26.39,35.3 26.39,34.28 26.62,34.05 27.77,34.05 28.14,33.68 UD15.G1 ; UD13.G1 39.19,33.68 38.82,34.05 37.67,34.05 37.44,34.28 37.44,35.3 37.07,35.67 36.91,35.67 36.89,35.7 36.66,35.7 36.46,35.91 v10(36.46,35.91)
  BOTTOM w0.188: UCPU1.AT43 v6(62.18,62.52)
MAG_DRDY: length 39.4
  TOP w0.076: U636.E5 160.05,64.27 160.3,64.02 160.3,63.72 160.44,63.57 160.65,63.57 160.8,63.42 160.8,62.72 160.94,62.57 161.15,62.57 161.15,62.57 161.72,62.57 161.83,62.46
  TOP w0.122: v2(152.83,64.16) 152.99,64 152.99,62.17 153.26,61.9 153.26,59.09 152.25,58.09 150.59,58.09 150.01,57.51 150.01,55.12 150.5,54.62 150.5,52.7 150.12,52.33 v1(150.12,49.43) 150.57,48.98 151.92,48.98 152.29,49.35 U637.9 ; 161.83,62.46 161.97,62.32 v2(161.97,62.27)
  GND1 w0.104: v3(152.78,64.64) 152.83,64.59 v2(152.83,64.16) ; v2(161.97,62.27) v3(162.44,62.27)
  IN1 w0.071: v3(152.78,64.64) 152.78,64.35 155.3,61.82 158.22,61.82 158.38,61.67 158.63,61.67 159.63,60.67 162.15,60.67 162.74,61.26 162.74,61.97 v3(162.44,62.27)
MEM_CHA_EN: length 12.3
  BOTTOM w0.122: v1(126.56,72.71) 125.48,72.71 124.62,73.57 RH339.2 124.24,74.23 123.86,73.85 RH298.1 123.04,74.36 121.91,74.36 121.46,74.81 119.7,74.81 119.61,74.9 119.16,74.9 118.02,73.76 UH1.B44
MEM_CHB_EN: length 33.4
  TOP w0.122: v7(100.05,51.79) 98.1,51.79 97.53,51.22 97.53,44.83 95.79,43.09 RH338.2 ; RH197.1 109.04,52.52 109.04,53.3 108.98,53.36 108.98,55.27 109.33,55.63 v1(109.33,56.17) 109.33,57.06 v2(109.4,57.14)
  GND1 w0.104: v2(109.4,57.14) v3(109.81,57.14)
  IN1 w0.071: v4(109.43,57.47) 109.48,57.47 v3(109.81,57.14)
  IN3 w0.094: v4(109.43,57.47) 108.03,57.47 107.37,56.81 107.37,55.18 106.59,54.39 106.59,53.27 105.31,51.99 102.97,51.99 101.85,50.86 100.97,50.86 v7(100.05,51.79)
  IN4 w0.071: v4(109.43,57.47) 109.28,57.31 v5(109.28,56.98)
  GND5 w0.104: v6(109.28,56.58) v5(109.28,56.98)
  BOTTOM w0.122: UH1.W3 v6(109.28,56.58)
MEM_CONFIG0: length 5.2
  BOTTOM w0.122: UH1.W1 109.29,56.13 109.72,55.7 109.72,55.4 109.3,54.98 v1(109.3,54.66) 109.06,54.42 109.06,53.41 109.06,52.82 109.25,52.63 RH316.2 108.89,52.34 108.85,52.38 RH303.1
MEM_CONFIG1: length 7.1
  TOP w0.122: v2(117.25,71.46) 117.49,71.7 117.53,71.7 117.67,71.84 117.75,71.84 118.13,72.22 RH315.2 118.13,72.28 118.6,72.75 119.47,72.75 120.07,73.35 RH180.1 120.1,73.32 120.61,72.82 v1(120.61,72.43)
  GND1 w0.104: v3(117.25,71.01) v2(117.25,71.46)
  IN1 w0.071: v3(117.25,71.01) 117.21,71.06 v4(116.76,71.06)
  IN4 w0.071: v5(116.73,71.54) 116.73,71.51 116.76,71.49 v4(116.76,71.06)
  GND5 w0.104: v6(116.31,71.73) 116.53,71.73 116.72,71.54 v5(116.73,71.54)
  BOTTOM w0.122: UH1.B40 v6(116.31,71.73)
MEM_CONFIG2: length 8.7
  TOP w0.122: v2(117.2,73.69) 117.67,74.16 RH271.1 118.57,74.9 120.35,74.9 RH314.2 121.45,74.26 121.96,73.75 v1(121.96,73.38)
  GND1 w0.104: v2(117.2,73.69) 117.55,74.03 v3(117.58,74.03)
  IN1 w0.071: v3(117.58,74.03) 117.3,73.75 v4(117.3,73.62)
  IN4 w0.071: v4(117.3,73.62) 117.02,73.34 v5(116.8,73.34)
  GND5 w0.104: v6(116.33,73.36) 116.34,73.34 v5(116.8,73.34)
  BOTTOM w0.122: UH1.C43 v6(116.33,73.36)
MINI1_SMBCLK: length 13.8
  TOP w0.122: JWLAN1.30 181.65,39.35 181.57,39.43 179.84,39.43 179.33,38.93 179.33,38.44 179.13,38.24 179.13,37.72 178.57,37.16 178.23,37.16 177.78,37.6 176.22,37.6 R1019.1 175.75,38.41 176.33,39 Q327.1 176.33,39.64 175.32,40.65 v1(175.32,41.21) 175.32,42.06 R724.1
MINI1_SMBDATA: length 11.1
  TOP w0.122: JWLAN1.32 181.72,40.15 181.31,39.74 179.43,39.74 v1(179.18,39.49) 179,39.31 179,38.48 R725.1 178.07,38.61 178.07,42.16 R1018.1 177.63,42.19 Q327.4
MINI1CLK_REQ#: length 88
  IN4 w0.071: v7(178.09,27.01) 177.58,27.01 175.02,29.58 175.02,31.3 174.31,32.01 174.31,38.76 173.53,39.55 173.53,42.04 171.48,44.08 171.28,44.08 168.27,47.09 167.62,47.74 158.55,47.74 158.18,47.37 147.62,47.37 145.36,49.63 135.97,49.63 135.82,49.78 133.12,49.78 131.43,51.47 129.64,51.47 129.45,51.66 127.44,51.66 126.96,51.18 123.14,51.18 122.15,50.18 120.83,50.18 120.3,50.71 v5(120.3,50.73)
  GND5 w0.104: v6(120.3,51.47) v5(120.3,50.73)
  BOTTOM w0.122: UH1.B8 116.86,59.13 117.1,58.89 117.1,58.48 117.76,57.82 117.76,55.37 120.05,53.08 RH103.1 120.3,52.85 v1(120.3,52.03) v6(120.3,51.47) ; JWLAN1.7 178.15,26.95 v7(178.09,27.01)
MSATA_DET#: length 82.9
  TOP w0.122: v2(114,61.94) 114,61.49 114.37,61.13 114.37,60.81 115.68,59.5 115.84,59.5 116.4,58.94 116.4,58.42 116.66,58.16 116.66,57.77 117.38,57.05 v2(117.38,56.85) 117.45,56.78 RH188.1 ; v7(176.16,44.77) 174.84,44.77 v1(174.68,44.62)
  GND1 w0.104: v2(114,61.94) 114.27,62.21 114.27,62.25 v3(114.27,62.25) ; v2(117.38,56.85) v3(117.96,56.85)
  IN1 w0.071: v4(113.52,62.3) 114.22,62.3 v3(114.27,62.25)
  IN1 w0.084: v4(118.42,56.51) 118.41,56.51 118.07,56.85 v3(117.96,56.85)
  IN2 w0.094: v7(176.16,44.77) 176.16,45.61 175.95,45.81 175.95,46.61 174.8,47.76 173.34,47.76 172.71,48.39 170.98,48.39 170.06,49.31 159.6,49.31 158.25,47.96 148.66,47.96 145.3,51.32 145.3,53.42 143.2,55.53 139.22,55.53 138.74,56.01 138.74,56.13 137.2,57.67 136.27,57.67 135.73,57.13 128.83,57.13 127.51,58.45 127.02,58.45 126.32,57.76 124.63,57.76 124.14,58.25 123.78,58.25 123.15,57.63 122.4,57.63 122.04,57.99 120.19,57.99 118.71,56.51 v4(118.42,56.51)
  IN4 w0.071: v5(113.13,62.61) 113.44,62.3 v4(113.52,62.3)
  GND5 w0.104: v6(113.14,63.11) 113.13,63.09 v5(113.13,62.61)
  BOTTOM w0.122: UH1.K17 113.13,63.09 v6(113.14,63.11) ; JSATA1.51 175.75,45.79 176.16,45.38 v7(176.16,44.77)
N_3V_001: length 63.3
  TOP w0.122: PD907.2 PD906.1 190.73,75.61 190.46,75.88 v2(189.49,75.88) 187.85,75.88 PD903.1 ; PD903.1 186.47,75.86 PC217.1 186.47,77.64 PR970.1 ; PD903.1 187.15,74.24 v1(186.28,73.37)
  TOP w0.254: PR957.2 202.33,55.51 PD909.1 200.12,55.51 v7(199.99,55.64)
  GND1 w0.104: v2(189.49,75.88) v3(189.49,76.38)
  IN1 w0.254: v4(189.49,76.89) v3(189.49,76.38)
  IN2 w0.254: v4(189.49,76.89) 189.49,77.18 191.12,78.8 193.81,78.8 195.38,77.23 198.94,77.23 201.28,74.89 206.29,74.89 208.77,72.42 208.77,59.68 206.31,57.21 203.08,57.21 201.62,55.75 200.11,55.75 v7(199.99,55.64)
  BOTTOM w0.254: v7(199.99,55.64) 199.84,55.64 199.51,55.97 PQ204.5
N_5V_001: length 46
  GND1 w0.254: v2(183.98,70.47) 184.2,70.69 v3(184.51,70.69)
  IN1 w0.254: v7(201.91,56.87) 201.91,53.21 201.45,52.76 193.94,52.76 193.68,52.49 191.3,52.49 188.59,55.19 184.76,55.19 182.3,57.65 182.3,65.64 185.41,68.75 185.41,69.79 v3(184.51,70.69)
  BOTTOM w0.254: PQ204.2 197.75,55.97 198.88,57.1 201.68,57.1 v7(201.91,56.87)
  vias: v1(205.66,58.99)
Net_143: length 0.5
  BOTTOM w0.254: 96.12,76.76 95.6,76.76
Net_144: length 0.5
  BOTTOM w0.254: 96.71,76.76 96.71,77.25
Net_145: length 0.5
  BOTTOM w0.254: 97.3,76.76 97.3,77.27
Net_176: length 0.5
  BOTTOM w0.254: 115.56,76.76 115.56,77.25
Net_177: length 0.5
  BOTTOM w0.254: 116.15,76.76 116.15,77.26
Net_178: length 0.2
  BOTTOM w0.254: 116.15,76.17 116.26,76.28
Net_179: length 0.5
  BOTTOM w0.254: 116.75,76.76 116.75,77.25
Net_180: length 0.5
  BOTTOM w0.254: 116.75,76.17 117.25,76.17
Net_181: length 0.3
  BOTTOM w0.254: 116.75,75.57 116.55,75.37
Net_262: length 0.5
  BOTTOM w0.254: 96.12,76.17 95.59,76.17
Net_263: length 0.5
  BOTTOM w0.254: 96.12,75.57 95.62,75.57
Net_264: length 0.2
  BOTTOM w0.254: 96.71,76.17 96.6,76.27
Net_265: length 0.2
  BOTTOM w0.254: 96.73,75.57 96.58,75.72
Net_266: length 0.6
  BOTTOM w0.254: 97.8,76.31 97.47,76.31 97.3,76.15
Net_317: length 0.6
  BOTTOM w0.254: 115.32,55.61 115.17,55.77 115.17,56.07 115.11,56.13
Net_318: length 0.6
  BOTTOM w0.254: 115.7,56.13 115.83,56 115.83,55.59
Net_319: length 0.6
  BOTTOM w0.254: 116.19,56.69 116.19,56.37 116.39,56.17
Net_320: length 0.6
  BOTTOM w0.254: 116.75,57.18 116.97,56.95 116.97,56.65
Net_349: length 0.5
  BOTTOM w0.254: 96.12,57.32 95.59,57.32
Net_350: length 0.5
  BOTTOM w0.254: 96.12,56.73 95.62,56.73
Net_351: length 0.5
  BOTTOM w0.254: 96.12,56.13 95.6,56.13
Net_352: length 0.6
  BOTTOM w0.254: 96.55,57.8 96.55,57.49 96.73,57.32
Net_353: length 0.2
  BOTTOM w0.254: 96.71,56.73 96.59,56.6
Net_354: length 0.5
  BOTTOM w0.254: 96.71,56.13 96.71,55.63
Net_355: length 0.3
  BOTTOM w0.254: 97.41,57.43 97.17,57.19
Net_356: length 0.2
  BOTTOM w0.254: 97.3,56.74 97.16,56.6
Net_357: length 0.5
  BOTTOM w0.254: 97.3,56.13 97.3,55.63
Net_384: length 0.5
  BOTTOM w0.305: 80.7,57.27 80.7,56.76
Net_385: length 0.5
  BOTTOM w0.305: 82,58.57 82.25,58.57 82.43,58.38
Net_396: length 0.7
  BOTTOM w0.305: 80.95,79.69 81.11,79.69 81.46,80.05
Net_399: length 0.4
  BOTTOM w0.305: 82,78.65 82.29,78.93
Net_504: length 0.5
  BOTTOM w0.305: 53.88,57.27 53.88,56.76
Net_505: length 0.5
  BOTTOM w0.305: 53.23,57.27 53.23,56.79
Net_506: length 0.5
  BOTTOM w0.305: 52.58,57.27 52.58,56.77
Net_507: length 0.5
  BOTTOM w0.305: 52.58,58.57 52.08,58.57
Net_508: length 0.4
  BOTTOM w0.305: 53.88,79.69 53.88,80.08
Net_510: length 0.6
  BOTTOM w0.305: 52.13,78.7 52.44,78.39 52.58,78.39
NFC_IRQ: length 12.5
  TOP w0.122: v2(114.92,58.2) 115.18,57.94 115.18,57.72 115.49,57.42 115.49,56.81 116.15,56.15 116.15,55.93 116.57,55.51 116.57,54.98 R517.1 116.9,54.67 117.36,54.21 117.36,54.13 117.36,51.31 v1(117.22,51.18) 116.58,50.53 R1100.2
  GND1 w0.104: v3(114.57,58.45) 114.68,58.45 v2(114.92,58.2)
  IN1 w0.071: v4(115.3,58.46) 114.59,58.46 v3(114.57,58.45)
  IN4 w0.071: v4(115.3,58.46) 115.3,58.84 v5(114.99,59.14)
  GND5 w0.104: v6(115.36,59.54) 115.36,59.51 v5(114.99,59.14)
  BOTTOM w0.122: UH1.C9 v6(115.36,59.54)
NTC: length 19.4
  TOP w0.254: v7(26.73,83.42) 26.7,83.42 26.75,83.47 PR727.1 ; PH702.2 25.31,71.21 v7(25.46,71.36)
  IN2 w0.254: v7(25.46,71.36) 25.46,71.46 26.02,72.02 26.02,73.39 24.04,75.37 24.04,77.48 26.3,79.74 26.3,83.01 26.7,83.42 v7(26.73,83.42)
  BOTTOM w0.122: v7(25.46,71.36) 25.03,71.36 v1(24.62,70.95)
  BOTTOM w0.254: PU700.10 25.37,83.36 25.49,83.48 26.67,83.48 v7(26.73,83.42)
NTCG: length 18.3
  TOP w0.254: v8(25.53,72.86) 25.43,72.76 24.92,72.76 23.98,71.82 23.98,71.01 PH700.1 ; v7(22.71,84.19) 22.71,84.37 23.35,85 PR704.2
  IN1 w0.254: v7(22.71,84.19) 22.71,83.6 23.3,83.02 23.3,78.72 24.21,77.81 24.21,74.18 v8(25.53,72.86)
  BOTTOM w0.254: v7(22.71,84.19) 22.71,83.99 22.97,83.73 PU700.4
P1:
  vias: v7(139.12,43.24) v7(139.12,42.61) v7(139.76,43.24) v7(139.76,42.61) v7(140.39,43.24) v7(140.39,42.61) v7(141.03,43.24) v7(141.03,42.61) v7(154.44,42.74) v7(154.44,42.1) v7(154.44,41.47) v7(155.07,42.76) v7(155.07,42.1) v7(155.07,41.47) v7(155.71,42.1) v7(155.71,41.47) v9(137.14,43.24)
PBTN_OUT#: length 28.4
  TOP w0.122: RH293.2 119,61.28 119.9,60.38 122.21,60.38 122.64,59.95 125.17,59.95 125.36,60.13 125.36,60.35 125.56,60.55 126.09,60.55 126.33,60.31 126.33,60.1 126.49,59.94 127.27,59.94 v2(127.29,59.93) ; U34.H4 141.28,61.24 v2(141.18,61.24)
  GND1 w0.104: v2(141.18,61.24) 141.5,60.92 v3(141.5,60.91) ; v3(127.31,60.54) 127.29,60.52 v2(127.29,59.93)
  IN1 w0.071: v3(127.31,60.54) 127.77,61 v4(127.79,61) ; v3(141.5,60.91) 141.87,60.54 v4(141.87,60.36)
  IN2 w0.094: v4(141.87,60.36) 141.61,60.11 139.21,60.11 139.11,60.21 138.75,60.21 138.37,59.82 135.06,59.82 134.79,60.1 130.66,60.1 129.33,61.43 128.22,61.43 v4(127.79,61)
PBTN_OUT#_R: length 8.7
  TOP w0.122: v2(113.55,64.33) 113.55,64.06 114.28,63.32 115.17,63.32 115.42,63.07 115.7,63.07 116.52,62.26 116.52,61.63 117.05,61.1 117.77,61.1 RH293.1
  GND1 w0.104: v3(113.55,63.92) v2(113.55,64.33)
  IN1 w0.071: v3(113.55,63.92) 113.57,63.89 v4(113.57,63.41)
  IN4 w0.071: v5(113.11,63.59) 113.29,63.41 v4(113.57,63.41)
  GND5 w0.104: v6(113.57,63.56) 113.14,63.56 v5(113.11,63.59)
  BOTTOM w0.122: v6(113.57,63.56) 113.14,63.56 UH1.K19
PBTN_SW#: length 199
  TOP w0.122: v2(94.04,54.9) 94.04,54.37 91.27,51.6 89.21,51.6 83.49,45.89 80.7,45.89 80.31,45.5 58.83,45.5 58.63,45.69 v1(58.44,45.69) 57.83,45.69 57.5,45.37 55.79,45.37 55.09,46.08 37.04,46.08 36.33,45.37 32.47,45.37 31.9,45.95 27.89,45.95 27.23,46.6 24.04,46.6 v7(23.71,46.27) ; v2(134.58,62.01) 133.79,61.23 D85.1 134.11,59.94 135.06,58.99 R940.2 135.06,58.59 135.5,58.14 137.65,58.14 137.77,58.26 137.81,58.3 137.81,58.37 137.96,58.51 138.21,58.51 138.64,58.94 139.12,58.94 139.28,59.1 U34.N7
  GND1 w0.104: v2(134.58,62.01) 134.12,62.47 v3(134.12,62.5) ; v3(94.47,54.9) v2(94.04,54.9)
  IN1 w0.071: v3(134.12,62.5) 133.2,62.5 v7(132.77,62.06) 132.49,62.34 130.4,62.34 129.73,61.67 129.73,60.73 128.54,59.54 128.54,58.58 127.51,57.55 126.44,57.55 124.34,55.45 121.27,55.45 120.95,55.13 118.42,55.13 117.48,56.07 115.41,56.07 114.2,54.86 112.22,54.86 112.12,54.96 109.05,54.96 108.87,55.14 107.69,55.14 107.11,55.73 107.1,55.73 106.91,55.93 105.36,55.93 105.12,56.16 95.94,56.16 94.67,54.9 v3(94.47,54.9)
  IN2 w0.094: v7(18.45,22.18) 18.82,22.55 18.82,24.1 18.44,24.48 18.29,24.48 17.6,25.17 17.6,29.78 17.4,29.99 17.4,39.39 17.61,39.6 17.61,40.14 18.25,40.77 18.25,41.66 19.45,42.86 19.45,44.79 20.72,46.06 21.23,46.06 22.01,45.28 23.46,45.28 23.71,45.52 v7(23.71,46.27)
  BOTTOM w0.122: SW2.2 150.02,78.25 149.57,77.8 147.21,77.8 146.76,78.25 SW2.1 144.27,77.61 138.08,77.61 137.76,77.29 137.76,72.01 135.8,70.04 135.8,69.78 134.89,68.88 134.89,68.7 132.39,66.2 132.39,64.58 132.82,64.15 132.82,62.11 v7(132.77,62.06) ; v7(18.45,22.18) 18.52,22.25 20.1,22.25 20.86,21.49 20.86,20.7 21.1,20.46 JIOL1.29
PCH_DP_AUXN: length 80.8
  TOP w0.104: v2(167.27,59.75) 167.35,59.83 167.58,59.83 CV10.2
  GND1 w0.089: v2(167.27,59.75) 167.37,59.86 167.64,59.86 v3(167.77,59.73)
  IN1 w0.071: v3(167.77,59.73) 167.67,59.83 166.96,59.83 166.4,60.39 166.1,60.39 v4(165.92,60.21)
  IN4 w0.071: v5(101.61,74.87) 101.6,74.86 101.6,74.76 101.81,74.56 102.27,74.56 102.79,74.04 108.48,74.04 110.43,72.09 110.43,69.53 112.88,67.08 113.13,67.08 113.61,66.6 114.17,66.6 114.6,66.18 115.46,66.18 115.83,66.54 116.8,66.54 117.13,66.21 117.53,66.21 118.77,64.98 119.93,64.98 120.62,65.67 125.86,65.67 127.63,63.91 129.48,63.91 129.9,63.48 131.7,63.48 132.34,62.84 134.26,62.84 135.49,64.07 146.99,64.07 147.76,63.31 152.33,63.31 154.36,61.27 156.35,61.27 156.88,60.74 163.89,60.74 164.87,61.73 166.1,61.73 166.63,61.2 166.63,60.62 166.39,60.38 166.09,60.38 v4(165.92,60.21)
  GND5 w0.089: v5(101.61,74.87) v6(102.02,74.87)
  BOTTOM w0.104: UH1.AU46 v6(102.02,74.87)
PCH_DP_AUXN_C: length 3.1
  TOP w0.104: CV10.1 169.02,59.74 169.91,59.74 170.16,59.49 170.16,59.07 170.41,58.82 UV1.5
PCH_DP_AUXP: length 80.8
  TOP w0.104: v2(167.27,60.19) 167.35,60.1 167.58,60.1 CV8.2
  GND1 w0.089: v2(167.27,60.19) 167.37,60.08 167.69,60.08 v3(167.77,60.16)
  IN1 w0.071: v3(167.77,60.16) 167.69,60.08 167.06,60.08 166.51,60.64 166.08,60.64 v4(165.92,60.79)
  IN4 w0.071: v5(101.61,74) 101.47,74 101.38,74.09 101.38,74.26 101.33,74.31 101.33,74.42 101.41,74.5 101.52,74.5 101.71,74.31 102.17,74.31 102.69,73.79 108.37,73.79 110.18,71.98 110.18,69.43 112.78,66.83 113.02,66.83 113.51,66.35 114.07,66.35 114.5,65.93 115.56,65.93 115.93,66.29 116.69,66.29 117.02,65.96 117.43,65.96 118.66,64.73 120.03,64.73 120.73,65.42 125.76,65.42 127.53,63.66 129.37,63.66 129.8,63.23 131.59,63.23 132.23,62.59 134.36,62.59 135.59,63.82 146.89,63.82 147.65,63.06 152.22,63.06 154.26,61.02 156.25,61.02 156.77,60.5 163.99,60.5 164.98,61.48 166,61.48 166.38,61.1 166.38,60.72 166.29,60.62 166.09,60.62 v4(165.92,60.79)
  GND5 w0.089: v5(101.61,74) v6(102.02,74)
  BOTTOM w0.104: UH1.AU44 v6(102.02,74)
PCH_DP_AUXP_C: length 3
  TOP w0.104: CV8.1 169.21,60.01 169.95,60.01 170.16,60.22 170.16,60.57 170.36,60.77 UV1.2
PCH_DP_CLK: length 82.2
  TOP w0.104: v8(167.24,61.91) 167.42,62.09 167.75,62.09 168.88,63.22 170.84,63.22 171.23,62.83 171.23,62.59 171.09,62.45 RH281.2 171.21,61.91 171.84,61.91 173.29,60.46 173.29,59.65 173.01,59.37 172.81,59.37 172.06,60.12 UV1.3
  IN4 w0.071: v5(111.29,75.41) 110.93,75.41 110.74,75.21 110.74,74.96 110.91,74.79 111.08,74.79 111.96,73.91 111.96,71.11 112.16,70.92 112.16,69.16 112.75,68.58 113.02,68.58 114.06,67.53 116.5,67.53 116.78,67.25 117.51,67.25 117.69,67.06 117.72,67.03 117.72,67.03 117.9,66.85 118.05,66.85 119.12,65.79 119.53,65.79 120.2,66.46 131.19,66.46 132.04,65.61 140.8,65.61 140.96,65.44 145.24,65.44 145.88,64.81 147.57,64.81 147.97,64.4 150.04,64.4 150.15,64.51 152.36,64.51 154.89,61.98 158.26,61.98 158.52,61.72 163.87,61.72 165.41,63.26 167.52,63.26 167.93,62.85 167.93,62.34 167.69,62.1 167.43,62.1 v8(167.24,61.91)
  GND5 w0.089: v5(111.29,75.41) 111.32,75.43 v6(111.71,75.43)
  BOTTOM w0.104: v6(111.71,75.43) 111.75,75.47 UH1.M48
PCH_DP_DAT: length 81.2
  TOP w0.104: v7(167.24,62.55) 167.43,62.36 167.64,62.36 168.76,63.49 v7(169.35,63.49) 170.95,63.49 171.5,62.94 171.5,62.65 RH282.2 172.45,61.7 172.45,61.68 173.56,60.58 173.56,59.54 173.12,59.1 172.89,59.1 171.96,58.17 UV1.6
  IN4 w0.071: v5(110.29,74.03) 110.29,74.24 110.59,74.54 110.98,74.54 111.71,73.81 111.71,71.01 111.91,70.81 111.91,69.06 112.64,68.33 112.91,68.33 113.96,67.28 116.39,67.28 116.68,67 117.4,67 117.52,66.89 117.72,66.68 117.8,66.6 117.95,66.6 119.02,65.54 119.63,65.54 120.3,66.21 131.09,66.21 131.94,65.36 140.7,65.36 140.86,65.19 145.14,65.19 145.78,64.56 147.47,64.56 147.87,64.15 150.15,64.15 150.26,64.26 152.25,64.26 154.79,61.73 158.16,61.73 158.41,61.47 163.98,61.47 165.51,63.01 167.42,63.01 167.68,62.75 167.68,62.45 167.58,62.35 167.43,62.35 167.24,62.54 v7(167.24,62.55)
  GND5 w0.089: v6(110.29,73.6) v5(110.29,74.03)
  BOTTOM w0.104: v6(110.29,73.6) UH1.U42
PCH_DP_HPD: length 136.9
  TOP w0.122: v2(211.82,77.15) 211.46,77.15 209.71,75.4 QV1.3 210.29,74.49 RH300.2 v1(210.29,72.48)
  GND1 w0.104: v2(211.82,77.15) v3(211.82,77.66)
  IN1 w0.071: v4(212.33,77.66) v3(211.82,77.66)
  IN2 w0.094: v4(96.45,73.33) 97.56,73.33 98.27,74.04 100,74.04 100.33,73.71 103.4,73.71 104.96,75.27 106.26,75.27 106.69,75.7 107.22,75.7 108.16,76.64 108.16,77.55 108.5,77.89 110.54,77.89 112.66,80.02 113.81,80.02 115.18,81.39 119.08,81.39 120.04,82.35 123.32,82.35 125.27,84.29 126.63,84.29 127.62,85.28 131.01,85.28 131.34,85.61 133.71,85.61 134.37,84.95 134.37,83.89 135.99,82.28 136.9,82.28 137.75,81.43 153.39,81.43 153.86,81.9 168.3,81.9 169.17,82.77 174.06,82.77 175.56,84.26 192.72,84.26 193.14,84.68 195.33,84.68 197.58,82.43 197.58,82.07 198.96,80.69 200.58,80.69 202.83,78.44 211.2,78.44 211.98,77.66 v4(212.33,77.66)
  IN4 w0.071: v4(96.45,73.33) 96.48,73.36 v5(96.96,73.36)
  GND5 w0.104: v6(96.55,73.36) v5(96.96,73.36)
  BOTTOM w0.122: UH1.BK44 v6(96.55,73.36)
PCH_DP_N0: length 131.1
  TOP w0.104: v7(214.79,75.22) 214.58,75.01 214.58,74.37 215,73.94 215.29,73.94 215.39,74.05 CV4.2
  IN1 w0.071: v4(98.15,76.31) 97.97,76.13 97.97,75.67 99.03,74.61 100.56,74.61 100.68,74.73 101.66,74.73 101.95,74.43 111.38,74.43 112.61,73.21 116.83,73.21 116.99,73.05 118.41,73.05 118.69,73.33 120.09,73.33 122.57,75.81 132.38,75.81 134.11,77.54 145.79,77.54 146.36,76.97 155.99,76.97 156.27,76.69 168.07,76.69 168.4,77.02 170.88,77.02 172.39,75.51 177.14,75.51 178.48,76.84 181.23,76.84 184.55,80.16 184.83,80.16 186.62,81.95 194.67,81.95 195.66,80.96 196.98,80.96 197.76,80.18 199.18,80.18 202.76,76.61 209.49,76.61 209.63,76.47 213.91,76.47 214.57,75.81 214.57,75.45 v7(214.79,75.22)
  IN4 w0.071: v4(98.15,76.31) 97.89,76.58 v5(97.89,76.76)
  GND5 w0.089: v5(97.89,76.76) v6(98.3,76.76)
  BOTTOM w0.104: v6(98.3,76.76) UH1.BG51
PCH_DP_N0_C: length 9.8
  TOP w0.104: v8(218.69,74.61) 218.89,74.41 218.89,74.07 219.22,73.73 219.22,73.55 219.15,73.47 219.06,73.47 218.93,73.61 DV1.10 DV1.1 217.39,73.61 217.27,73.48 217.14,73.48 217.05,73.57 217.05,73.81 216.82,74.04 216.65,74.04 CV4.1
  IN1 w0.071: v8(218.69,74.61) 218.89,74.41 218.89,74.04 219.16,73.77 220.29,73.77 220.89,73.18 222.28,73.18 JMDP1.5
PCH_DP_N1: length 132.1
  TOP w0.104: v7(214.69,71.84) 214.77,71.93 215.18,71.93 CV7.2
  IN1 w0.071: v7(214.69,71.84) 214.82,71.98 215.15,71.98 215.47,72.3 215.47,73.34 214.7,74.11 214.41,74.11 212.77,75.76 209.32,75.76 209.19,75.89 202.43,75.89 198.85,79.47 197.45,79.47 196.67,80.25 195.18,80.25 194.19,81.24 186.92,81.24 185.16,79.47 184.87,79.47 181.26,75.86 179.76,75.86 178.36,74.47 171.94,74.47 170.81,75.6 168.8,75.6 168.59,75.39 152.13,75.39 151.94,75.2 148.39,75.2 147.34,74.15 142.17,74.15 141.26,75.06 138.57,75.06 137.72,75.92 133.78,75.92 132.49,74.63 122.43,74.63 120.41,72.61 119.06,72.61 118.22,71.78 117.11,71.78 117.09,71.81 113.33,71.81 112.77,72.36 112.4,72.36 111.06,73.7 99.18,73.7 98.38,72.91 v4(98.38,72.83)
  IN4 w0.071: v5(98.01,73.21) v4(98.38,72.83)
  GND5 w0.089: v6(98.01,72.79) v5(98.01,73.21)
  BOTTOM w0.104: UH1.BF42 v6(98.01,72.79)
PCH_DP_N1_C: length 9.1
  TOP w0.104: JMDP1.11 224.29,71.17 220.03,71.17 v7(219.69,71.51) 219.48,71.72 219.14,71.72 219.02,71.61 DV1.6 DV1.5 217.34,71.61 217.22,71.72 216.99,71.72 216.71,72.01 216.6,72.01 CV7.1
PCH_DP_N2: length 147.8
  IN1 w0.071: v4(97.44,75.22) 97.34,75.12 97.04,75.12 96.95,75.21 96.95,76.38 98.25,77.68 101.15,77.68 103.63,75.21 105.39,75.21 105.42,75.24 107.65,75.24 107.66,75.23 108.43,75.23 108.44,75.24 111.9,75.24 113.12,74.02 116.2,74.02 116.68,74.5 118.39,74.5 119.09,73.79 119.87,73.79 122.89,76.81 128.62,76.81 128.9,76.53 129.49,76.53 129.66,76.7 132.27,76.7 133.73,78.16 145.89,78.16 146.51,77.53 156.39,77.53 156.62,77.76 177.93,77.76 177.96,77.74 180.04,77.74 180.06,77.75 181.35,77.75 184.47,80.87 184.64,80.87 185.55,81.78 185.55,82.1 186.14,82.69 190.13,82.69 190.41,82.97 191.14,82.97 191.32,82.79 194.65,82.79 196.02,81.42 197.24,81.42 197.56,81.1 198.01,80.64 199.37,80.64 202.92,77.09 209.74,77.09 209.89,76.95 214.08,76.95 215.94,75.09 215.94,67.83 214.4,66.29 212.64,66.29 212.33,65.98 212.33,65.75 v8(212.15,65.57)
  IN4 w0.071: v4(97.44,75.22) 97.2,74.98 v5(97.01,74.98)
  GND5 w0.089: v5(97.01,74.98) v6(97.42,74.98)
  BOTTOM w0.104: v8(212.15,65.57) 212.4,65.82 212.4,66.93 212.71,67.24 212.93,67.24 213.24,67.55 CV12.2 ; v6(97.42,74.98) UH1.BJ47
PCH_DP_N2_C: length 11.5
  TOP w0.104: v7(219.36,66.33) 219.16,66.53 219.16,68.13 220.01,68.99 v7(220.57,68.99) 222.47,68.99 JMDP1.17
  BOTTOM w0.104: CV12.1 214.85,67.23 215.64,67.23 215.69,67.28 DV2.7 DV2.4 217.25,67.28 217.3,67.22 217.3,67.12 217.37,67.05 217.81,67.05 217.88,67.12 218.81,67.12 219.12,66.81 219.12,66.57 v7(219.36,66.33)
PCH_DP_N3: length 134.8
  IN1 w0.071: v4(96.55,73.9) 96.79,73.67 96.79,73.49 98.18,72.1 100.26,72.1 100.97,72.8 108.83,72.8 110.53,71.09 111.75,71.09 112.37,70.48 113.72,70.48 113.85,70.34 115.7,70.34 115.86,70.5 116.23,70.5 116.45,70.28 117.93,70.28 118.1,70.46 118.31,70.46 119.46,71.62 120.83,71.62 122.18,72.96 132.95,72.96 133.57,73.58 138.6,73.58 139,73.19 147.74,73.19 148.8,74.24 153.28,74.24 153.42,74.38 168.61,74.38 169.48,73.52 180.55,73.52 183.37,76.34 184.03,76.34 185.83,78.14 185.83,78.75 187.36,80.28 193.76,80.28 195.14,78.9 196.59,78.9 196.97,78.51 198.38,78.51 201.96,74.93 208.78,74.93 208.91,74.8 212.37,74.8 212.74,74.43 212.74,74.24 212.58,74.08 212.36,74.08 212.27,74.17 v7(212.27,74.31)
  IN4 w0.071: v5(96.13,74.17) 96.4,73.9 v4(96.55,73.9)
  GND5 w0.089: v6(96.56,74.17) v5(96.13,74.17)
  BOTTOM w0.104: CV9.2 213.65,70.57 213.65,71.01 213.23,71.42 212.36,71.42 211.95,71.83 211.95,72.88 211.51,73.32 v7(211.51,73.61) 211.51,73.88 211.75,74.12 212.08,74.12 v7(212.27,74.31) ; UH1.BL45 v6(96.56,74.17)
PCH_DP_N3_C: length 11.2
  BOTTOM w0.104: JMDP1.12 219.95,71 219.95,71.01 219.83,71.01 219.67,71.17 217.65,71.17 217.45,70.97 217.45,70.1 217.93,69.62 v7(217.93,69.2) 217.93,68.86 217.47,68.4 217.26,68.4 217.14,68.28 DV2.2 DV2.9 215.74,68.28 215.65,68.36 214.08,68.36 213.52,68.92 213.52,69.18 CV9.1
PCH_DP_P0: length 131.2
  TOP w0.104: CV3.2 215.21,73.67 214.89,73.67 214.31,74.26 214.31,75.03 v8(214.13,75.21)
  IN1 w0.071: v8(214.13,75.21) 214.32,75.4 214.32,75.71 213.81,76.22 209.53,76.22 209.39,76.36 202.65,76.36 199.08,79.93 197.66,79.93 196.88,80.71 195.56,80.71 194.57,81.7 186.72,81.7 184.93,79.91 184.65,79.91 181.34,76.59 178.58,76.59 177.25,75.26 172.29,75.26 170.77,76.77 168.5,76.77 168.17,76.44 156.17,76.44 155.89,76.72 146.26,76.72 145.69,77.29 134.21,77.29 132.48,75.56 122.68,75.56 120.19,73.08 118.79,73.08 118.51,72.8 116.89,72.8 116.72,72.96 112.5,72.96 111.28,74.19 101.85,74.19 101.56,74.48 100.78,74.48 100.66,74.36 98.92,74.36 97.72,75.56 97.72,76.16 v4(97.57,76.31)
  IN4 w0.071: v5(97.87,75.9) 97.87,76.01 v4(97.57,76.31)
  GND5 w0.089: v5(97.87,75.9) v6(98.3,75.9)
  BOTTOM w0.104: v6(98.3,75.9) UH1.BG49
PCH_DP_P0_C: length 9.8
  TOP w0.104: CV3.1 216.31,73.5 216.58,73.77 216.71,73.77 216.78,73.7 216.78,73.46 217.03,73.21 217.27,73.21 217.38,73.11 DV1.2 DV1.9 219.08,73.11 219.18,73.21 219.26,73.21 219.49,73.43 219.49,73.85 219.16,74.18 219.16,74.45 v8(219.32,74.61)
  IN1 w0.071: v8(219.32,74.61) 219.14,74.43 219.14,74.14 219.26,74.02 220.39,74.02 220.99,73.42 222.28,73.42 JMDP1.3
PCH_DP_P1: length 132.1
  TOP w0.104: v7(214.69,72.48) 214.97,72.2 215.21,72.2 215.39,72.38 CV5.2
  IN1 w0.071: v7(214.69,72.48) 214.69,72.4 214.87,72.22 215.04,72.22 215.22,72.4 215.22,73.24 214.6,73.86 214.31,73.86 212.67,75.51 209.22,75.51 209.09,75.64 202.33,75.64 198.75,79.22 197.35,79.22 196.57,80 195.07,80 194.09,80.99 187.03,80.99 185.26,79.22 184.97,79.22 181.36,75.62 179.86,75.62 178.47,74.22 171.84,74.22 170.71,75.35 168.9,75.35 168.69,75.15 152.23,75.15 152.04,74.96 148.5,74.96 147.44,73.9 142.07,73.9 141.15,74.82 138.47,74.82 137.62,75.67 133.88,75.67 132.6,74.38 122.54,74.38 120.52,72.36 119.16,72.36 118.33,71.53 117.01,71.53 116.99,71.56 113.22,71.56 112.67,72.11 112.3,72.11 110.95,73.45 99.28,73.45 98.76,72.94 98.76,72.63 98.86,72.53 99.14,72.53 99.22,72.61 v4(99.22,72.83)
  IN4 w0.071: v5(98.87,73.19) 99.22,72.84 v4(99.22,72.83)
  GND5 w0.089: v6(98.87,72.78) v5(98.87,73.19)
  BOTTOM w0.104: UH1.BD42 v6(98.87,72.78)
PCH_DP_P1_C: length 9.1
  TOP w0.104: CV5.1 216.31,72.56 216.59,72.28 216.82,72.28 217.11,71.99 217.22,71.99 217.34,72.11 DV1.4 DV1.7 219.02,72.11 219.14,71.99 219.6,71.99 220.15,71.44 v7(221.56,71.44) 224.3,71.44 JMDP1.9
PCH_DP_P2: length 147.7
  IN1 w0.071: v8(212.83,65.57) 212.69,65.57 212.57,65.69 212.57,65.87 212.74,66.04 214.5,66.04 216.19,67.73 216.19,75.2 214.19,77.2 209.99,77.2 209.85,77.34 203.03,77.34 199.47,80.89 198.12,80.89 197.74,81.27 197.34,81.67 196.12,81.67 194.75,83.04 191.43,83.04 191.24,83.22 190.31,83.22 190.02,82.94 186.04,82.94 185.3,82.2 185.3,81.89 184.53,81.12 184.37,81.12 181.25,78 179.95,78 179.94,77.99 178.06,77.99 178.04,78.01 156.52,78.01 156.29,77.78 146.62,77.78 145.99,78.4 133.62,78.4 132.16,76.94 129.55,76.94 129.39,76.78 129.01,76.78 128.73,77.06 122.79,77.06 119.77,74.04 119.2,74.04 118.49,74.75 116.58,74.75 116.1,74.26 113.23,74.26 112.01,75.48 108.34,75.48 108.33,75.48 107.76,75.48 107.76,75.48 105.32,75.48 105.29,75.46 103.73,75.46 101.26,77.93 98.15,77.93 96.7,76.48 96.7,75.37 v4(96.55,75.22)
  IN4 w0.071: v4(96.55,75.22) 96.31,74.98 v5(96.11,74.98)
  GND5 w0.089: v6(96.54,74.98) v5(96.11,74.98)
  BOTTOM w0.104: UH1.BL47 v6(96.54,74.98) ; CV11.2 213.24,66.66 212.93,66.97 212.82,66.97 212.67,66.82 212.67,65.73 v8(212.83,65.57)
PCH_DP_P2_C: length 11.4
  TOP w0.104: JMDP1.15 222.12,69.26 219.9,69.26 218.89,68.24 v7(218.89,67.32) 218.89,66.5 v7(218.72,66.33)
  BOTTOM w0.104: v7(218.72,66.33) 218.85,66.46 218.85,66.7 218.7,66.85 217.99,66.85 217.92,66.78 DV2.5 DV2.6 215.7,66.78 215.51,66.96 214.83,66.96 CV11.1
PCH_DP_P3: length 134.9
  IN1 w0.071: v7(212.27,73.66) 212.44,73.83 212.69,73.83 212.99,74.14 212.99,74.53 212.48,75.05 209.01,75.05 208.89,75.18 202.07,75.18 198.48,78.76 197.07,78.76 196.69,79.15 195.24,79.15 193.86,80.53 187.25,80.53 185.58,78.86 185.58,78.25 183.93,76.59 183.27,76.59 180.45,73.77 169.58,73.77 168.71,74.63 153.32,74.63 153.18,74.49 148.69,74.49 147.64,73.44 139.1,73.44 138.71,73.83 133.47,73.83 132.85,73.21 122.07,73.21 120.72,71.86 119.36,71.86 118.2,70.71 118,70.71 117.82,70.53 116.55,70.53 116.33,70.75 115.75,70.75 115.6,70.59 113.96,70.59 113.82,70.73 112.47,70.73 111.86,71.34 110.64,71.34 108.93,73.05 100.86,73.05 100.16,72.35 98.28,72.35 97.04,73.59 97.04,73.84 97.1,73.9 v4(97.42,73.9)
  IN4 w0.071: v4(97.42,73.9) 97.26,73.9 v5(97,74.17)
  GND5 w0.089: v6(97.4,74.17) v5(97,74.17)
  BOTTOM w0.104: UH1.BJ45 v6(97.4,74.17) ; CV6.2 213.92,70.58 213.92,71.12 213.34,71.69 v7(212.83,71.69) 212.48,71.69 212.22,71.95 212.22,72.99 211.78,73.43 211.78,73.76 211.87,73.85 212.09,73.85 v7(212.27,73.66)
PCH_DP_P3_C: length 11.2
  BOTTOM w0.104: JMDP1.10 219.8,71.6 219.64,71.44 217.54,71.44 217.18,71.08 v7(217.18,70.59) 217.18,69.99 217.66,69.51 217.66,68.97 217.35,68.67 217.23,68.67 217.12,68.78 DV2.1 DV2.10 215.71,68.78 215.57,68.63 214.19,68.63 213.79,69.03 213.79,69.3 213.92,69.43 214.15,69.43 CV6.1
PCH_DPWROK: length 19.7
  TOP w0.122: v1(128.99,64.34) 128.82,64.17 RH309.2 127.87,64.17 ; 127.87,64.17 127.4,64.17 127.36,64.13 RH126.1 ; 127.87,64.17 127.24,64.81 v7(127.24,65.16)
  IN1 w0.071: v7(127.24,65.16) 126.96,64.88 126.96,64.87 126.67,64.58 124.25,64.58 123.58,63.91 123.58,61.75 122.92,61.09 120.39,61.09 120.01,61.47 v4(120.01,61.75)
  IN4 w0.071: v4(120.01,61.75) 119.71,62.06 119.62,62.06 v5(119.62,62.06)
  GND5 w0.104: v6(119.63,62.51) 119.63,62.07 v5(119.62,62.06)
  BOTTOM w0.122: UH1.A21 118.54,64.41 119.85,63.1 119.85,62.73 119.63,62.51 v6(119.63,62.51)
PCH_ENVDD: length 64.2
  TOP w0.122: D93.2 166.87,66.77 RH158.2 166.62,67.56 v2(166.59,67.59) 166.54,67.59 v1(166.2,67.93)
  GND1 w0.104: v2(166.59,67.59) v3(166.59,67.14)
  IN1 w0.071: v4(154.9,69.66) 154.9,68.65 155.83,67.72 166.02,67.72 v3(166.59,67.14)
  IN4 w0.071: v5(113.04,73.14) 113.06,73.16 114.36,73.16 114.69,72.83 115.07,72.83 115.25,73.01 118.59,73.01 120.78,75.2 125.44,75.2 127.08,73.56 129.33,73.56 130.41,72.48 130.97,72.48 131.71,71.74 131.71,71.13 133.59,69.25 134.04,69.25 134.7,68.59 137.2,68.59 137.99,69.38 139.61,69.38 140.88,70.65 148.32,70.65 149,69.96 154.59,69.96 v4(154.9,69.66)
  GND5 w0.104: v6(112.63,73.14) v5(113.04,73.14)
  BOTTOM w0.122: UH1.M42 v6(112.63,73.14)
PCH_GPIO2: length 10.9
  BOTTOM w0.122: v1(124.29,79.77) 124.52,79.54 RH335.2 124.49,78.76 124.11,78.37 124.11,78.35 124.05,78.29 124.05,77.51 123.94,77.4 122.5,77.4 121.33,76.24 118.74,76.24 118.26,75.76 117.52,75.76 UH1.A47
PCH_GPIO3: length 17.6
  TOP w0.122: v7(127.97,73.95) 127.49,74.43 v1(127.49,74.68) 127.49,75.34 127.18,75.65 RH330.2
  IN2 w0.094: v4(118.07,72.24) 118.1,72.28 120.63,72.28 122.5,74.14 123.91,74.14 124.59,73.46 127.48,73.46 v7(127.97,73.95)
  IN4 w0.071: v4(118.07,72.24) 118.07,72.28 117.53,72.81 116.14,72.81 v5(115.87,72.54)
  GND5 w0.104: v6(116.3,72.54) v5(115.87,72.54)
  BOTTOM w0.122: UH1.C41 v6(116.3,72.54)
PCH_GPIO5: length 15.4
  TOP w0.122: v2(123.51,73.53) 124.25,73.53 v1(124.35,73.63) 124.63,73.63 124.86,73.41 125.76,73.41 RH328.2
  GND1 w0.104: v3(123.03,73.7) 123.19,73.53 v2(123.51,73.53)
  IN1 w0.071: v3(123.03,73.7) 123.09,73.76 v4(123.56,73.76)
  IN2 w0.094: v4(123.56,73.76) 122.44,73.76 120.37,71.68 116.84,71.68 116.29,71.13 v4(114.87,71.13)
  IN4 w0.071: v4(114.87,71.13) 115.22,71.49 v5(115.22,71.54)
  GND5 w0.104: v6(114.85,71.73) 115.04,71.54 v5(115.22,71.54)
  BOTTOM w0.122: v6(114.85,71.73) UH1.F40
PCH_GPIO12: length 7.7
  BOTTOM w0.122: RH290.1 119.18,53.12 117.42,54.89 117.42,57.66 116.95,58.13 116.59,58.13 116.38,57.91 UH1.C5
PCH_GPIO15: length 9.9
  TOP w0.122: v2(112.88,57.98) 112.88,56.87 113.71,56.05 113.71,55.56 113.9,55.37 114.14,55.37 114.53,54.99 114.53,52.94 115.08,52.39 RH270.1
  GND1 w0.104: v2(112.88,57.98) 112.88,57.66 v3(113.43,57.11)
  IN1 w0.071: v4(112.94,56.87) 113.18,57.11 v3(113.43,57.11)
  IN4 w0.071: v5(113.3,57.2) 113.27,57.2 v4(112.94,56.87)
  GND5 w0.104: v6(113.3,57.61) v5(113.3,57.2)
  BOTTOM w0.122: UH1.K6 113.3,57.92 v6(113.3,57.61)
PCH_GPIO18: length 6.1
  TOP w0.122: v2(109.66,58.18) 109.74,58.1 v1(109.74,57.39) 109.74,55.54 109.45,55.25 RH95.1
  GND1 w0.104: v3(109.66,58.59) v2(109.66,58.18)
  IN1 w0.071: v3(109.66,58.59) 109.66,58.97 v4(109.79,59.09)
  IN4 w0.071: v4(109.79,59.09) 110.04,58.84 v5(110.22,58.84)
  GND5 w0.104: v6(110.29,59.3) 110.22,59.22 v5(110.22,58.84)
  BOTTOM w0.122: UH1.U8 v6(110.29,59.3)
PCH_GPIO20: length 6.2
  TOP w0.122: RH100.1 110.38,55.11 110.47,55.2 v1(110.47,55.59) 110.47,56.26 110.4,56.34 110.4,57.9 v2(110.32,57.98)
  GND1 w0.104: v3(110.8,58.02) 110.37,58.02 v2(110.32,57.98)
  IN1 w0.071: v4(110.5,58.41) 110.5,58.33 110.8,58.03 v3(110.8,58.02)
  IN4 w0.071: v4(110.5,58.41) 110.5,58.05 v5(110.34,57.9)
  GND5 w0.104: v6(110.75,58.03) 110.62,57.9 v5(110.34,57.9)
  BOTTOM w0.122: v6(110.75,58.03) 110.5,57.77 UH1.T4
PCH_GPIO21: length 4.8
  BOTTOM w0.122: RH32.2 112.51,52.34 113.02,52.86 113.02,54.04 v1(112.76,54.31) 112.76,54.85 112.12,55.49 UH1.M2
PCH_GPIO26: length 13.5
  TOP w0.122: v2(113.95,62.55) v1(114.46,62.04) 114.46,61.47 114.47,61.45 114.6,61.33 114.6,60.96 115.83,59.73 115.96,59.73 116.63,59.05 116.63,58.51 116.94,58.2 116.94,57.85 117.54,57.25 119.67,57.25 119.68,57.23 120.72,57.23 RH107.1
  GND1 w0.104: v2(113.95,62.55) 114.03,62.62 v3(114.03,62.98)
  IN1 w0.071: v3(114.03,62.98) 113.91,62.86 v4(113.54,62.86)
  IN4 w0.071: v5(112.74,63) 113.4,63 v4(113.54,62.86)
  GND5 w0.104: v6(112.71,63.49) 112.71,63.03 v5(112.74,63)
  BOTTOM w0.122: v6(112.71,63.49) 112.64,63.55 UH1.M19
PCH_GPIO27: length 40.3
  TOP w0.122: RH311.2 119.37,61.75 118.4,61.75 117.98,62.17 RH186.2 117.97,62.18 v7(117.28,62.18) ; RH310.2 119.87,50.92 v2(119.82,50.87) 119.82,50.37 v1(119.74,50.29)
  GND1 w0.104: v3(120,50.46) 119.82,50.63 v2(119.82,50.87)
  IN1 w0.071: v4(119.44,50.51) 119.49,50.46 v3(120,50.46)
  IN4 w0.071: v7(117.28,62.18) 116.53,62.18 v5(116.33,62.38) ; v5(122.47,51.01) 122.45,51.03 119.96,51.03 v4(119.44,50.51)
  GND5 w0.104: v6(116.33,61.98) 116.33,62.38 v5(116.33,62.38) ; v6(122.9,51.01) v5(122.47,51.01)
  BOTTOM w0.122: v6(122.9,51.01) 122.92,51.01 123.36,50.57 124.81,50.57 124.98,50.74 124.98,51.24 124.77,51.44 124.77,55.01 125.02,55.26 125.02,56.31 123.93,57.41 123.81,57.41 123.57,57.65 123.57,59.03 124.51,59.97 125.93,59.97 126.75,60.79 126.75,63.03 126.37,63.41 125.4,63.41 122.8,60.81 120.71,60.81 120.06,61.46 119.25,61.46 119.14,61.56 117.91,61.56 v7(117.28,62.18) ; UH1.C15 v6(116.33,61.98)
PCH_GPIO28: length 4.8
  BOTTOM w0.122: RH177.2 114.22,51.7 v1(114.22,52.49) 114.22,52.73 114.36,52.87 114.36,53.17 114.24,53.28 114.24,55.35 114,55.59 114,55.98 UH1.G1
PCH_GPIO36: length 6.3
  TOP w0.122: RH193.1 108.47,54.71 108.47,55.99 109.05,56.58 109.05,57.92 v2(109.18,58.05)
  GND1 w0.104: v2(109.18,58.05) 108.92,58.31 v3(108.92,58.48)
  IN1 w0.071: v4(109.28,58.03) 109.28,58.13 v3(108.92,58.48)
  IN4 w0.071: v4(109.28,58.03) 109.28,58.1 108.9,58.48 v5(108.9,58.48)
  GND5 w0.104: v6(109.33,58.48) v5(108.9,58.48)
  BOTTOM w0.122: UH1.W6 v6(109.33,58.48)
PCH_GPIO37: length 6.5
  TOP w0.122: RH182.2 112.29,54.63 RH181.1 112.25,55.21 112.28,55.23 112.28,56.4 112.07,56.61 v2(112.07,57.49)
  GND1 w0.104: v3(112.02,57.95) 112.1,57.87 112.1,57.52 v2(112.07,57.49)
  IN1 w0.071: v3(112.02,57.95) 112.02,58.25 v4(112.22,58.46)
  IN4 w0.071: v4(112.22,58.46) 112.48,58.2 v5(112.48,58)
  GND5 w0.104: v6(112.22,58.46) 112.48,58.2 v5(112.48,58)
  BOTTOM w0.122: UH1.M6 v6(112.22,58.46)
PCH_GPIO39: length 9.8
  TOP w0.122: v2(110.7,59.02) 110.67,58.99 110.67,58.97 v1(110.34,58.64) 110.34,58.41 110.67,58.08 110.67,56.4 110.81,56.26 110.81,55.33 110.85,55.29 110.85,53.37 110.94,53.28 110.94,52.82 110.67,52.55 RH263.1
  GND1 w0.104: v3(110.7,59.45) v2(110.7,59.02)
  IN1 w0.071: v4(110.7,58.97) v3(110.7,59.45)
  IN4 w0.071: v4(110.7,58.97) 110.7,59.32 v5(110.29,59.73)
  GND5 w0.104: v5(110.29,59.73) v6(110.29,60.16)
  BOTTOM w0.122: v6(110.29,60.16) 110.29,59.75 UH1.U10
PCH_GPIO44: length 7.8
  TOP w0.122: RH110.2 114,54.69 114,54.91 113.46,55.46 113.46,55.93 112.66,56.73 112.66,57.72 112.35,58.03 v1(112.35,58.19) 112.35,58.76 v2(112.22,58.89)
  GND1 w0.104: v2(112.22,58.89) 112.58,58.89 v3(112.63,58.94)
  IN1 w0.071: v4(112.78,58.47) 112.78,58.79 v3(112.63,58.94)
  IN4 w0.071: v5(113.64,58.51) 113.35,58.51 113.31,58.47 v4(112.78,58.47)
  GND5 w0.104: v6(113.19,58.43) 113.26,58.51 v5(113.64,58.51)
  BOTTOM w0.122: UH1.K8 v6(113.19,58.43)
PCH_GPIO45: length 8.9
  GND5 w0.104: v6(113.34,56.55) v6(112.93,56.15)
  BOTTOM w0.122: v6(113.34,56.55) UH1.J3 ; v1(114.41,49.75) 113.99,49.75 113.94,49.8 RH116.2 113.47,50.46 113.84,50.83 113.84,52.68 113.54,52.98 113.54,55.28 113.2,55.61 113.2,55.8 112.93,56.07 v6(112.93,56.15)
PCH_GPIO46: length 5.9
  IN4 w0.071: v5(113.8,55.97) 113.8,56.4 v5(113.77,56.4)
  GND5 w0.104: v6(113.75,56.99) 113.75,56.58 113.75,56.58 113.75,56.43 v5(113.77,56.4) ; v6(114.36,55.71) 114.33,55.74 114.03,55.74 v5(113.8,55.97)
  BOTTOM w0.122: v6(113.75,56.99) UH1.H4 ; RH118.2 115.07,52.36 114.61,52.82 114.61,53.57 114.52,53.66 114.52,55.55 v6(114.36,55.71)
PCH_GPIO52: length 18.6
  TOP w0.122: v7(127.05,75.15) 126.66,74.76 RH329.2
  IN2 w0.094: v4(113.06,73.65) 113.49,74.07 116.14,74.07 116.7,74.63 118.36,74.63 119.15,73.83 119.94,73.83 121.39,75.29 126.91,75.29 v7(127.05,75.15)
  IN4 w0.071: v5(113.75,73.7) 113.11,73.7 v4(113.06,73.65)
  GND5 w0.104: v5(113.75,73.7) 113.41,73.7 v6(113.32,73.61)
  BOTTOM w0.122: v6(113.32,73.61) 113.19,73.74 UH1.K44 ; v1(127.62,75.15) v7(127.05,75.15)
PCH_GPIO54: length 12.8
  TOP w0.122: v2(115.42,74.65) 115.43,74.65 116.31,75.52 117.73,75.52 118.42,76.2 v1(120.14,76.2) 121.23,76.2 121.79,76.76 121.79,77.18 122.04,77.43 RH331.2
  GND1 w0.104: v3(115.02,74.65) v2(115.42,74.65)
  IN1 w0.071: v4(114.54,74.65) v3(115.02,74.65)
  IN4 w0.071: v4(114.54,74.65) 114.59,74.59 v5(115.02,74.59)
  GND5 w0.104: v5(115.02,74.59) 115.02,74.66 v6(115.32,74.97)
  BOTTOM w0.122: UH1.F46 115.23,74.88 115.32,74.97 v6(115.32,74.97)
PCH_GPIO70: length 6.7
  GND5 w0.104: v6(115.88,72.14) v6(116.72,72.14)
  BOTTOM w0.122: RH308.1 119.11,71.5 v1(118.89,71.5) 118.69,71.69 117.28,71.69 116.83,72.14 v6(116.72,72.14) ; UH1.D40 v6(115.88,72.14)
PCH_GPIO72: length 9.9
  TOP w0.122: v2(113.95,58.81) 114.03,58.74 114.03,56.55 114.59,55.99 114.59,55.84 v1(114.69,55.74) 114.89,55.74 115.51,55.12 115.51,52.93 116.06,52.39 RH143.1
  GND1 w0.104: v3(113.7,59.14) 113.7,59.07 v2(113.95,58.81)
  IN1 w0.071: v4(113.94,59.6) 113.94,59.38 v3(113.7,59.14)
  IN4 w0.071: v4(113.94,59.6) 113.72,59.81 113.72,59.85 v5(113.6,59.97)
  GND5 w0.104: v5(113.6,59.97) 113.79,59.97 v6(113.99,60.17)
  BOTTOM w0.122: UH1.H10 v6(113.99,60.17)
PCH_GPIO73: length 8.3
  TOP w0.122: v2(111.66,57.49) 111.67,57.49 111.67,56.68 112.01,56.34 112.01,55.42 111.79,55.2 111.79,52.94 111.94,52.79 RH91.2
  GND1 w0.104: v3(111.61,57.9) 111.66,57.85 v2(111.66,57.49)
  IN1 w0.071: v3(111.61,57.9) 111.61,58.38 v4(111.67,58.43)
  IN4 w0.071: v5(112.07,57.95) 112.07,58.03 v4(111.67,58.43)
  GND5 w0.104: v5(112.07,57.95) 112.03,58 v6(111.66,58)
  BOTTOM w0.122: UH1.M4 112.12,57.6 111.72,58 v6(111.66,58)
PCH_INTVRMEN: length 11.7
  TOP w0.122: RH34.2 RH31.2 123.04,65.57 122.87,65.75 121.28,65.75 v1(120.17,66.85) 119.72,66.4 119.72,65.95 118.65,64.88 v2(117,64.88)
  GND1 w0.104: v3(117.01,64.43) 117.01,64.87 v2(117,64.88)
  IN1 w0.071: v3(117.01,64.43) 117.01,64.05 v4(117.18,63.87)
  IN4 w0.071: v4(117.18,63.87) 116.84,63.87 v5(116.64,64.07)
  GND5 w0.104: v5(116.64,64.07) 116.33,64.39 v6(116.33,64.41)
  BOTTOM w0.122: UH1.C21 v6(116.33,64.41)
PCH_INV_PWM: length 56.3
  TOP w0.122: D92.2 v1(162.42,77.8) v2(162.42,78.45)
  GND1 w0.104: v2(162.42,78.45) v3(162.42,78.96)
  IN1 w0.071: v4(112.6,75.42) 113,75.02 116.19,75.02 116.38,75.21 120.02,75.21 122.41,77.6 131.94,77.6 133.61,79.27 151.17,79.27 151.99,78.45 156.24,78.45 156.9,79.11 162.27,79.11 v3(162.42,78.96)
  IN4 w0.071: v5(112.53,75.9) 112.53,75.49 v4(112.6,75.42)
  GND5 w0.104: v6(112.53,76.31) v5(112.53,75.9)
  BOTTOM w0.122: UH1.L49 v6(112.53,76.31)
PCH_JTAG_TCK: length 4.8
  TOP w0.122: RH53.1 v2(111.94,63.08) 111.94,63.41 v1(111.32,64.03)
  GND1 w0.104: v2(111.94,63.08) v3(112.35,63.08)
  IN1 w0.084: v3(112.35,63.08) v4(112.35,62.47)
  IN4 w0.071: v4(112.35,62.47) 112.35,63.18 v5(112.1,63.44)
  GND5 w0.104: v5(112.1,63.44) 112.26,63.27 v6(112.26,63)
  BOTTOM w0.122: UH1.M17 v6(112.26,63)
