# Allegro board LA8821PR30_MB-1113.brd (continued)
## Nets (continued)
VR_SVID_DAT: PR717.2 PU700.7 RC96.2
VSB_N_001: PC908.2 PQ903.2 PR908.2 PR909.2
VSB_N_002: PC910.1 PQ904.2 PR911.2
VSB_N_003: PQ904.1 PR909.1
VSMB: PC37.2 PD9.1 PR31.1 PR33.1 PU2.12
VSUM+: PC741.1 PC742.1 PC743.1 PR741.1 PR744.1 PR747.1 PU700.14
VSUM-: PC741.2 PC742.2 PC743.2 PC745.1 PH703.1 PR744.2 PR748.1 PR749.2 PR750.1
VSUMG+: PC710.2 PC711.2 PR706.2 PR709.2 PR714.1 PU700.1
VSUMG-: PC710.1 PC711.1 PC714.1 PH701.2 PR707.2 PR709.1 PR712.1 PR715.2
VTTREF_1.35V: PC309.1 PU300.4
WAKE#: RH128.2 RH146.1 UH1.D8
WAKE_PCH#: R604.2 RH128.1 RH310.1 U34.N11
WIN8_BTN_SW#: C1142.1 R977.1 R978.2 R981.1 U34.F2
WIN8_BTN_SW#_C: JLVDS2.19 R978.1
WL_OFF#: Q328.3 RH306.1 RH325.2 UH1.D44
WL_OFF#_R: JWLAN1.20 Q328.1 R1020.2
WLAN_EN: Q333.1 R1030.2 U655.3
WLAN_EN#: R1021.1 R1031.1 U34.M1
XCLK_RCOMP: RH113.1 UH1.AC49
XDP_DBRESET#: RC42.1 RC56.2 UH1.L1
XDP_DBRESET#_R: RC56.1 UCPU1.K58
XDP_PRDY#: T241.1(TP-1) UCPU1.N53
XDP_PREQ#: RC47.1 UCPU1.N55
XDP_TCK: RC52.1 UCPU1.L56
XDP_TDI: RC46.1 UCPU1.M60
XDP_TDO: RC48.1 UCPU1.L59
XDP_TMS: RC45.1 UCPU1.L55
XDP_TRST#: RC54.1 UCPU1.J58
XTAL25_IN: CH23.1 RH117.2 UH1.W49 YH2.3
XTAL25_OUT: CH24.1 RH117.1 UH1.W51 YH2.1
N3514555: PC210.1 PC214.1 PC220.1 PJP202.1 PJP204.1 PL1207.1 PR200.1
N6573945: PC15.1 PC16.1 PC17.1 PC18.1 PC507.1 PC511.1 PJP507.2 PJP508.2 PQ1223.5
N6638747: PC29.1 PQ103.4 PR46.2
N16905977: JWLAN1.17 R1017.2
N16920025: JWLAN1.10 R1013.1
N16920097: JWLAN1.16 R1016.1
N16920180: JWLAN1.12 R1014.1
N16920200: JWLAN1.14 R1015.1
N16920204: JWLAN1.8 R1012.1
N16935361: JSATA1.45 T244.1(TP-1)
N16935447: JSATA1.47 T245.1(TP-1)
N16935449: JSATA1.49 T246.1(TP-1)
N16940180: JSATA1.38 T243.1(TP-1)
N16940198: JSATA1.36 T242.1(TP-1)
N17565538: C1169.1 U655.12
N17599718: T81.1(TP-1) UH1.AD48
N17599720: T82.1(TP-1) UH1.AD50
N17638789: Q329.1 R943.1
N17654244: C1160.1 Q326.1 Q329.2 R989.1
N17824335: PC124.2 PQ908.1
N18675747: C284.1 R226.2
N18675794: R250.2 U34.N9
N18675796: R249.2 U34.J5
N18684481: PC219.1 PR201.1 PR203.1 PU501.1
N18687912: PC219.2 PC224.1 PJP201.2 PJP203.2 PL201.2 PR201.2 PR941.2
N19240262: C1152.1 R1003.1 R1089.2
N20043972: C1170.1 U655.10
N20347908: Q42.1 Q47.2 R543.2
N20611554: C1163.1 U654.12
N20611582: C1164.1 U654.10
N21102640: PD902.2 PL901.1 PQ900.1 PR900.1 PR903.2
N21241055: PQ101.1 PQ101.2 PQ101.3 PR13.4 PR17.1
N21884322: PC401.1 PC402.1 PC403.1 PJP402.2 PL400.2 PR401.1
N21900089: PQ101.4 PR17.2 PR22.1
N21947387: PR13.3 PR14.1
N21952280: PR13.2 PR15.1
N21957175: PR40.1 PR49.2 PR954.2 PU2.14
N23648927: RH313.2 T219.1(TP-1) UH1.A15
N25021747: PC713.2 PR710.2
N25021757: PQ1217.1 PR939.2 PT12.1(TP-1)
N25021764: PC715.1 PR711.2
N27967271: PC600.1 PR603.1 PU600.17
N27981869: PR601.2 PR611.2 PU600.16
N27995579: PR609.1 PU600.3
N27996731: PC616.1 PC617.2 PU600.2
N28024997: PR608.2 PR610.2 PU600.5
N28033400: PC604.2 PC605.2 PC606.1 PC607.2 PC608.2 PC609.1 PC610.2 PC611.2 PJP601.2 PL600.2 PR608.1
N28058271: PC618.2 PU600.4
N28066458: PQ1227.2 PR943.2
N28080561: PQ1227.1 PR942.2
N28083008: PR41.1 PR943.1 PT20.1(TP-1)
N28379220: T247.1(TP-1) UH1.BC7
N28385936: T248.1(TP-1) UCPU1.F49
N28580605: Q334.1 R1094.1 R1106.2
N28729492: R1091.2 U638.5
N29996487: PR48.2 PR521.2 PU300.10
N30510546: QH8.2 R1106.1
N31230947: PR43.1 PR516.2 PU501.6
N31334430: CC217.1 QC4.2 RC104.2 RC107.2
N31819837: QC1.1 RC19.1
N31893657: PR955.1 PU2.10
N31894758: PR956.1 PU2.11
N32893408: PR607.2 PU600.6
N32893413: PC617.1 PR609.2
N34016374: D81.1 JFAN1.2 R886.1
N34276852: CH21.1 RH86.1
N34276861: CH22.1 RH89.1
N34353106: PC1916.1 PR961.2 PU702.3
N34353215: PR959.2 PU702.1
N35014398: PC718.1 PR724.1 PU700.25
N35074299: PL704.3 PR747.2
N35074711: PL704.2 PR749.1
N35103280: PC703.2 PC708.1 PR700.2 PR702.2 PR703.2 PU700.38
N35103282: PC700.1 PR700.1
N35124422: Q32.1 R287.2 R894.2
N35128487: PC701.1 PC708.2 PR708.1 PU700.37
N36352449: R1104.2 U636.A5
N37120607: Q333.2 R1031.2
N37468330: PQ1228.6 PR965.1 PR966.1
N37468352: PQ1228.2 PQ1228.3 PR964.1 PR968.2
N37468375: PC1918.1 PQ1228.5 PR967.2
N38312875: PC1919.2 PR218.2 PU501.4
N38315341: PC1920.1 PR216.1 PU501.2
N38789239: CRF4.1 RRF2.1 URF1.4
N38789526: CRF5.1 RRF1.1 URF1.6
N39303073: PD907.1 PR971.2
N39870974: PR513.2 PT19.1(TP-1)
N40584368: Q335.2 Q336.1 R1086.2
N40707343: R1107.1 U638.1
N43370893: RC99.1 UCPU1.G43
N45600193: Q71.1 R536.2
N50875368: PC509.1 PR506.1 PR507.1 PR508.2
N50950299: PC35.1 PR35.1
N50950325: PC22.1 PR23.2
N50950426: PR31.2 PU2.4
N50950439: PC36.1 PR37.2
N51193799: PC510.1 PR506.2
N51517838: PC30.2 PR26.1
N51590731: PR38.1 PR104.1 PU2.13
N51681745: PD10.1 PR24.1
N51733458: PC32.1 PR32.1 PU2.20
N51743550: PC41.2 PC45.2 PQ102.4 PR16.1 PR20.1
N51743582: PC45.1 PQ101.5 PQ102.5
N51790438: PR33.2 PR34.1 PU2.6
N52416950: PC33.2 PR36.1
N52558691: PC740.2 PR742.2
N52558783: PC728.1 PR733.1
N52558792: PC719.1 PR722.1 PU700.26
N52558828: PH702.1 PR726.2 PR727.2
N52558829: PR723.2 PU700.9
N52558859: PC730.2 PR738.1
N52558875: PH700.2 PR701.1 PR704.1
N52558898: PH703.2 PR741.2
N52558937: PQ1218.1 PR940.2 PT16.1(TP-1)
N52559017: PC744.1 PR743.2
N52559077: PC733.1 PR740.2
N52757730: PL701.3 PR714.2
N52760442: PL701.2 PR715.1
N53073163: PQ7.2 PR41.2
N53085144: PC301.1 PR300.1
N56236213: PD200.2 PR210.1 PR219.2
N59797367: RC11.2 UC1.2
N70085701: PD903.2 PR938.2
N74579073: PC125.1 PR941.1 PU501.20
N74615006: PC222.1 PR513.1 PR514.2 PU501.14
N75083074: CH45.1 RH207.1 UH1.AJ13 UH1.AJ15 UH1.AK15 UH1.AL13
N75342688: PC603.2 PR606.1
N75921521: R808.2 R809.1 UI1.4
N76682880: C964.2 U637.13
N76692443: C964.1 U637.12
N76702116: C968.1 U637.6
N76768428: C974.1 U638.14
N82958598: RD10.1 UD10.H8
N82974297: RD9.1 UD9.H8
N82984966: RD12.1 UD12.H8
N82985022: RD11.1 UD11.H8
N83067505: RD14.1 UD14.H8
N83067634: RD16.1 UD16.H8
N83067686: RD15.1 UD15.H8
N83068729: RD13.1 UD13.H8
N83116242: RD2.1 UD2.H8
N83116246: RD1.1 UD1.H8
N83116251: RD4.1 UD4.H8
N83116264: RD3.1 UD3.H8
N83118336: RD6.1 UD6.H8
N83118366: RD8.1 UD8.H8
N83118379: RD7.1 UD7.H8
N83118646: RD5.1 UD5.H8
N83503951: CD124.1 RD36.2 RD38.2
N83550878: CD123.1 RD35.2 RD37.2
N83744884: PC407.1 PC408.1 PC411.1 PJP403.2 PL401.2 PR408.1
N83757774: PC205.1 PR512.1 PU501.15
N84344604: PC509.2 PJP501.2 PJP502.2 PL1212.2
N85222631: R921.1 U34.J6
N85751870: PC504.1 PR501.2
N85751893: PC508.1 PR504.2
N86118123: Q316.5 Q316.6 R907.1
N86178716: LED1.1 R910.1
N86209671: LED2.1 R911.1
N86209740: LED3.1 R912.1
N86209815: LED4.1 R913.1
N86209896: LED5.1 R916.1
N86222873: Q317.5 Q317.6 R909.1
N86223054: Q318.5 Q318.6 R915.1
N86223355: Q319.5 Q319.6 R918.1
N86223600: Q320.5 Q320.6 R920.1
N88409051: C1141.1 R976.2
N88620271: DH4.2 RH259.1
N89386241: RD39.2 UD17.1
N89389377: RD40.2 UD17.2
N89456409: RD41.2 UD18.1
N89456446: RD42.2 UD18.2
N90173610: CV1.1 CV2.1 CV14.1 CV15.1 FV1.2 JMDP1.20 RV1.1
N93046705: T224.1(TP-1) UCPU1.G58
N93049125: T225.1(TP-1) UCPU1.E55
N93049404: T226.1(TP-1) UCPU1.E59
N93049685: T227.1(TP-1) UCPU1.G55
N93049968: T228.1(TP-1) UCPU1.G59
N93050253: T229.1(TP-1) UCPU1.H60
N93050540: T231.1(TP-1) UCPU1.J61
N93050829: T230.1(TP-1) UCPU1.J59
N93297412: Q305.5 Q305.6 R542.2
N93297423: Q305.3 R541.2
N96981838: JBL1.3 R944.2
N98615300: CH94.1 RH256.1
N104496657: T123.1(TP-1) UH1.H2
N141332713: PC746.2 PR748.2 PU700.15
N141350441: PC746.1 PR750.2
N141612052: PC701.2 PR703.1
N141616081: PC703.1 PR705.1
N141681282: PH701.1 PR706.1
N141712369: PC712.1 PR712.2 PU700.40
N141714393: PC712.2 PR707.1

Pads without a net: D90 4 6; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JBATT9 3; JBL1 2; JKB1 28 29; JSATA1 1 3 5 6 7 11 13 17 19 28 30 32 42 44 46 48; JWLAN1 3 5 42 44 45 46 47; PD902 3; PD905 3; PU400 1 7; PU401 1 7; PU700 2 11 13 27 28 29 30 36; U635 1; U636 A2 A3 B3 B6 C4 C8 D2 D3 D5 E1 E2 E3 E6 F1 F3 F4 G1 G2 G3 G4 G7 H4 H5 H6 H7; U637 8; U652 6 12 13 14; UCPU1 A4 A8 A11 A15 A19 A23 A58 AE6 AE7 AE10 AE11 AG13 AH2 AM14 AM15 AT21 AT40 AT49 AU19 AU21 AU40 AV19 AY21 AY22 B6 B10 B14 B18 B22 BA19 BA22 BA36 BA41 BA43 BB19 BB21 BB26 BB36 BC41 BC43 BD1 BD21 BD22 BD25 BD26 BD61 BE22 BE24 BE26 BE47 BF23 BF27 BG4 BG22 BG26 BG47 BG58 BG59 BG61 C5 C8 C9 C11 C13 C15 C17 C19 C21 C23 C57 D1 D8 D9 D12 D13 D16 D17 D19 D21 D23 D24 D61 E5 E14 E21 F6 F8 F10 F14 F17 F21 F22 G8 G10 G13 G17 G19 G22 H6 H8 H13 H19 H22 H43 H45 J4 J14 J21 K4 K6 K7 K10 K13 K15 K17 K19 K22 K24 K43 K45 L42 L45 L47 M10 M13 M14 N42 N50 P13 U14 W14; UD1 A3 A7 F1 F9 H1 H9; UD2 A3 A7 F1 F9 H1 H9; UD3 A3 A7 F1 F9 H1 H9; UD4 A3 A7 F1 F9 H1 H9; UD5 A3 A7 F1 F9 H1 H9; UD6 A3 A7 F1 F9 H1 H9; UD7 A3 A7 F1 F9 H1 H9; UD8 A3 A7 F1 F9 H1 H9; UD9 A3 A7 F1 F9 H1 H9; UD10 A3 A7 F1 F9 H1 H9; UD11 A3 A7 F1 F9 H1 H9; UD12 A3 A7 F1 F9 H1 H9; UD13 A3 A7 F1 F9 H1 H9; UD14 A3 A7 F1 F9 H1 H9; UD15 A3 A7 F1 F9 H1 H9; UD16 A3 A7 F1 F9 H1 H9; UH1 A4 A5 A7 A27 A31 A35 A48 A49 A51 AB6 AB40 AB42 AB44 AB46 AC1 AC3 AD2 AD4 AD6 AD8 AD10 AD40 AD42 AD44 AD46 AE1 AE3 AE49 AE51 AF40 AF42 AF44 AF46 AG1 AG3 AG49 AG51 AH6 AH8 AH40 AH42 AH44 AH46 AH48 AH50 AJ1 AJ3 AJ49 AJ51 AK40 AK42 AK44 AK46 AL1 AL3 AL49 AL51 AM4 AM48 AM50 AN6 AN8 AN40 AN42 AN44 AN46 AN49 AN51 AR1 AR3 AR40 AR42 AR44 AR46 AR49 AR51 AT2 AT4 AT48 AT50 AU6 AU8 AU40 AU42 AU49 AU51 AW1 AW3 AW49 AW51 AY2 AY4 AY6 AY8 AY30 AY33 AY35 AY37 AY40 AY42 AY44 AY46 AY48 AY50 B24 B28 B32 B36 BA1 BA3 BA49 BA51 BB6 BB30 BB33 BB35 BB37 BB40 BB42 BB44 BB46 BC1 BC3 BC49 BC51 BD2 BD4 BD28 BD30 BD35 BD37 BD48 BD50 BE1 BE3 BE6 BE46 BE49 BE51 BF6 BF7 BF28 BF30 BF35 BF37 BF45 BF46 BG1 BG3 BH1 BH3 BH4 BH16 BH20 BH24 BH40 BH49 BH51 BJ1 BJ3 BJ4 BJ5 BJ7 BJ29 BJ31 BJ33 BJ35 BJ37 BJ39 BJ41 BJ43 BJ48 BJ49 BJ51 BK6 BK16 BK24 BK40 BL1 BL3 BL4 BL5 BL7 BL29 BL31 BL33 BL35 BL37 BL39 BL41 BL43 BL48 BL49 BL51 C3 C27 C31 C35 C49 C51 D1 D20 D24 D28 D32 D51 E1 E3 F26 F28 F33 F37 G49 H26 H28 H33 H40 J1 J51 K15 K28 K30 K35 K46 L3 L51 M8 M28 M30 M35 M40 M46 M50 N49 N51 R42 R44 R46 R49 T50 U40 U44 U46 W40 W42 W44 W46 Y48 Y50; UV1 9 10 11 12 13 14; Y2 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 510 vias
v2: diameter 0.305, hole 0.102, TOP to GND1, 904 vias
v3: diameter 0.305, hole 0.102, GND1 to IN1, 716 vias
v4: diameter 0.457, hole 0.203, IN1 to IN4, 1122 vias
v5: diameter 0.305, hole 0.102, IN4 to GND5, 967 vias
v6: diameter 0.305, hole 0.102, GND5 to BOTTOM, 1374 vias
v7: diameter 0.508, hole 0.254, TOP to BOTTOM, 2234 vias
v8: diameter 0.508, hole 0.229, TOP to BOTTOM, 66 vias
v9: diameter 0.406, hole 0.203, TOP to BOTTOM, 157 vias
v10: diameter 0.483, hole 0.229, TOP to BOTTOM, 671 vias
v11: diameter 0.254, hole 0.102, TOP to GND1, 1 via

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.5V_PG: length 4.2
  TOP w0.122: v1(169.27,38.06) 168.84,38.49 168.84,38.92 PR45.1
  TOP w0.254: v7(167.67,40.37) 167.77,40.27 PR518.2 PR45.1
  BOTTOM w0.254: v7(167.67,40.37) 167.83,40.21 PU401.4
1.5VSP_FB: length 6.3
  TOP w0.122: PR409.1 v1(172.09,42)
  TOP w0.254: v7(172.19,38.54) 172.19,39.1 PC407.2 172.07,39.22 PR408.2 172.07,40.97 PR409.1
  BOTTOM w0.254: v7(172.19,38.54) 172.19,40.12 171.6,40.71 PU401.6
1.5VSP_LX: length 3.8
  TOP w0.122: v1(164.75,38.21) 164.92,38.38 PR406.1
  TOP w0.508: PR406.1 166.43,38.85 167.14,39.56 v7(167.67,39.56)
1.5VSP_VIN: length 1.9
  BOTTOM w0.122: v9(174.53,36.3) 173.95,36.88 PC410.1
1.8V_PG: length 18.2
  TOP w0.122: v2(101.99,51.07) PR517.2 102.84,51.07 v1(103.73,51.96)
  GND1 w0.104: v2(101.99,51.07) v3(102.42,51.07)
  IN1 w0.071: v4(110.8,49.36) 110.75,49.36 110.12,48.73 107.78,48.73 106.28,50.23 106.28,51.42 105.6,52.1 103.65,52.1 102.98,51.43 v4(102.98,51.07) v3(102.42,51.07)
  IN4 w0.084: v5(110.8,48.78) v4(110.8,49.36) ; v4(102.98,51.07) 102.37,51.68 v5(102.34,51.68)
  GND5 w0.104: v5(102.34,51.68) v6(102.78,51.68) ; v5(110.8,48.78) v6(110.8,48.32)
  BOTTOM w0.122: PR44.1 v6(110.8,48.32) ; PU400.4 103.05,50.77 102.78,51.04 v6(102.78,51.68)
1.8VSP_FB: length 4.3
  TOP w0.508: PR401.2 PC401.2 ; PC401.2 106.92,51.65 PR404.1 ; PC401.2 106.18,51.04 v7(106.69,50.53)
  BOTTOM w0.305: v7(106.69,50.53) 106.69,50.97 106.39,51.27 PU400.6
1.8VSP_LX:
  vias: v1(101.81,47.26)
1.8VSP_VIN: length 1.3
  BOTTOM w0.122: v1(107.12,46.33) 107.12,46.95 106.88,47.19 106.88,47.51
1.35V_B+: length 23.5
  TOP w0.254: PC303.1 27.29,22.29 PR305.1 27.29,21.12 26.86,20.69 v7(26.84,20.69)
  IN1 w0.254: v7(26.84,20.69) 27.62,20.69 28.89,19.42 29.42,19.42 30.08,20.08 32.44,20.08 32.75,19.77 32.75,18.99 32.93,18.81 44.94,18.81 45.7,19.57 45.7,19.6 46.16,20.05 v7(46.18,20.05)
  vias: v7(46.46,22.44) v7(46.82,20.04) v7(47.1,22.44) v7(47.45,20.04) v9(45.24,22.42)
1.35V_FB: length 4.8
  TOP w0.203: PU300.6 29.28,22.77 28.9,23.15 28.9,23.46 PR304.1
  TOP w0.254: PR307.1 26.74,23.58 27.17,24.02 PC314.1 PR304.1
1.35V_TON: length 2
  TOP w0.254: PU300.9 29.37,21.57 29.06,21.26 29.05,21.26 28.84,21.04 28.51,21.04 PR305.2
+0.675VS: length 165.4
  IN2 w0.508: 43.92,25.06 46.51,27.65 48.72,27.65 49.61,26.76 56.62,26.76 57.26,26.12 57.77,26.12 57.89,26.25 59.65,26.25 60.46,25.44 60.46,24.37 57.84,24.37 56.34,25.87 49.18,25.87 48.78,26.28 46.9,26.28 45.45,24.83 44.16,24.83 43.92,25.06
  IN2 w1.016: 60.46,24.37 60.46,22.42 63.76,19.11 v7(65.89,19.11) ; 30.72,23.46 33.99,23.46 34.55,24.02 39.25,24.02 40.3,25.06 43.92,25.06
  IN3 w0.508: v7(57.13,47.92) 57.44,47.62 57.44,47.13 56.98,46.67 55.35,46.67 54.08,47.94 52.28,47.94 50.25,45.91 42.07,45.91 38.36,42.2 32.44,42.2 31.02,40.78 29.47,40.78 28.63,39.94 22.97,39.94 22.38,40.53 22.38,41.72 21.88,42.23 21.34,42.23 19.64,40.53 18.46,40.53 16.94,39 v7(15.98,39)
  IN3 w1.016: 114.87,19.39 114.87,19.39 109.83,19.39 109.65,19.57 105.33,19.57 104.36,20.54 98.3,20.54 97.27,19.51 94.94,19.51 93.89,20.56 87.28,20.56 86.24,19.52 83.93,19.52 82.91,20.54 76.16,20.54 75.75,20.13 ; 17.36,27.85 17.36,25.54 18.07,24.83 24.37,24.83 25.28,23.91 28.54,23.91
  vias: v7(15.98,28.54) v7(16.15,29.2) v7(30.11,24.87) v7(30.11,24.24) v7(66.78,19.09) v7(115.78,19.04) v7(116.42,18.96) v9(118.38,22.48)
+0.675VSP: length 0.9
  TOP w0.254: 31.77,24.4 PU300.2
  vias: v7(32.95,24.36) v7(33.59,24.35) v9(34.22,24.28)
+1.5V_PWROK: length 179.8
  TOP w0.122: R933.2 142.23,68.54 138.48,68.54 138.4,68.47 138.08,68.47 135.02,65.41 135.02,64.59 134.65,64.22 134.65,62.57 133.15,61.07 133.15,57.34 134.28,56.21 134.28,54.08 v7(134.17,53.96) ; PR521.1 27.4,20.24 v2(26.93,19.77) ; v7(81.92,42.63) 81.36,42.07 78.63,42.07 78.56,42.14 76.9,42.14 76.04,43 63.97,43 63.75,42.78 54.78,42.78 54,43.56 49.22,43.56 v1(48.67,43.01) 48.29,42.63 45.48,42.63 45.43,42.59 v7(45.43,42.59)
  GND1 w0.104: v2(26.93,19.77) v3(27.52,19.77)
  IN1 w0.071: v7(45.43,42.59) 45.43,42.56 45.23,42.76 31.99,42.76 28.56,39.33 19.05,39.33 18.94,39.44 18.42,39.44 17.81,38.84 17.81,37.81 16.97,36.97 16.97,30.25 17.2,30.03 17.2,25.94 18.15,24.99 23.84,24.99 24.47,24.37 25.84,24.37 27.03,23.18 27.03,21.48 26.45,20.89 26.45,20.52 27.2,19.77 v3(27.52,19.77)
  IN2 w0.094: v7(81.92,42.63) 82.52,42.63 93.31,53.43 94.18,53.43 97.48,56.73 102.88,56.73 104.81,54.8 106.37,54.8 106.84,54.33 107.25,54.33 107.93,53.66 118.65,53.66 119.39,52.92 121.8,52.92 122.22,53.33 128.73,53.33 128.8,53.26 131.67,53.26 131.86,53.45 133.66,53.45 v7(134.17,53.96)
+1.05VM_VCCSUS: length 16.1
  TOP w0.122: v7(93.53,67.04) 93.17,67.4 v1(92.89,67.4)
  TOP w0.508: CH76.1 v2(101.7,69.37)
  GND1 w0.508: v2(101.7,69.37) v3(102.14,69.37)
  IN1 w0.508: v3(102.14,69.37) v4(102.62,69.37)
  IN3 w0.508: v7(93.53,67.04) 94.01,67.53 97.24,67.53 97.44,67.73 100.54,67.73 102.18,69.37 v4(102.62,69.37)
  IN4 w0.279: v4(102.62,69.37) 102.62,69.76 102.78,69.92 v5(102.78,70.13)
  GND5 w0.279: v5(102.78,70.13) 102.47,69.82 v6(102.47,69.79)
  BOTTOM w0.279: UH1.AU33 UH1.AR33 v6(102.47,69.79)
  BOTTOM w0.508: RH234.1 92.59,67.98 v7(93.53,67.04)
+1.5VS: length 96.4
  TOP w0.508: v7(170.82,45.61) 170.82,45.66 171.35,46.18 R296.1 ; v7(102.5,55.59) 102.5,55.6 102.83,55.92 102.83,55.94 RH211.2 ; v2(174.73,41.29) v9(174.73,39.13) 174.73,36.89
  GND1 w0.508: v2(174.73,41.29) v3(174.73,41.72)
  IN1 w0.508: v4(174.68,42.2) 174.68,41.77 v3(174.73,41.72)
  IN2 w0.508: v7(166.5,43.42) 164.73,43.42 163.56,44.59 v7(158.83,44.59) ; v4(174.68,42.2) 174.2,42.2 172.55,43.85 171.15,43.85 170.47,44.54 170.47,45.25 v7(170.82,45.61) ; v7(102.5,55.59) 102.5,53.37 103.45,52.43 105.94,52.43 106.28,52.08 118.83,52.08 119.02,51.89 122.38,51.89 122.87,52.38 125.49,52.38 126.19,51.68 126.77,51.68 127.3,52.21 131.88,52.21 132.28,51.82 132.89,51.82 133.28,52.21 133.84,52.21 134.32,51.73 136.34,51.73 137.29,50.77 138.01,50.77 140.74,48.04 142.21,48.04 143.71,46.55 144.83,46.55 146.15,45.22 153.6,45.22 154.07,44.75 156.78,44.75 157.25,44.28 157.87,44.28 v7(158.2,43.95)
  BOTTOM w0.508: v7(166.5,43.42) 166.5,43.11 167.05,42.56 167.62,42.56 167.91,42.85 168.7,42.85 170.49,44.64 170.49,45.25 170.82,45.58 v7(170.82,45.61)
  BOTTOM w1.016: v7(158.83,44.59) v7(158.2,43.95) 156.9,42.66 156.9,40.98
+1.5VS_D: length 3.1
  TOP w0.122: v1(167.43,46.76) Q34.1
  TOP w0.508: R296.2 169.54,47.08 Q34.1
+1.5VS_PWROK: length 50.4
  TOP w0.122: v7(167.82,43.9) 168.03,43.7 168.03,41.49 PR518.1 ; R982.2 v8(144.84,69.05)
  IN1 w0.071: v7(165.59,58.97) 164.15,60.4 159.66,60.4 158.56,61.5 158.3,61.5 158.15,61.65 155.23,61.65 151.58,65.3 151.58,65.68 148.89,68.38 147.64,68.38 146.97,69.05 v8(144.84,69.05)
  BOTTOM w0.122: v7(167.82,43.9) 165.26,43.9 164.32,44.84 164.32,48.69 164.91,49.29 164.91,54.57 163.25,56.23 163.25,58.41 163.81,58.97 v7(165.59,58.97)
+1.05VS_SATA3: length 28.4
  TOP w0.254: v2(106.2,62.01) 105.75,61.56 CH70.1
  GND1 w0.381: v3(105.95,61.58) 105.95,61.76 v2(106.2,62.01)
  IN1 w0.305: v3(105.95,61.58) 105.95,61.38 v4(106.28,61.05)
  IN3 w0.508: v4(106.28,61.05) 106.28,60.78 103.35,57.85 96.2,57.85 94.16,59.88 94.16,62.98 v4(95,63.82)
  IN4 w0.279: v5(108.01,61.05) v5(106.76,61.05) v4(106.28,61.05)
  IN4 w0.508: v4(95,63.82) 95,65.16 95,65.16 v5(95.03,65.16)
  GND5 w0.279: v6(106.36,61.05) v5(106.76,61.05) ; v6(108.41,61.05) v5(108.01,61.05)
  GND5 w0.508: v5(95.03,65.16) v6(94.6,65.16)
  BOTTOM w0.279: UH1.AA13 v6(108.41,61.05) ; UH1.AG13 v6(106.36,61.05)
  BOTTOM w0.508: RH233.2 93.17,66.51 v9(93.95,65.73) 94.52,65.16 v6(94.6,65.16)
+1.05VS_VCC_SATA: length 7.4
  TOP w0.305: v2(108.13,61.33) 108.13,61.43 108.49,61.78 CH75.1 108.59,60.8 RH41.2 108.25,60.46 RH292.2
  GND1 w0.305: v3(108.01,61.81) 108.13,61.68 v2(108.13,61.33)
  IN1 w0.305: v4(108.13,62.32) 108.01,62.19 v3(108.01,61.81)
  IN4 w0.305: v5(108.52,61.94) v4(108.13,62.32)
  GND5 w0.254: v5(108.52,61.94) 108.77,62.19 v6(108.77,62.32)
  BOTTOM w0.254: UH1.AC13 107.88,61.7 UH1.AC15 UH1.AB15 108.41,61.96 v6(108.77,62.32)
+1.05VS_VCCA_A_DPL: length 17.8
  TOP w0.508: v7(94.06,77.53) 94.47,77.53 v9(96.27,75.73) 98.25,73.75 98.25,72.53 97.73,72 CH87.1 v2(97.59,71.46)
  GND1 w0.508: v2(97.59,71.46) v3(97.59,71.87)
  IN1 w0.508: v3(97.59,71.87) 97.06,71.87 v4(96.93,72)
  IN4 w0.279: v4(96.93,72) 96.93,72.02 97.14,72.22 v5(97.39,72.22)
  GND5 w0.279: v6(97.7,72.53) v5(97.39,72.22)
  BOTTOM w0.279: v6(97.7,72.53) 97.99,72.24 UH1.BF40
  BOTTOM w0.508: CH86.1 89.22,73.29 90.93,74.99 91.61,74.99 94.06,77.44 v7(94.06,77.53)
+1.05VS_VCCA_B_DPL: length 17.4
  TOP w0.508: v2(99.4,72.1) CH89.1
  GND1 w0.508: v2(99.4,72.1) 99.37,72.07 v3(99.37,71.69)
  IN1 w0.508: v3(99.37,71.69) 99.17,71.49 v4(98.84,71.49)
  IN3 w0.508: v4(88.35,68.24) 90,69.89 91.02,69.89 92.67,71.54 93.45,71.54 94.37,70.62 97.97,70.62 v4(98.84,71.49)
  IN4 w0.254: v4(98.84,71.49) 98.75,71.49 v5(98.42,71.82)
  IN4 w0.508: v5(87.76,68.24) v4(88.35,68.24)
  GND5 w0.254: v6(98.42,72.24) v5(98.42,71.82)
  GND5 w0.508: v6(87.27,68.24) v5(87.76,68.24)
  BOTTOM w0.122: v1(86.62,67.53) 87.36,67.53
  BOTTOM w0.254: UH1.BD40 v6(98.42,72.24)
+1.05VS_VCCAPLL_FDI: length 35.9
  TOP w0.381: v2(102.88,61.84) 102.88,61.32 CH46.1
  GND1 w0.381: v2(102.88,61.84) 102.88,61.62 103.08,61.42 v3(103.08,61.4)
  IN1 w0.381: v3(103.08,61.4) 103.08,61.86 v4(103.05,61.89)
  IN3 w0.254: 92.15,65.25 96.74,65.25 97.66,64.34 97.66,63.83 97.9,63.59 98.86,63.59 99.27,63.18 99.27,63.06 99.7,62.62 100.62,62.62 101.33,61.91 101.73,61.91 102.24,62.42 102.67,62.42 103.05,62.04 v4(103.05,61.89) 102.85,61.68 102.85,61.05 102.45,60.64 101.78,60.64 101.27,61.16 101.27,61.24 100.88,61.63 98.46,61.63 97.16,62.93 97.16,63.92 96.76,64.33 91.83,64.33 v4(91.52,64.63) 92.15,65.25
  IN4 w0.071: v5(103.44,61.51) v4(103.05,61.89)
  IN4 w0.508: v5(91.98,64.86) 91.75,64.86 v4(91.52,64.63)
  GND5 w0.254: v5(103.44,61.51) 103.44,61.94 v6(103.13,62.24)
  GND5 w0.508: v5(91.98,64.86) 92.11,64.73 v6(92.11,64.17)
  BOTTOM w0.122: v1(91.89,63.61) 91.96,63.68 91.96,64.02 v6(92.11,64.17)
  BOTTOM w0.279: UH1.AP13 103.05,61.75 UH1.AP15 v6(103.13,62.24)
  BOTTOM w0.508: RH208.1 92.59,64.66 v6(92.11,64.17)
+1.05VS_VCCPQ: length 33.3
  TOP w0.254: CC224.1 70.48,64.46 v2(70.85,64.1)
  GND1 w0.254: v2(70.85,64.1) v3(70.85,64.53)
  IN1 w0.254: v3(70.85,64.53) 71.64,64.53 v4(71.66,64.5)
  IN3 w0.254: v7(88.53,46.19) 88.53,46.65 77.95,57.22 76.87,57.22 75.02,59.07 73.59,59.07 72.93,59.73 72.93,60.24 72.55,60.62 72.55,61.1 72.78,61.33 72.78,62.34 72.12,63 72.12,63.82 71.66,64.27 v4(71.66,64.5)
  IN4 w0.254: v4(71.66,64.5) 71.56,64.4 v5(71.15,64.4)
  GND5 w0.254: v6(70.72,64.4) v5(71.15,64.4)
  BOTTOM w0.122: v7(88.53,46.19) 87.56,46.19 v1(87.27,45.9)
  BOTTOM w0.254: UCPU1.AM25 70.6,64.4 v6(70.72,64.4) 71.04,64.08 UCPU1.AN22 ; v7(88.53,46.19) 88.58,46.14 RH280.2
+1.5VS_WLAN: length 37.3
  TOP w0.381: v2(180.87,26.98) 180.56,26.67 180.02,26.67 C710.1
  TOP w0.508: C708.1 180,36.95 181.6,38.55 JWLAN1.28 ; JWLAN1.48 181.52,46.55 180.65,45.68 v9(180.65,45.66) 180.65,44.67 179.89,43.9 C709.1 ; C710.1 179.79,26.38 180.14,26.03 181.11,26.03 181.64,26.55 JWLAN1.6
  GND1 w0.508: v2(180.87,26.98) v3(180.87,27.42)
  IN1 w0.508: v3(180.87,27.42) v4(180.87,27.9) ; JWLAN1.28 181.82,38.55 181.3,39.08 181.3,46.06 181.78,46.55 JWLAN1.48
  IN4 w0.508: JWLAN1.28 181.81,38.55 181.21,39.15 180.75,39.15 179.61,38.01 179.61,31.33 180.87,30.07 v4(180.87,27.9)
+1.8VS:
  vias: v9(89.64,50.28)
+1.8VS_PWROK: length 59.7
  TOP w0.122: v2(103.54,55.36) 103.42,55.24 103.42,52.25 103.16,51.98 PR517.1 ; v2(133.94,55.99) 133.94,56.15 132.81,57.28 132.81,61.11 134.39,62.69 134.39,64.47 v1(134.68,64.76) 134.68,65.42 137.98,68.72 138.25,68.72 138.32,68.8 142.86,68.8 R934.2
  GND1 w0.104: v2(133.94,55.99) 133.94,55.77 v3(134.2,55.51) ; v2(103.54,55.36) 103.66,55.49 v3(103.99,55.49)
  IN1 w0.071: v3(134.2,55.51) 133,54.32 v4(133,53.86)
  IN1 w0.084: v4(105.29,55.51) 105.29,55.56 104.87,55.98 104.49,55.98 v3(103.99,55.49)
  IN2 w0.094: v4(133,53.86) 131.86,53.86 131.46,53.46 128.88,53.46 128.81,53.53 122.03,53.53 121.93,53.43 120.8,53.43 120.37,53.86 108,53.86 107.33,54.53 107.09,54.53 106.51,55.11 105.74,55.11 105.34,55.51 v4(105.29,55.51)
+1.8VS_VCCPLL:
  vias: v9(87.41,54.63)
+1.35V: length 157
  TOP w0.254: UD2.G8 109.49,28.6 v10(109.88,28.21) ; v7(152.18,68.19) 152.08,68.08 R289.1 ; v10(54.55,36.88) 54.55,36.88 UD10.C1 ; RD21.1 116.53,38.01 114,38.01 110.55,34.56 v10(110.55,34.35)
  TOP w0.305: UD16.C1 21.41,36.88 v10(21.4,36.88) ; UD2.C1 103.19,31.8 v10(103.19,31.8)
  TOP w0.508: RD18.1 18.22,43.27 18.57,43.27 19.13,42.71 v7(19.13,41.54) ; RC75.1 49.97,49.35 50.4,48.92 v7(50.4,48.78)
  IN3 w0.254: v10(110.44,22.81) 111.85,22.81 114.36,20.31 116.72,20.31 117.33,19.7 132.24,19.7 134.35,21.81 140.27,21.81 142.81,24.35 142.81,24.52 v7(142.83,24.55)
  IN4 w0.254: v5(98.66,31.92) 98.66,34.2 v10(99.32,34.86) ; v10(110.55,34.35) 109.89,33.69 v5(109.89,31.99) ; v5(153.69,46.49) 154.16,46.02 155.18,46.02 155.48,45.72 159.29,45.72 159.5,45.5 163.72,45.5 164.98,46.76 167.04,46.76 170.85,42.95 171.22,42.95 172.55,41.62 172.55,39.12 172.9,38.78 172.9,30.73 170.49,28.32 170.49,25.48 169.3,24.3 163.91,24.3 163.43,24.78 149.39,24.78 148.63,24.02 143.31,24.02 142.83,24.5 v7(142.83,24.55)
  GND5 w0.254: v5(109.89,31.99) 109.89,31.61 v6(109.86,31.58) ; v6(152.94,47.13) 153.58,46.49 v5(153.69,46.49) ; v6(98.81,31.53) 98.81,31.76 v5(98.66,31.92)
  BOTTOM w0.254: v6(152.94,47.13) 149.37,47.13 148.83,47.68 148.83,56.83 152.18,60.19 v7(152.18,68.19)
  BOTTOM w0.508: 51.49,46.06 51.49,48.22 50.93,48.78 v7(50.4,48.78)
  vias: v7(23.12,40.68) v7(30.69,39.64) v7(31.27,40.12) v7(44.89,39.84) v7(55.43,40.35) v7(64.57,20.66) v7(65.21,20.66) v7(65.84,20.66) v7(66.48,20.66) v7(66.76,21.58) v7(67.24,20.66) v7(67.37,21.55) v7(68,21.55) v7(68,20.66) v7(68.64,21.55) v7(68.64,20.66) v7(69.25,20.64) v7(69.4,21.55) v7(70.09,21.53) v7(76.83,19.62) v7(78.54,37.55) v7(82.07,35.29) v7(84.77,35.27) v7(88.86,38.32) v7(92.02,37.83) v7(92.74,37.12) v7(93.17,36.69) v7(93.63,36.26) v7(103.82,34.63) v7(106.56,34.56) v9(73.71,39.79) v10(21.64,34.83) v10(21.68,31.68) v10(21.68,30.08) v10(22.48,38.88) v10(22.51,34.09) v10(28.07,33.29) v10(28.88,30.88) v10(29.1,37.02) v10(29.49,28.43) v10(32.45,36.88) v10(32.69,34.83) v10(32.73,31.68) v10(32.73,30.08) v10(33.52,38.83) v10(33.52,34.07) v10(39.11,33.3) v10(39.93,30.88) v10(40.15,37.02) v10(40.54,28.43) v10(43.5,36.88) v10(43.74,34.83) v10(43.78,31.68) v10(43.78,30.08) v10(44.57,38.88) v10(44.55,34.11) v10(50.18,33.29) v10(50.73,39.89) v10(50.98,30.88) v10(51.2,37.02) v10(51.58,28.43) v10(54.78,34.83) v10(54.83,31.68) v10(54.83,30.08) v10(55.62,38.88) v10(55.61,34.12) v10(61.24,33.28) v10(61.75,39.9) v10(62.03,30.88) v10(62.29,37.02) v10(62.65,28.39) v10(70.04,31.8) v10(70.28,29.75) v10(70.32,26.6) v10(70.32,25) v10(71.12,33.8) v10(71.12,29.04) v10(76.72,28.22) v10(77.27,34.81) v10(77.52,25.8) v10(77.74,31.94) v10(78.13,23.35) v10(81.09,31.8) v10(81.33,29.75) v10(81.37,26.6) v10(81.37,25) v10(82.17,33.8) v10(82.17,29.01) v10(87.77,28.22) v10(88.32,34.81) v10(88.57,25.8) v10(88.79,31.94) v10(89.18,23.35) v10(92.14,31.8) v10(92.38,29.75) v10(92.42,26.6) v10(92.42,25) v10(93.21,33.8) v10(93.2,29.03) v10(98.8,28.2) v10(99.62,25.8) v10(100.23,23.35) v10(103.43,29.75) v10(103.47,26.6) v10(103.47,25) v10(104.26,33.8) v10(104.27,29) v10(110.67,25.8)
+1.35V_CPU_VDDQ: length 64.6
  TOP w0.508: v7(57.79,52.87) 55.79,52.87 55.3,53.35 55.3,55.71 56.02,56.43 58.4,56.43 58.88,56.91 58.88,57.52 59.54,58.18 61.07,58.18 ; 60.88,55.17 RC8.1
  GND1 w0.254: v3(66.07,64.3) v2(66.07,63.87) ; v2(68.76,65.37) 68.76,65.06 v3(68.89,64.94) ; v3(67.47,65.11) v2(67.9,65.11) ; v3(69.93,59.83) v2(70.37,59.83) ; v2(63.13,61.63) 62.97,61.79 v3(62.97,62.09) ; v3(70.85,61.51) v2(70.42,61.51) ; v3(65.08,63.31) v2(65.62,63.31) ; v3(66.66,65.82) v2(67.24,65.82) ; v3(68.94,63.84) v2(68.94,63.41) ; v3(69.93,63.79) v2(69.6,63.46)
  GND1 w0.305: v5(66.71,63.84) v6(67.14,63.84) ; v3(67.11,64.83) v2(67.44,64.5) ; v3(65.29,66.28) v2(65.29,65.85)
  IN1 w0.254: v4(66.07,63.82) v3(66.07,64.3) ; v4(69.93,59.35) v3(69.93,59.83) ; v4(70.85,61.02) v3(70.85,61.51) ; v4(70.42,63.79) v3(69.93,63.79) ; v3(62.97,62.09) 62.97,61.81 63.15,61.63 v4(63.15,61.61) ; v4(67.98,65.11) v3(67.47,65.11) ; v3(68.94,63.84) 68.76,64.02 v4(68.49,64.02) ; v4(69.37,64.94) v3(68.89,64.94) ; v4(65.08,63.79) v3(65.08,63.31) ; v4(67.15,65.82) v3(66.66,65.82)
  IN1 w0.305: v4(67.19,63.84) v5(66.71,63.84) ; v4(65.29,65.8) v3(65.29,66.28) ; v4(66.63,64.83) v3(67.11,64.83)
  IN3 w0.508: v7(56.65,47.43) 56.24,47.84 56.24,48.86 56.78,49.39 56.78,51.88 57.74,52.84 57.77,52.84 v7(57.79,52.87)
  IN4 w0.254: v5(70.42,63.3) v4(70.42,63.79) ; v4(68.49,64.02) 68.82,64.02 v5(68.99,63.84) ; v4(69.93,59.35) 69.7,59.58 v5(69.48,59.58) ; v4(65.08,63.79) 64.95,63.92 v5(64.95,64.66) ; v5(68.46,65.11) v4(67.98,65.11) ; v5(70.42,61.34) 70.53,61.34 v4(70.85,61.02) ; v5(62.67,61.61) v4(63.15,61.61) ; v5(65.56,63.82) v4(66.07,63.82) ; v5(69.37,64.45) v4(69.37,64.94) ; v5(67.15,65.34) v4(67.15,65.82)
  IN4 w0.305: v5(66.71,63.84) v4(67.19,63.84) ; v5(67.14,64.83) v4(66.63,64.83) ; v5(65.77,65.8) v4(65.29,65.8)
  GND5 w0.254: v6(69.98,61.34) v5(70.42,61.34) ; v6(65.38,64.47) 65.15,64.47 v5(64.95,64.66) ; v6(65.56,63.37) v5(65.56,63.82) ; v5(69.48,59.58) 69.37,59.68 69.17,59.68 v6(69.04,59.8) ; v6(68.99,63.4) v5(68.99,63.84) ; v6(67.15,65.8) v5(67.15,65.34) ; v6(68.92,64.45) v5(69.37,64.45) ; v6(68.03,65.11) v5(68.46,65.11) ; v5(62.67,61.61) 62.39,61.61 v6(62.26,61.48) ; v6(69.98,63.3) v5(70.42,63.3)
  GND5 w0.305: v6(67.14,64.4) v5(67.14,64.83) ; v6(67.14,63.84) v5(66.71,63.84) ; v6(65.34,65.8) v5(65.77,65.8)
  BOTTOM w0.254: UCPU1.BA40 64.05,60.17 v7(64.24,60.36) ; v6(69.04,59.8) 68.74,59.5 UCPU1.BB28 ; UCPU1.AN26 69.3,64.08 v6(68.92,64.45) ; v6(67.14,64.4) 67.25,64.4 UCPU1.AN30 ; UCPU1.AR28 v6(68.99,63.4) ; v7(64.45,63.72) 64.8,63.37 UCPU1.AR36 ; UCPU1.AR40 63.64,62.95 v7(63.71,62.95) ; UCPU1.AJ28 68.46,66.18 v7(68.87,66.59) ; v6(65.38,64.47) 65.76,64.08 UCPU1.AN34 ; v6(67.15,65.8) 67.5,65.45 UCPU1.AL30 ; UCPU1.AV41 62.58,61.8 v6(62.26,61.48) ; UCPU1.AJ36 64.82,66.14 v7(64.45,66.51) ; UCPU1.AR32 67.32,63.09 UCPU1.AR30 ; v6(68.03,65.11) 68.38,64.77 UCPU1.AM28 ; UCPU1.AR26 v6(69.98,63.3) ; UCPU1.AW26 v6(69.98,61.34) ; UCPU1.AR34 v6(65.56,63.37)
  BOTTOM w0.305: v7(67.11,66.56) 66.69,66.14 UCPU1.AJ33 ; v6(67.14,64.4) 66.77,64.77 UCPU1.AM33 ; UCPU1.BG33 66.48,56.68 ; UCPU1.AL38 64.08,65.45 64.42,65.11 64.42,65.09 64.45,65.11 64.45,65.09 v7(64.44,65.09) 64.58,65.09 UCPU1.AM36 ; v7(62.72,66.59) 63.12,66.18 UCPU1.AJ40 ; v10(63.76,63.59) 63.76,63.82 64.01,64.07 UCPU1.AN38 ; v7(63.58,65.09) 63.45,65.09 UCPU1.AM40 ; v7(62.69,65.77) 62.67,65.8 62.67,65.75 62.37,65.45 UCPU1.AL42 ; v6(65.34,65.8) 65.41,65.8 65.76,65.45 UCPU1.AL34 ; v6(67.14,63.84) 66.99,63.7 UCPU1.AR32
  BOTTOM w0.508: v7(65.15,53.94) 65.15,54.51 66.48,55.84 66.48,56.68
  vias: v7(64.82,53.28) v7(65.46,53.3) v7(65.79,53.96) v7(66.12,53.28) v7(66.43,53.96) v7(66.76,53.3) v7(67.06,53.96) v7(67.7,53.96) v7(68.33,53.96) v9(66.12,57.26)
+1.35V_CPU_VDDQ_CHG: length 2.6
  BOTTOM w0.122: v1(58.1,47.79) 58.68,47.21 R292.2
  BOTTOM w0.381: Q37.1 R292.2
+1.35V_D: length 2.6
  TOP w0.122: Q35.6 150.96,65.34 151.2,65.1 v1(151.39,65.1) 151.78,65.1 152.08,65.4 R289.2
+1.35VS: length 37.3
  TOP w0.203: v7(29.41,24.28) 29.41,23.76 29.69,23.47 PU300.5
  TOP w0.254: PC312.1 26.79,24.46 27.26,24.93 PC314.2 PR304.2 28.76,24.93 v7(29.41,24.28)
  IN1 w0.508: v7(38.16,22.62) 37.33,22.62 36.5,21.79 34.34,21.79 33.18,22.95 30.5,22.95 29.41,24.04 v7(29.41,24.28)
  IN2 w0.508: v7(56.95,22.58) v7(56.95,23.22) 56.95,23.27 55.11,25.11 49.87,25.11 48.81,24.05 40.78,24.05 39.35,22.62 v7(38.16,22.62)
  vias: v9(63.22,25.97)
+3V_D: length 2.4
  TOP w0.122: Q5.1 133.1,51.14 R298.2 132.71,50.12 132.47,50.12 v1(132.14,49.78)
+3V_PCH: length 178.2
  TOP w0.122: RH145.2 118.86,57.75
  TOP w0.203: RH154.2 149.8,61.12 149.8,61.7 150.04,61.94 150.43,61.94 151.34,62.85 151.34,63.46 v7(151.65,63.77)
  TOP w0.254: CH63.1 112.36,70.07 112.86,70.57 113.82,70.57 114.08,70.32 114.9,70.32 RH42.1 ; v2(111.32,53.14) 111.32,52.03 111.92,51.43 RH91.1 ; v7(127.29,58.05) 127.3,58.07 RH74.2 ; RH75.2 117.49,63.44 v2(117.63,63.58) ; v2(106.85,53.16) 106.69,53.33 RH40.1
  TOP w0.305: RH190.2 119.59,57.7 v2(119.56,57.72) 119.54,57.75 118.86,57.75 ; RH67.2 119.54,58.66 v2(119.56,58.64) ; RH39.1 118.91,55.95 RH188.2 119.03,56.9 v2(119.56,56.9) 119.69,56.77 RH107.2
  TOP w0.381: v7(116.03,53.05) 116.03,53.69 RH38.1 ; v7(128.58,68.41) 129.5,68.41 129.99,67.92 ; 129.99,67.92 130.41,68.34 RH279.1 ; 129.99,67.92 DH2.2 ; R812.2 RH69.2 118.09,53.33 v7(118.37,53.05) 118.09,52.77 RH146.2 ; RH141.2 111.32,53.75 v2(111.32,53.14) ; RH70.2 115.06,53.69 v7(115.06,53.05) ; CC65.1 144.16,47.64 UC1.5
  TOP w0.508: v2(104.27,66.64) 104.34,66.7 CH59.1 104.81,67.38 105.47,68.03 v9(106.48,68.03) 110.98,68.03 RH244.1 ; Q41.1 130.36,58.89 v7(129.42,59.83) ; v7(133.59,51.6) 133.59,51.57 134.01,51.15 R298.1 134.01,50.32 132.67,48.98 v7(132.6,48.98) ; v7(126.52,56.86) 126.14,56.48 RH73.2 ; RH323.2 RH322.2 RH321.2 ; RH323.2 125.06,61.3 125.39,61.63 v7(125.57,61.63) ; RH323.2 RH324.2 ; CC65.1 v7(144.2,48.35) ; RC4.2 138.32,47.5 138.01,47.18 v7(137.85,47.18)
  GND1 w0.254: v2(117.63,63.58) 117.63,63.38 117.83,63.18 v3(117.83,63.16) ; v2(111.92,67.96) v3(111.92,68.36) ; v3(107.26,53.59) 107.18,53.59 106.89,53.3 106.89,53.2 v2(106.85,53.16)
  GND1 w0.381: v2(119.56,56.9) 119.56,56.92 ; 119.56,56.92 v2(119.56,57.72) ; 119.56,56.92 119.62,56.87 120.03,56.87 v3(120.1,56.93) ; v2(114.17,53.15) 114.95,53.15 v7(115.06,53.05) ; v3(112,53.15) 111.98,53.14 v2(111.32,53.14)
  GND1 w0.508: v2(119.56,58.64) v3(120.02,58.64) ; v2(104.27,66.64) v3(104.27,67.04)
  IN1 w0.254: v4(117.23,63.13) 117.26,63.16 v3(117.83,63.16) ; v4(110.73,68.19) 110.9,68.36 v3(111.92,68.36) ; v7(115.06,53.05) 113.32,53.05 112.82,52.54 112.35,52.54 112,52.9 v3(112,53.15) 111.51,53.15 v4(111.44,53.07) 110.98,53.53 108.06,53.53 108,53.59 v3(107.26,53.59)
  IN1 w0.381: v4(120.45,57.29) v3(120.1,56.93)
  IN1 w0.508: v7(136.94,72.2) 136.49,71.75 134.94,71.75 v7(134.14,70.95) 133.31,70.12 129.27,70.12 128.58,69.43 v7(128.58,68.41) ; v7(132.6,48.98) 132.78,48.8 136.46,48.8 137.09,48.17 137.09,47.94 v7(137.85,47.18) 139.88,47.18 141.05,48.35 v7(144.2,48.35) ; v4(119.54,58.64) v3(120.02,58.64) ; v4(103.28,66.84) 103.49,67.04 v3(104.27,67.04)
  IN3 w0.203: v7(134.14,70.95) 134.14,70.5 136.02,68.62 138.48,68.62 138.59,68.73 142.92,68.73 143.77,69.58 146.35,69.58 148.27,67.67 148.27,66.69 149.01,65.95 149.38,65.95 150.22,66.79 150.22,68.11 150.67,68.55 151.23,68.55 151.72,68.06 151.72,63.84 v7(151.65,63.77)
  IN3 w0.508: v7(128.21,63.22) 128.21,63.23 127.85,63.6 127.85,66.15 128.58,66.89 v7(128.58,68.41) 128.29,68.41 125.85,65.98 121.44,65.98 118.93,68.5 113.29,68.5 112.69,69.1 112.01,69.1 111.41,68.5 111.03,68.5 v4(110.73,68.19)
  IN4 w0.254: v5(110.73,67.63) v4(110.73,68.19)
  IN4 w0.305: v5(103.79,66.84) v4(103.28,66.84)
  GND5 w0.254: v6(110.73,67.22) v5(110.73,67.63)
  GND5 w0.305: v6(103.79,67.27) v5(103.79,66.84)
  BOTTOM w0.305: UH1.AM27 v6(103.79,67.27)
  BOTTOM w0.381: 115.12,50.28 116.03,50.28 116.54,50.79 116.54,50.81 116.97,51.24 ; 119.18,51.59 119.91,50.99 120.49,50.99 120.78,51.29 120.78,53.58 v7(121.04,53.84) ; 118.55,51.78 118.55,52.87 v7(118.37,53.05)
  BOTTOM w0.508: CH6.1 124.12,85.39 124.7,85.97 127.29,85.97 127.57,85.69 131.63,85.69 132.65,84.67 132.65,82.36 134.4,80.61 U48.8 134.93,80.55 134.93,79.92 134.49,79.48 RH56.2 134.47,78.93 134.47,76.25 134.91,75.81 136.05,75.81 136.47,75.39 136.47,72.67 v7(136.94,72.2) ; RH118.1 115.17,50.33 115.12,50.28 115.12,49.56 114.45,48.89 RH116.1
  vias: v7(121.67,53.84)
+3V_PCH_DSW: length 32.4
  TOP w0.254: RH311.1 v2(121.75,60.85) ; v2(119.74,55.42) 119.92,55.24 120.34,55.24 120.81,54.78 v9(121.27,54.78) RH214.1 RH312.1 ; v2(111.36,60.28) 111.03,60.28 CH48.1 ; v2(121.7,58.2) 121.27,58.64 RH150.2
  GND1 w0.254: v3(119.69,56.32) 119.69,55.47 v2(119.74,55.42) ; v2(111.36,60.28) 111.49,60.28 v3(111.72,60.51) ; v3(122.13,58.17) 121.73,58.17 v2(121.7,58.2) ; v2(121.75,60.85) 121.67,60.85 v3(121.37,60.54)
  IN1 w0.254: v3(121.37,60.54) 121.09,60.26 v4(120.89,60.26) ; v3(111.72,60.51) 111.35,60.51 v4(110.78,59.93) 111.56,59.93 111.69,60.06 112.06,60.06 113.28,58.84 113.28,58.31 113.19,58.22 113.19,57.86 113.52,57.53 114.47,57.53 114.89,57.95 116.82,57.95 117.18,57.6 118.29,57.6 119.56,56.32 v3(119.69,56.32) 119.67,56.35 119.67,57.19 120.26,57.78 121.65,57.78 122.04,58.17 v3(122.13,58.17) 122.46,58.17 v4(122.62,58.02)
  IN4 w0.254: v4(110.78,59.93) 110.75,59.96 110.75,60.26 v5(111.01,60.52) ; v5(121.52,60.06) 121.32,60.26 v4(120.89,60.26) ; v5(122.01,58.11) 122.53,58.11 v4(122.62,58.02)
  GND5 w0.254: v6(111.18,61.02) 111.18,60.69 v5(111.01,60.52) ; v5(122.01,58.11) 122.01,58.41 v6(121.83,58.6) ; v5(121.52,60.06) v6(121.52,59.63)
  BOTTOM w0.254: UH1.R12 111.26,60.95 v6(111.18,61.02) ; v6(121.83,58.6) 121.52,58.91 v6(121.52,59.63)
+3V_VCCPSPI: length 4.6
  TOP w0.381: RH210.1 108.9,63.49 CH47.1 108.7,63.75 109.23,64.27 v2(109.23,64.33)
  GND1 w0.381: v3(109.15,63.87) 109.15,64.25 v2(109.23,64.33)
  IN1 w0.381: v4(109.56,63.51) 109.56,63.55 109.24,63.87 v3(109.15,63.87)
  IN4 w0.254: v5(109.07,63.51) v4(109.56,63.51)
  GND5 w0.254: v6(109.07,63.92) v5(109.07,63.51)
  BOTTOM w0.254: UH1.Y19 v6(109.07,63.92)
+3VALW: length 611.1
  TOP w0.122: v2(122.23,24.07) 122.23,21.04 v9(122.16,20.97) ; v7(90.53,41.67) 90.53,41.63 v9(89.95,41.05)
  TOP w0.254: v7(167.67,38.48) 167.71,38.51 PR45.2 ; v7(153.35,33.11) 153.35,32.83 153.03,32.51 151.7,32.51 151.65,32.56 PD9.3 ; R977.2 178.04,76.95 177.73,76.64 R543.1 178.14,75.6 178.8,76.26 179.23,76.26 179.46,76.49 179.46,77.13 v7(179.61,77.28) ; v7(181.72,83.71) 181.52,83.91 180.27,83.91 179.89,83.53 179.89,82.33 180.89,81.33 180.89,79.91 PR910.2
  TOP w0.381: v2(122.23,24.07) PR916.2
  TOP w0.508: v7(204.24,56.64) 204.24,55.32 R806.1 ; v7(130.44,55.03) 131.33,55.92 Q41.3 131.17,56.71 129.8,55.33 v7(129.8,55.03) ; R1102.1 151.85,70.21 152.36,70.71 152.36,71.74 v7(152.46,71.84) ; v7(165.87,45.33) 166.06,45.52 R1024.1 ; v7(15.6,18.96) 15.55,19.01 C1100.2 ; v7(224.82,25.47) 224.22,25.47 223.86,25.11 221.24,25.11 220.82,24.69 R906.2 ; R216.1 136.71,48.15 v7(136.23,48.15) ; v7(127.38,27.55) 127.83,27.55 128.65,28.36 PR961.1 ; v2(229.32,12.73) 229.29,12.71 R908.2 ; Q47.3 183.4,72.29 182.15,71.04 C617.2 182.33,70.7 182.33,69.81 181.95,69.43 181.16,69.43 181.06,69.53 v7(181.03,69.53) ; RH312.2 124.37,53.38 124.14,53.61 124.14,53.87 v7(123.95,54.06) ; R542.1 v7(166.08,86.47) ; v7(199.85,81.11) PR901.2 ; v7(208.77,58.41) R887.1
  GND1 w0.254: v2(229.31,3.97) v3(229.31,4.55) ; v2(225.1,7.39) v3(225.1,7.86) ; v2(229.29,8.54) v3(229.29,9) ; v2(229.31,6.13) v3(229.8,6.13) ; v2(225.11,4.09) v3(225.62,4.09) ; v2(225.1,9.8) v3(225.1,9.27) ; v2(225.1,11.33) v3(225.1,10.67) ; v2(229.32,12.73) v3(229.32,13.3)
  GND1 w0.381: v2(122.23,24.07) v3(122.23,23.08)
  IN1 w0.254: v7(190.53,19.39) 190.53,19.72 189.72,20.54 187,20.54 v7(186.01,19.55)
  IN1 w0.508: v7(22.99,44.66) 22.99,43.71 21.59,42.3 20.12,42.3 19.59,42.84 18.58,42.84 17.14,41.4 17.14,40.88 16.51,40.25 16.33,40.25 15.3,39.22 15.3,30.11 14.9,29.71 14.9,29.23 14.74,29.07 14.74,26.99 14.46,26.71 14.46,23.58 15.65,22.39 15.65,19.01 v7(15.6,18.96) ; v3(229.8,6.13) 229.31,5.64 v3(229.31,4.55) 228.85,4.09 v3(225.62,4.09) 225.62,4.72 225.94,5.04 225.94,5.63 225.64,5.93 225.38,5.93 225,6.31 225,7.76 v3(225.1,7.86) v3(225.1,9.27) v3(225.1,10.67) 224.97,10.8 224.97,12.33 225.41,12.76 228.53,12.76 228.63,12.66 ; 228.63,12.66 229.27,13.3 v3(229.32,13.3) 229.32,18 225.97,21.35 ; 228.63,12.66 228.63,9.66 v3(229.29,9) ; v7(181.72,83.71) 187.93,83.71 188.37,84.15 192.07,84.15 v7(193.29,85.37) ; v3(122.23,23.08) v4(122.23,23.58) v4(122.23,24.3) 122.23,26.67 124.24,28.68 126.25,28.68 v7(127.38,27.55) ; v7(135.85,83.88) 135.85,83.15 137.7,81.29 144,81.29 145.57,82.87 150.43,82.87 153.25,85.69 162.29,85.69 162.69,85.28 165.44,85.28 166.08,85.92 v7(166.08,86.47) ; v7(224.82,25.47) 223.7,24.35 223.7,23.2 224.21,22.69 224.62,22.69 225.97,21.35 ; 225.97,21.35 225.84,21.35 225.18,20.69 223.96,20.69 222.41,19.14 190.79,19.14 v7(190.53,19.39)
  IN2 w0.254: v7(190.53,19.39) 190.53,19.75 189.75,20.54 187,20.54 v7(186.01,19.55) ; v7(15.6,18.96) 15.6,19.44 16.06,19.9 v7(25.65,19.9)
  IN2 w0.508: v7(152.46,71.84) 152.14,71.84 149.4,74.59 v7(147.12,74.59) ; v7(204.24,56.64) 204.32,56.73 207.4,56.73 208.77,58.1 v7(208.77,58.41) 209.25,58.9 209.25,72.68 206.55,75.38 201.47,75.38 199.14,77.71 195.58,77.71 194.01,79.29 190.92,79.29 188.67,77.03 188.67,75.88 188.01,75.22 187.89,75.22 182.1,69.43 181.16,69.43 181.06,69.53 v7(181.03,69.53) ; v7(90.53,41.67) 90.94,42.08 92.72,42.08 98,47.36 99.96,47.36 100.59,47.99 106.15,47.99 107.32,49.16 v7(109.33,49.16) ; v4(122.23,23.58) v4(122.23,24.3)
  IN3 w0.508: v7(22.99,44.66) 22.99,43.78 24.47,42.3 30.51,42.3 32.02,43.81 36.57,43.81 49.88,57.12 49.88,66.57 50.43,67.12 50.43,69.56 52.64,71.77 52.64,71.78 53.27,72.41 53.78,72.41 54.19,72 59.19,72 60.38,73.19 60.38,73.95 61.81,75.37 72.85,75.37 74.78,73.44 75.06,73.44 76.94,71.56 76.94,70.14 77.22,69.86 77.22,68.67 77.63,68.26 78.77,68.26 79.05,67.98 80.07,67.98 80.55,67.5 85.02,67.5 85.58,66.94 88.83,66.94 89.54,67.65 90.53,67.65 92.77,69.89 98.11,69.89 102.2,73.98 111.59,73.98 112.58,72.99 119.51,72.99 120.02,73.49 122.36,73.49 123.22,74.36 124.16,74.36 125.2,73.32 129.42,73.32 v7(129.85,73.75)
  IN4 w0.508: 152.69,31.41 152.69,32.45 v7(153.35,33.11) ; 152.69,31.41 152.71,31.41 157.08,27.04 160.53,27.04 161.82,25.74 166.43,25.74 170.21,29.53 170.21,30.11 168.97,31.36 168.97,34.68 v7(169.68,35.39) ; 152.69,31.41 152.15,30.87 150.5,30.87 145.24,25.62 142.29,25.62 141.27,24.59 138.25,24.59 135.64,21.98 134.25,21.98 132.29,20.03 129.51,20.03 126.33,23.2 122.61,23.2 v4(122.23,23.58) ; v7(147.12,74.59) 141.66,74.59 138.92,77.33 138.11,77.33 ; v7(181.72,83.71) 181.72,82.69 180.99,81.97 178.23,81.97 v7(177.43,81.17) 177.02,80.76 177.02,78.3 178.04,77.28 v7(179.61,77.28)
  BOTTOM w0.254: v7(177.43,81.17) 177.43,81.02 177.24,80.84 JLVDS2.17 ; PR38.2 153.15,34.66 153.74,34.07 153.74,33.5 v7(153.35,33.11) ; JIOL1.7 v7(15.6,18.96) ; v7(25.65,19.9) 25.81,19.74 26.37,19.74 26.82,20.18 27.11,20.18 27.43,20.5 27.43,21.2 PR48.1
  BOTTOM w0.508: v7(186.01,19.55) 180.78,19.55 175.14,25.18 175.14,28.03 175.93,28.82 175.93,33.11 174.94,34.1 171.53,34.1 170.75,34.89 ; v7(199.85,81.11) 196.62,81.11 194.14,83.59 194.14,84.54 193.31,85.37 v7(193.29,85.37) ; v7(90.53,41.67) 83.8,41.67 80.64,44.83 RC102.1
  vias: v7(108.59,50.38) v7(109.23,50.43) v7(109.33,49.8) v7(109.86,50.53) v7(109.96,49.8) v7(109.96,49.16) v7(110.5,50.53) v7(121.29,84.23) v7(121.29,83.59) v7(121.93,84.23) v7(121.93,83.59) v7(122.56,84.23) v7(122.56,83.59) v7(123.2,84.23) v7(123.2,83.59) v7(129.75,50.05) v7(129.75,49.42) v7(129.75,48.78) v7(130.39,50.05) v7(130.39,49.42) v7(130.39,48.78) v7(130.39,48.15) v7(131.02,48.78) v7(131.02,48.15) v7(134.37,75.15) v7(134.37,74.51) v7(135.01,75.15) v7(135.01,74.51) v7(135.64,75.15) v7(135.64,74.51) v7(170.31,35.39) v7(170.64,53.73) v7(170.7,55.03) v7(170.67,54.37) v7(171.3,54.52) v7(171.41,50.89) v7(171.41,50.25) v7(171.41,49.62) v7(171.43,48.98) v7(172.04,50.25) v7(172.04,49.62) v7(172.07,50.89) v7(172.07,48.98) v7(179.25,65.01) v7(179.25,64.38) v7(179.25,63.74) v7(179.25,63.11) v7(179.89,65) v7(179.89,64.36) v7(179.89,63.73) v7(179.89,63.09) v9(178.14,64.12)
+3VALW_EC: length 378.5
  TOP w0.178: v2(140.34,58.99) 140.29,58.99 140.23,59.05 140.23,60.57 140.58,60.92 141.03,60.92 141.35,60.6 U34.J4
  TOP w0.203: U34.J7 U34.K7 ; v2(140.72,56.93) 140.62,57.04 140.35,57.04 139.92,56.6 U34.M12
  TOP w0.254: v2(140.72,56.93) 140.92,56.74 U34.K12 ; R954.2 v7(142.17,65.87) ; v7(146.64,68.61) 147,68.25 147,67.72 R987.2 ; U34.K7 140.86,59.1 140.75,58.99 v2(140.34,58.99)
  TOP w0.381: R603.1 143.92,65.28 143.52,65.68 v7(143.52,65.87)
  TOP w0.508: v7(148.37,65.23) 148.58,65.02 R981.2 ; v7(149.28,61.71) 149.18,61.81 148.83,61.81 R922.2 ; R221.2 138.44,52.43 C280.2 C281.2 139.39,51.16 v7(139.5,51.04) 138.76,50.29 R811.2 ; 146.4,47.99 144.7,49.7 144.7,50.01 143.71,51 L43.1 142.64,50.07 140.95,50.07 140.94,50.07 R811.2 ; 146.4,47.99 147.31,48.9 R219.2 147.94,49.36 148.61,50.04 C278.1 C279.1 148.58,52.96 R241.2 v2(149.18,53.81) ; 146.4,47.99 146.4,46.6 147.54,45.45 148.42,45.45 149.7,46.74 150.3,46.74 150.87,46.16 159.1,46.16 159.34,46.41 159.34,46.81 159.61,47.08 162.52,47.08 164.07,45.53 164.07,43.95 165.21,42.81 165.21,39.53 164.12,38.44 164.12,37.27 165.01,36.38 v7(165.54,36.38) ; R230.2 148.85,57.49 148.95,57.39 v2(149.31,57.39) 149.31,55.77 v2(149.28,55.74) 149.24,55.7 R229.2 ; R1021.2 138.38,65.61 138.38,66.26 v7(137.93,66.71) 137.65,66.71 136.84,65.9 136.84,64.98 C277.1 C276.1 ; R811.2 R216.2 137.11,50.07 136.48,50.69 136.48,51.7 135.69,52.49 135.69,54.9 135.75,54.95 ; v7(141.47,68.08) 141.81,67.75 R930.1 ; 135.75,54.95 R604.1 ; 135.75,54.95 135.35,54.95 135.11,55.19 135.11,56.73 136.04,57.66 R935.2
  GND1 w0.254: v3(140.29,57) 140.51,57 140.57,56.93 v2(140.72,56.93)
  GND1 w0.305: v2(140.34,58.99) 140.25,58.9 v3(140.25,58.41)
  GND1 w0.381: v2(149.31,57.39) 149.49,57.39 v3(149.89,57.8)
  GND1 w0.508: v2(149.28,55.74) 149.28,55.09 v3(149.18,54.99) ; v2(149.18,53.81) v3(149.18,54.24)
  IN1 w0.254: v7(139.5,51.04) 139.85,51.38 139.85,54.65 140.01,54.81 140.01,56.69 140.02,56.7 140.02,56.73 v3(140.29,57) 140.29,58.39 140.28,58.41 v3(140.25,58.41)
  IN1 w0.381: v4(68.35,19.57) 68.43,19.48 75.38,19.48 76.22,20.32 82.34,20.32 83.11,19.55 86.71,19.55 87.84,20.68 92.95,20.68 94.11,19.51 96.83,19.51 97.9,20.57 105.57,20.57 106.46,19.68 111.08,19.68 111.96,20.56 v4(113.39,20.56)
  IN1 w0.508: v3(149.89,57.8) v4(150.38,57.8) ; v3(149.18,54.99) v3(149.18,54.24)
  IN2 w0.381: v7(10.68,25.36) 10.68,25.31 10.47,25.11 4.63,25.11 3.06,23.53 3.06,20.49 5.29,18.25 22.88,18.25 23.72,19.09 26.05,19.09 27.46,20.5 27.46,23.78 29.36,25.68 31.72,25.68 32.4,25 38.88,25 40.95,27.06 43.16,27.06 45.88,29.78 47.99,29.78 50.25,27.52 59.85,27.52 61.89,25.48 61.89,22.35 64.18,20.07 67.85,20.07 v4(68.35,19.57) ; v7(162.21,26.38) 159.8,23.96 142.76,23.96 140.62,21.83 134.5,21.83 132.67,20 113.95,20 v4(113.39,20.56)
  IN3 w0.508: 141.47,68.06 141.47,67.72 139.83,66.08 138.34,66.08 137.93,66.48 v7(137.93,66.71) ; 141.47,68.06 142.17,67.36 v7(142.17,65.87) v7(143.52,65.87) 143.52,66.48 145.64,68.61 v7(146.64,68.61) 147.12,68.12 147.12,66.47 v7(148.37,65.23) 148.37,62.67 149.28,61.76 v7(149.28,61.71) 148.9,61.33 148.9,60.29 150.38,58.81 v4(150.38,57.8) ; 141.47,68.06 v7(141.47,68.08)
  IN4 w0.254: v5(14.36,28.16) 13.52,27.32 12.63,27.32 v7(10.68,25.36)
  IN4 w0.381: v7(162.21,26.38) 161.97,26.38 160.64,27.7 157.2,27.7 155.29,29.6 155.29,30.07 156.27,31.05 161.55,31.05 164.47,33.97 164.47,35.65 165.2,36.38 v7(165.54,36.38)
  GND5 w0.254: v6(15.29,28.82) 15.04,28.82 14.38,28.16 v5(14.36,28.16)
  BOTTOM w0.122: R952.2 10.73,26.03
  BOTTOM w0.254: v6(15.29,28.82) 15.29,29.24 15.91,29.86 15.91,33.08 15.48,33.52 v9(15.48,39.97) 15.48,41.67 17.89,44.08 17.89,45.28 19.11,46.49 20.97,46.49 21.17,46.3 21.48,45.99 22.27,45.2 23.96,45.2 24.81,46.05 27.38,46.05 28.79,44.64 29.74,44.64 30.84,45.75 PR935.2
  BOTTOM w0.381: 10.73,26.03 10.73,25.41 v7(10.68,25.36)
  BOTTOM w0.508: R990.2 165.57,36.34 v7(165.54,36.38)
+3VLP: length 305.4
  TOP w0.254: v7(140.47,52.34) 140.27,52.54 R921.2 ; R937.1 150.54,63.33 v2(150.52,63.31) ; R939.1 138.71,71.74 139.23,72.26 141.08,72.26 141.6,71.74 R938.2 141.63,71.72 141.99,71.36 142.12,71.22 142.12,69.94 v7(142.02,69.84) ; R940.1 134.6,57.32 134.6,54.29 134.84,54.05 134.84,52.62 135.9,51.57 135.9,50.3 135.64,50.05 135.64,48 136.26,47.38 v9(136.88,47.38) 137.32,47.38 v7(138.01,48.07)
  TOP w0.508: v7(138.01,48.07) 138.61,48.67 R811.1 ; R927.1 151.04,58.85 152,58.85 v7(152.03,58.88) 152.04,58.88 152.46,59.3 R936.2
  GND1 w0.254: v2(150.52,63.31) v3(150.96,63.31)
  IN1 w0.254: v4(151.02,68.12) 150.6,68.12 148.36,70.37 142.55,70.37 v7(142.02,69.84) ; v3(150.96,63.31) v4(150.96,63.79)
  IN2 w0.508: v7(138.01,48.07) 139.5,46.57 139.5,45.55 ; v7(184.72,56.67) 184.72,57.24 185.12,57.65 185.12,58.51 183.5,60.13 171.84,60.13 171.57,59.86 168.97,59.86 167.72,58.61 167.04,58.61 166.49,58.06 164.61,58.06 163.47,59.21 v7(158.58,59.21) 156.63,59.21 156.22,59.62 153.83,59.62 153.37,59.15 152.56,59.15 152.29,58.88 v7(152.03,58.88) ; 139.5,45.55 140.15,44.91 142.39,44.91 143.24,44.06 145.18,44.06 145.26,43.98 149.46,43.98 149.69,43.75 151.84,43.75 v7(152.04,43.55) ; 139.5,45.55 137.57,45.55 135.16,43.14 131.76,43.14 130.97,42.35 119.72,42.35 114.91,37.54 94.89,37.54 93.01,39.42 90.6,39.42 89.06,40.96 86.39,40.96 86.12,40.69 82.06,40.69 80.66,42.09 80.66,43.56 81.82,44.72 81.82,50.2 78.95,53.07 78.95,54.98 80.97,57 80.97,63.78 80.14,64.6 77.32,64.6 76.33,65.6 76.33,68.14 75.75,68.72 75.75,69.61 75.5,69.86 74.56,69.86 73.72,70.7 73.72,70.85 73.01,71.56 71.48,71.56 70.8,70.88 70.8,69.91 70.95,69.76 70.95,68.87 70.37,68.29 54.44,68.29 53.25,67.09 53.25,67.04 52.56,66.36 51.92,66.36 51.75,66.54 51.09,66.54 47.19,62.64 47.19,58.81 44.97,56.6 41.19,56.6 34.69,50.1 v7(34.27,50.1)
  IN3 w0.254: v7(138.01,48.07) 138.01,50.23 139.35,51.57 139.71,51.57 v7(140.47,52.34) ; v4(151.02,68.12) 151.29,67.86 151.29,65.44 150.96,65.11 v4(150.96,63.79)
  IN3 w0.508: v7(152.03,58.88) 151.28,58.88 150.32,59.83 150.32,62.24 150.96,62.88 v4(150.96,63.79)
  IN4 w0.508: v7(184.72,56.67) 184.72,56.29 185.29,55.71 188.3,55.71 191.35,52.67 194.24,52.67 194.76,53.19 v7(194.76,53.37)
  BOTTOM w0.254: v7(184.72,56.67) 184.72,57.3 185.24,57.82 186.66,57.82 186.98,57.51 188.99,57.51 PR43.2 ; PR512.2 194.77,54.04 194.22,54.6 PR515.2
  BOTTOM w0.381: PR512.2 195.08,53.68 v7(194.76,53.37)
  BOTTOM w0.508: DH4.3 29.82,47.39 32.02,49.59 33.32,49.59 33.83,50.1 v7(34.27,50.1) ; v7(158.58,59.21) 159.34,58.45 159.34,48.79 154.56,44.01 153.85,44.01 153.4,43.55 v7(152.04,43.55)
+3VNS_PWR: length 120.8
  TOP w0.122: C970.1 141.09,79.88 141.34,79.64 U638.15 ; C970.1 C969.1 138.2,79.88 R1107.2 137.68,79.86 137.12,79.3 v7(137.12,78.83) ; C970.1 140.48,79.25 140.69,79.04 U638.16 ; v7(153.83,64.86) 153.83,65.65 R1003.2
  TOP w0.127: 156.39,52.23 156.39,49.15 155.67,48.43 C966.1 C965.1 ; 156.39,52.23 156.88,52.23 157.69,53.04 v7(157.69,53.45) 157.69,53.66 156.89,54.46 156.03,54.46 155.49,53.92 U637.1 ; 156.39,52.23 U637.14
  TOP w0.178: U636.G6 U636.F7 160.55,65.32 U636.G8
  TOP w0.229: 161.94,61.56 161.55,61.96 U636.H1 ; U636.A8 158.02,65.85 v7(157.31,65.85)
  TOP w0.254: U636.G8 161.05,66.27 v7(161.13,66.36) ; 157.14,62.01 157.59,62.01 157.91,62.32 U636.A1
  TOP w0.508: C978.1 155.89,61.14 R1092.2 157.14,62.01 v7(157.92,61.23) 158.01,61.14 C976.1 ; R855.2 v7(154.82,57.4) ; R1091.1 137.95,72.86 137.22,73.6 v7(137.22,74.57) ; 161.94,61.56 163.51,61.56 ; 163.51,61.56 163.51,62.52 v9(163.67,62.67) 163.67,63.64 163.01,64.3 v7(163,64.3) ; 163.51,61.56 C979.1 C977.1 163.51,59.09 163.08,58.65 162.25,58.65 161.75,59.14 159.44,59.14 159.19,59.4 159.19,59.64 R817.1 158.73,59.84 158.41,60.16 C976.1 ; v7(154.36,72.48) 154.36,73.13 R1095.1 ; C976.1 158.01,59.72 157.64,59.35 156.29,59.35 v7(155.4,58.46) ; R1097.1 v7(152.46,72.48) 152.13,72.48 151.72,72.07 151.72,71.01 151.28,70.56 v7(150.55,70.56) 149.66,71.45 QH8.1 149.44,71.92 v7(148.72,71.92) ; R1098.1 v7(153.47,72.48) 153.4,72.56 R1096.1 ; R854.2 v7(155.78,57.39)
  IN1 w0.508: v7(154.82,57.4) 154.83,57.39 v7(155.78,57.39) ; v7(163,64.3) 164.12,63.18 168.9,63.18 169.26,62.83 169.26,59.44 v7(169.62,59.08) ; v7(153.83,64.86) 153.83,65.47 153.4,65.9 153.4,67.84 151.84,69.41 151.68,69.41 150.55,70.54 v7(150.55,70.56)
  IN2 w0.508: v7(137.12,78.83) 141.1,78.83 148.01,71.92 v7(148.72,71.92) ; v7(153.83,64.86) 155.29,66.32 156.16,66.32 156.63,65.85 v7(157.31,65.85) 158.38,65.85 158.88,66.36 v7(161.13,66.36)
  IN3 w0.508: v7(152.46,72.48) v7(153.47,72.48) v7(154.36,72.48)
  IN4 w0.508: v7(137.22,74.57) 137.22,78.73 v7(137.12,78.83) ; v7(163,64.3) 163,64.49 v7(161.13,66.36)
  BOTTOM w0.508: v7(155.4,58.46) 155.78,58.09 v7(155.78,57.39) 157.66,55.5 157.66,53.48 v7(157.69,53.45) ; JSATA1.22 168.43,57.62 169.62,58.81 v7(169.62,59.08)
