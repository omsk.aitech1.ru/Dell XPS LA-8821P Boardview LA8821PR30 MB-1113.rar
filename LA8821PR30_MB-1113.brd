# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SMI#: length 35.1
  TOP w0.122: v2(114.79,61.58) 114.88,61.49 115.03,61.49 117.09,59.44 117.09,58.79 117.43,58.45 117.43,58.31 117.55,58.19 119.88,58.19 119.9,58.17 120.72,58.17 RH190.1 121.64,57.25 121.64,56.2 122.41,55.42 125.6,55.42 v1(126.15,54.87) v2(126.15,54.25) ; U34.L13 140.11,55.8 140.11,55.58 139.94,55.4 139.59,55.4 138.87,54.67 v2(138.16,54.67)
  GND1 w0.104: v2(114.79,61.58) 114.64,61.73 v3(114.64,62.01) ; v2(138.16,54.67) 138.11,54.62 137.62,54.62 v3(137.54,54.53) ; v3(126.17,53.81) 126.17,54.23 v2(126.15,54.25)
  IN1 w0.071: v4(136.25,53.35) 136.35,53.35 v3(137.54,54.53) ; v4(130.82,53.84) 130.79,53.81 v3(126.17,53.81) ; v3(114.64,62.01) 114.85,62.22 v4(114.85,62.47)
  IN2 w0.094: v4(136.25,53.35) 135.38,53.35 134.34,54.39 131.27,54.39 130.82,53.94 v4(130.82,53.84)
  IN4 w0.071: v5(114.39,62.64) 114.38,62.64 114.41,62.64 114.57,62.47 114.84,62.47 114.84,62.47 v4(114.85,62.47)
  GND5 w0.104: v5(114.39,62.64) 113.99,63.03 v6(113.99,63.04)
  BOTTOM w0.122: UH1.H17 v6(113.99,63.04)
EC_TX: length 50.9
  TOP w0.122: v7(178.16,46.27) 178.16,46.17 R728.1 ; v2(140.26,57.41) 140.73,57.41 U34.K10
  GND1 w0.104: v3(140.7,57.35) 140.64,57.41 v2(140.26,57.41)
  IN1 w0.071: v3(140.7,57.35) 140.84,57.35 v4(141.1,57.62)
  IN2 w0.094: v4(141.1,57.62) 142.02,56.71 143.68,56.71 146.48,53.91 146.48,51.8 149.15,49.13 157.71,49.13 159.06,50.48 162.5,50.48 163.27,51.25 166.29,51.25 166.91,51.87 169.13,51.87 170,52.74 174.82,52.74 177.26,50.3 177.26,47.06 177.6,46.72 177.71,46.72 v7(178.16,46.27)
  BOTTOM w0.122: v7(178.16,46.27) v1(178.16,46.8)
EC_TX_R: length 5.7
  TOP w0.122: v1(180.28,47.17) 180.28,46.18 179.79,45.68 R728.2 ; R728.2 179.57,45.29 179.6,45.26 R730.1 ; R728.2 179.57,46 179.03,46.55 v7(178.75,46.55)
  BOTTOM w0.122: v7(178.75,46.55) 179.15,46.95 JWLAN1.49
EC_WLAN_WAKE#: length 80.9
  TOP w0.076: U34.M7 139.67,58.85 139.32,58.85 139.32,58.85 139.28,58.85 139.19,58.76 138.82,58.76 138.23,58.18
  TOP w0.122: 138.23,58.18 138.22,58.17 v2(138.13,58.17) ; v1(179.81,23.2) v7(179.81,23.81) 179.64,23.99 R942.2
  GND1 w0.104: v3(138.04,57.72) 138.04,58.08 v2(138.13,58.17)
  IN1 w0.071: v4(139.05,58.22) 138.55,57.72 v3(138.04,57.72)
  IN2 w0.094: v7(179.81,23.81) 178.71,24.92 178.71,30.5 179.37,31.16 179.37,34.1 179.7,34.43 179.7,40.68 179.82,40.8 179.82,44.66 178.68,45.8 177.38,45.8 177.02,46.16 177.02,50.27 174.74,52.55 170.12,52.55 169.18,51.61 168.07,51.61 167.51,51.06 163.35,51.06 162.58,50.29 159.14,50.29 157.79,48.93 149.07,48.93 146.28,51.72 146.28,53.83 143.6,56.51 141.66,56.51 139.95,58.22 v4(139.05,58.22)
  BOTTOM w0.122: JWLAN1.1 180.05,24.05 v7(179.81,23.81)
ECAGND: length 6
  TOP w0.203: U34.A11 145.42,57.05 145.77,56.71 145.77,56.51 145.98,56.3 145.98,56.26
  TOP w0.254: C282.2 146.01,54.06 C286.1 ; C286.1 145.44,54.59 145.98,55.13 145.98,56.26 ; C286.1 145.44,53.47 145.21,53.23 L44.2
EDP_AUXN: length 96
  IN4 w0.071: v5(81.04,68.08) 81.04,68.02 80.91,67.88 80.78,67.88 80.72,67.95 80.72,68.3 80.86,68.44 83.08,68.44 84.02,67.5 84.51,67.5 84.94,67.07 88.83,67.07 89.83,68.07 89.83,69.3 90.29,69.76 90.88,69.76 92.08,70.97 92.54,70.97 93.72,72.15 96.5,72.15 97.99,73.63 97.99,74.38 99.13,75.53 100.18,75.53 101.55,76.9 107.53,76.9 108.35,77.72 110.63,77.72 112.03,76.31 112.03,75.16 113.11,74.08 116.15,74.08 116.43,74.36 118.21,74.36 118.93,75.08 119.64,75.08 120.23,75.67 125.64,75.67 126.82,74.49 129.72,74.49 132.19,72.02 132.19,71.51 133.5,70.21 138.36,70.21 139.66,71.5 142.11,71.5 142.42,71.82 146.34,71.82 146.87,71.29 149.51,71.29 151.3,73.08 160.23,73.08 160.33,72.97 160.33,72.76 160.22,72.65 v7(160.11,72.65)
  GND5 w0.076: v6(81.04,67.67) v5(81.04,68.08)
  BOTTOM w0.114: v6(81.04,67.67) 80.73,67.35 UCPU1.AG4 ; v7(160.11,72.65) 160.24,72.78 160.24,73.04 C1065.1
EDP_AUXN_C: length 2.7
  BOTTOM w0.114: R1033.1 159.43,74.27 159.47,74.24 C1065.2 160.2,74.49 160.2,74.74 159.95,74.99 L58.1 159.82,75.48 R1011.1
EDP_AUXN_CONN: length 5
  BOTTOM w0.114: R1011.2 159.95,76.77 L58.2 159.95,77.25 160.25,77.55 160.25,77.82 160.57,78.14 v7(160.9,78.14) 161.99,78.14 162.41,78.56 162.41,78.9 162.25,79.06 JLVDS1.9
EDP_AUXP: length 96
  IN4 w0.071: v5(80.4,68.08) 80.41,68.08 80.55,68.22 80.55,68.37 80.79,68.61 83.15,68.61 84.09,67.67 84.58,67.67 85.01,67.23 88.76,67.23 89.67,68.14 89.67,69.37 90.23,69.93 90.81,69.93 92.02,71.13 92.47,71.13 93.65,72.31 96.43,72.31 97.82,73.7 97.82,74.45 99.07,75.69 100.11,75.69 101.49,77.06 107.46,77.06 108.28,77.88 110.69,77.88 112.2,76.38 112.2,75.23 113.18,74.24 116.08,74.24 116.36,74.52 118.14,74.52 118.86,75.25 119.57,75.25 120.16,75.84 125.71,75.84 126.89,74.65 129.79,74.65 132.35,72.09 132.35,71.58 133.57,70.37 138.29,70.37 139.59,71.67 142.04,71.67 142.36,71.98 146.41,71.98 146.94,71.45 149.44,71.45 151.23,73.24 160.3,73.24 160.5,73.04 160.5,72.9 v7(160.75,72.65)
  GND5 w0.076: v6(80.4,67.66) v5(80.4,68.08)
  BOTTOM w0.114: UCPU1.AF4 80.73,67.91 80.48,67.66 v6(80.4,67.66) ; v7(160.75,72.65) 160.5,72.9 160.5,73.01 160.82,73.32 C1064.1
EDP_AUXP_C: length 2.6
  BOTTOM w0.114: R1010.1 160.84,75.44 L58.4 160.75,74.93 160.55,74.73 160.55,74.53 C1064.2 R1034.2
EDP_AUXP_CONN: length 4.9
  BOTTOM w0.114: JLVDS1.8 162.75,78.88 162.67,78.8 162.67,78.45 v7(162.34,78.12) 162.1,77.88 160.67,77.88 160.51,77.71 160.51,77.53 160.75,77.29 L58.3 160.75,76.73 R1010.2
EDP_HPD: length 94.2
  TOP w0.122: v7(95.26,74.18) v1(93.78,74.18) 91.9,74.18 90.28,72.56 90.28,70.7 91.6,69.38 91.6,65.44 QC5.2 92.32,64.26 RC138.1
  IN2 w0.094: v7(162.62,82.38) 154.07,82.38 153.31,81.63 151.45,81.63 150.67,82.41 147.5,82.41 146.72,81.63 137.83,81.63 136.98,82.48 136.07,82.48 134.57,83.97 134.57,85.03 133.8,85.81 131.09,85.81 130.8,85.52 127.5,85.52 126.5,84.52 125.2,84.52 123.31,82.63 120.04,82.63 119,81.58 115.1,81.58 113.73,80.21 112.55,80.21 110.62,78.28 105.02,78.28 101.32,74.57 98.22,74.57 97.92,74.28 96.35,74.28 96.25,74.18 v7(95.26,74.18)
  BOTTOM w0.122: v7(162.62,82.38) 161.75,81.52 JLVDS1.10
EDP_TXN_P0: length 94.1
  IN4 w0.071: v5(81.8,69.96) 81.82,69.96 81.93,70.08 81.93,70.22 82.21,70.5 82.72,70.5 82.8,70.42 89.78,70.42 91.28,71.92 92.08,71.92 98.01,77.85 107.31,77.85 108,78.55 111.1,78.55 112.74,76.91 113.21,76.43 113.21,76.25 114.12,75.34 114.29,75.34 114.43,75.2 117.82,75.2 118.72,76.1 119.46,76.1 120.25,76.89 125.6,76.89 126.72,75.77 130.07,75.77 130.46,75.38 130.46,74.92 133.83,71.55 134.42,71.55 134.91,71.06 138,71.06 139.28,72.34 140.93,72.34 141.26,72.67 146.71,72.67 146.95,72.43 148.27,72.43 149.75,73.91 162.37,73.91 163.18,73.1 163.18,72.88 v7(163.41,72.65)
  GND5 w0.076: v6(81.77,69.56) 81.77,69.58 81.85,69.66 81.85,69.91 v5(81.8,69.96)
  BOTTOM w0.114: v6(81.77,69.56) 81.39,69.18 UCPU1.AC3 ; v7(163.41,72.65) 163.18,72.88 163.18,73 163.47,73.29 C1060.1
EDP_TXN_P0_C: length 1.7
  BOTTOM w0.114: C1060.2 163.22,74.51 163.22,74.68 163.43,74.89 L57.4 163.43,75.56 R1008.1
EDP_TXN_P0_CONN: length 3.8
  BOTTOM w0.114: R1008.2 163.43,76.62 L57.3 163.43,77.2 163.19,77.44 163.19,77.62 163.4,77.82 163.57,77.82 v7(163.84,78.09) 164.16,78.41 164.16,78.92 164.25,79.01 JLVDS1.5
EDP_TXN_P1: length 97.2
  IN4 w0.071: v5(80.74,69.92) 80.89,70.07 80.89,70.31 81.68,71.09 89.51,71.09 91.03,72.61 91.83,72.61 97.74,78.52 107.03,78.52 107.73,79.21 111.54,79.21 113.87,76.88 117.7,76.88 119.14,78.32 122.82,78.32 123.57,77.57 127.24,77.57 127.71,77.1 128.65,77.1 129.02,76.73 130.2,76.73 131.21,75.72 131.21,75.11 134.04,72.29 134.64,72.29 135.19,71.74 137.75,71.74 139.03,73.02 140.25,73.02 140.57,73.34 147.7,73.34 148.95,74.6 163.56,74.6 165.08,73.08 165.08,72.9 v8(165.31,72.66)
  GND5 w0.076: v5(80.74,69.92) 81.08,69.58 v6(81.08,69.58)
  BOTTOM w0.114: C1061.1 165.35,73.29 165.07,73.02 165.07,72.91 v8(165.31,72.66) ; UCPU1.AC4 80.73,69.28 81.03,69.58 v6(81.08,69.58)
EDP_TXN_P1_C: length 1.7
  BOTTOM w0.114: C1061.2 165.12,74.51 165.12,74.74 165.34,74.95 L56.4 165.34,75.56 R1006.1
EDP_TXN_P1_CONN: length 3.5
  BOTTOM w0.114: R1006.2 165.34,76.66 L56.3 165.34,77.2 165.1,77.44 165.1,77.67 v7(165.54,78.11) 165.68,78.26 165.68,78.95 165.75,79.01 JLVDS1.2
EDP_TXP_P0: length 94.1
  IN4 w0.071: v7(162.77,72.65) 163.01,72.89 163.01,73.03 162.3,73.75 149.82,73.75 148.34,72.26 146.88,72.26 146.64,72.5 141.33,72.5 141,72.17 139.35,72.17 138.07,70.89 134.84,70.89 134.35,71.39 133.76,71.39 130.3,74.85 130.3,75.31 130,75.6 126.65,75.6 125.53,76.72 120.32,76.72 119.53,75.93 118.79,75.93 117.89,75.03 114.37,75.03 114.22,75.18 114.06,75.18 113.05,76.18 113.05,76.36 112.62,76.79 111.03,78.38 108.07,78.38 107.37,77.69 98.08,77.69 92.15,71.75 91.35,71.75 89.85,70.26 82.73,70.26 82.66,70.33 82.28,70.33 82.1,70.15 82.1,69.86 82.2,69.76 82.35,69.76 82.46,69.86 v5(82.46,69.96)
  GND5 w0.076: v6(82.38,69.53) 82.38,69.89 v5(82.46,69.96)
  BOTTOM w0.114: UCPU1.AC1 82.1,69.41 82.23,69.53 v6(82.38,69.53) ; v7(162.77,72.65) 162.92,72.8 162.92,73 C1062.1
EDP_TXP_P0_C: length 1.7
  BOTTOM w0.114: C1062.2 162.87,74.44 162.87,74.65 162.63,74.89 L57.1 162.63,75.49 R1009.1
EDP_TXP_P0_CONN: length 3.9
  BOTTOM w0.114: JLVDS1.6 163.75,79.04 163.9,78.88 163.9,78.52 163.47,78.08 163.29,78.08 162.93,77.73 162.93,77.51 162.63,77.2 L57.2 162.63,76.69 R1009.2
EDP_TXP_P1: length 97.1
  IN4 w0.071: v7(164.68,72.66) 164.73,72.66 164.92,72.85 164.92,73.01 163.49,74.43 149.02,74.43 147.76,73.18 140.63,73.18 140.32,72.86 139.1,72.86 137.81,71.58 135.12,71.58 134.58,72.12 133.97,72.12 131.05,75.04 131.05,75.65 130.13,76.57 128.95,76.57 128.58,76.94 127.64,76.94 127.17,77.41 123.5,77.41 122.75,78.16 119.21,78.16 117.77,76.71 113.8,76.71 111.47,79.04 107.8,79.04 107.1,78.35 97.81,78.35 91.9,72.44 91.09,72.44 89.58,70.93 81.74,70.93 81.06,70.24 81.06,69.8 81.15,69.71 81.3,69.71 81.38,69.79 v5(81.38,69.92)
  GND5 w0.076: v5(81.38,69.92) 81.04,70.26 v6(81.03,70.26)
  BOTTOM w0.114: v6(81.03,70.26) 81,70.23 81,70.21 UCPU1.AA4 ; v7(164.68,72.66) 164.81,72.8 164.81,73.02 C1063.1
EDP_TXP_P1_C: length 1.7
  BOTTOM w0.114: R1007.1 164.54,75.52 L56.1 164.54,74.93 164.78,74.69 164.78,74.44 C1063.2
EDP_TXP_P1_CONN: length 3.6
  BOTTOM w0.114: R1007.2 164.54,76.69 L56.2 164.54,77.22 164.84,77.52 164.84,77.78 165.03,77.97 165.42,78.36 165.42,78.9 165.25,79.08 JLVDS1.3
EN_1.5VSP: length 5.2
  TOP w0.122: PR405.2 168.87,43.65 v1(168.43,43.22)
  TOP w0.254: v7(168.51,42) 168.63,41.87 PC406.1 PR407.1 PR405.2
  BOTTOM w0.254: PU401.5 v7(168.51,42)
EN_1.8VSP: length 7.4
  TOP w0.122: v1(101.07,51.89) 101.07,52.39 v2(101.2,52.51)
  TOP w0.508: PR402.2 102,54.89 102,54.03 PC404.1 PR403.1 101.56,52.51 v2(101.2,52.51)
  GND1 w0.508: v3(101.23,51.78) 101.23,52.49 v2(101.2,52.51)
  IN1 w0.508: v4(101.84,52.11) 101.56,52.11 v3(101.23,51.78)
  IN4 w0.305: v4(101.84,52.11) v5(102.34,52.11)
  GND5 w0.305: v6(102.8,52.11) v5(102.34,52.11)
  BOTTOM w0.305: v6(102.8,52.11) 102.98,52.11 103.33,51.76 PU400.5
EN_+V1.05S_VCCPP: length 4.9
  TOP w0.254: PU500.3 125.15,48.48 125.74,49.06 127.64,49.06 127.93,49.35 PC505.1 PR503.2
EN_CAM: length 78.8
  TOP w0.122: v7(170.42,74.87) v1(172.7,74.87) 176.54,74.87 178.6,72.8 Q42.2
  IN2 w0.094: v7(170.42,74.87) 170.2,74.87 166.24,70.9 166.24,69.65 165.66,69.07 165.66,67.29 165.11,66.74 161.37,66.74 160.99,67.12 157.39,67.12 156.81,66.54 156.51,66.54 156.17,66.88 156.17,67.13 155.8,67.5 154.61,67.5 153.41,66.3 150.21,66.3 149.68,66.84 148.69,66.84 148,66.14 147.47,66.14 146.99,66.61 145.78,66.61 145.16,67.23 142.5,67.23 142.34,67.06 139.56,67.06 138.21,68.41 135.77,68.41 129.83,74.36 127.81,74.36 127.26,73.81 124.67,73.81 124.12,74.36 122.32,74.36 120.43,72.47 118.44,72.47 118.27,72.65 116.21,72.65 116.12,72.56 115.22,72.56 v4(114.84,72.17)
  IN4 w0.071: v4(114.84,72.17) 114.84,72.22 114.41,72.66 v5(114.41,72.68)
  GND5 w0.104: v6(113.99,72.71) 114.38,72.71 v5(114.41,72.68)
  BOTTOM w0.122: UH1.H42 v6(113.99,72.71)
EN_INVPWR: length 32.7
  TOP w0.122: v7(148.19,69.66) 147,69.66 146.17,68.83 146.17,68.33 146.39,68.11 146.39,65.11 146.67,64.83 146.67,64.33 145.12,62.78 145.12,62.3 U34.B1 ; v7(152.38,80.66) 156.35,84.63 v1(156.86,84.63) 157.74,85.51 R538.2
  IN2 w0.094: v7(152.38,80.66) 152.38,80.57 152.86,80.09 152.86,71.64 151.29,70.07 148.6,70.07 v7(148.19,69.66)
EN_TS: length 71.3
  TOP w0.122: v2(113.65,74.65) 114.32,74.65 v1(115.55,73.42) 116.4,73.42 117.09,74.1 117.09,74.33 117.51,74.75 118.03,74.75 118.46,75.19 121.5,75.19 RH326.2 122.43,73.68 122.96,73.15 128.15,73.15 128.51,73.51 128.51,75.5 128.14,75.87 128.14,77.94 128.95,78.75 128.95,81.13 130.49,82.66 134.86,82.66 135.06,82.46 142.41,82.46 142.62,82.66 145.4,82.66 149.58,78.49 156.08,78.49 156.97,79.38 160.5,79.38 160.83,79.04 160.83,78.45 161.06,78.22 161.65,78.22 161.78,78.35 161.78,78.69 162.21,79.12 163.61,79.12 164.94,77.79 Q336.2
  GND1 w0.104: v3(114.05,74.65) v2(113.65,74.65)
  IN1 w0.071: v4(113.57,74.65) v3(114.05,74.65)
  IN4 w0.071: v4(113.57,74.65) 113.58,74.65 113.8,74.87 v5(114.08,74.87)
  GND5 w0.104: v5(114.08,74.87) 114.33,74.61 v6(114.51,74.61)
  BOTTOM w0.122: v6(114.51,74.61) 114.25,74.87 UH1.G46
ENBKL: length 59.2
  TOP w0.076: v2(145.8,59.86) 145.51,59.86 145.51,59.85 145.17,59.85 U34.B6
  TOP w0.122: RH123.2 112.26,73.62 v2(112.29,73.58) 112.61,73.58 112.72,73.47 v1(113.19,73.47)
  GND1 w0.104: v3(145.35,59.78) 145.42,59.86 v2(145.8,59.86) ; v2(112.29,73.58) v3(112.29,74.23)
  IN1 w0.071: v4(111.94,74.61) 112.29,74.26 v3(112.29,74.23) ; v3(145.35,59.78) 145.45,59.88 145.9,59.88 v4(146.03,60.01)
  IN2 w0.094: v4(146.03,60.01) 146.03,61.67 146.76,62.4 146.76,63.34 146.49,63.61 144.53,63.61 143.95,64.19 137.28,64.19 136.56,63.47 136.56,62.9 136.02,62.36 133.09,62.36 132.98,62.47 132.24,62.47 131.28,63.44 129.81,63.44 129,64.25 129,64.63 129.33,64.96 129.33,66.73 128.11,67.95 128.11,70.11 125.04,73.18 122.21,73.18 120.52,71.48 117.73,71.48 116.85,70.6 114.03,70.6 v4(113.34,69.91)
  IN4 w0.071: v4(111.94,74.61) 112.25,74.31 v5(112.25,74) 112.48,73.77 112.48,72.38 112.92,71.93 112.92,71.35 112.61,71.03 112.61,70.12 112.81,69.91 v4(113.34,69.91)
  GND5 w0.104: v6(111.79,74) v5(112.25,74)
  BOTTOM w0.122: UH1.M44 v6(111.79,74)
ENM: length 3.9
  TOP w0.254: PU501.13 193.54,53.6 193.4,53.45 193.4,53.43 v7(193.38,53.4)
  BOTTOM w0.122: v7(193.38,53.4) v1(193.38,52.72)
  BOTTOM w0.254: v7(193.38,53.4) 193.38,53.45 PR514.1 192.77,54.39 PR515.1
ENTRIP1: length 14.4
  IN1 w0.254: v7(200.11,54.5) 198.81,54.5 198.15,53.84 195.97,53.84 195.43,54.37 195.43,58.23 v7(194.91,58.75)
  BOTTOM w0.122: v1(200.59,53.12) 200.59,54.01 v7(200.11,54.5)
  BOTTOM w0.254: v7(200.11,54.5) 199.38,55.22 PQ204.6 ; v7(194.91,58.75) 194.91,58.55 194.63,58.27 PC1920.2 194.63,56.93 PR216.2
ENTRIP2: length 3.5
  BOTTOM w0.122: PQ204.3 197.14,56.96 v1(196.53,56.96)
  BOTTOM w0.254: 198.32,57.64 PR218.1 ; 198.32,57.64 198.33,57.63 PC1919.1 ; 198.32,57.64 198.32,57.08 197.86,56.62 PQ204.3
ENVDD: length 9.5
  TOP w0.122: D93.1 169.3,65.37 169.65,65.02 R1026.1 v2(170.49,64.43) 170.49,64.3 v1(170.8,64) ; U654.5 173.76,64.67 v7(173.79,64.63)
  GND1 w0.104: v2(170.49,64.43) v3(170.49,64.86)
  IN1 w0.071: v7(173.79,64.63) 172.65,63.49 170.9,63.49 170.49,63.89 v3(170.49,64.86)
FB: length 6.2
  TOP w0.254: PR740.1 26.6,79.21 27.24,79.84 v7(27.24,79.86) 27.35,79.86 28,79.21 PC728.2 28.84,78.85 PR737.2
  BOTTOM w0.254: PR738.2 28.86,80.05 PC729.2 27.85,79.9 27.31,79.9 27.28,79.86 v7(27.24,79.86) 27.2,79.86 27.11,79.94 PU700.17
FB_3V: length 5.4
  TOP w0.122: v1(191.4,58.8) 191.4,58.56 v7(191.02,58.18)
  TOP w0.254: PC220.2 PR200.2 190.98,58.22 v7(191.02,58.18) 191.17,58.03 192.58,58.03 192.74,57.86 PU501.5
  BOTTOM w0.254: PR202.2 191.18,58.18 v7(191.02,58.18)
FB_+V1.05S_VCCPP: length 3.8
  TOP w0.254: PU500.4 124.65,48.61 125.28,49.24 PR507.2 PC510.2 127.03,49.67 PR510.2
FDI_CTX_PRX_N0: length 26.8
  IN1 w0.071: v4(96.55,61.25) 96.91,61.6 96.91,61.86 96.96,61.91 96.96,64.02 96.73,64.25 94.46,64.25 91.24,67.48 87.37,67.48 84.68,70.16 81.94,70.16 81.51,70.59 80.13,70.59 79.64,71.09 79.64,71.25 79.19,71.7 79.19,71.91 v8(78.9,72.2)
  IN4 w0.071: v4(96.55,61.25) 96.41,61.1 v5(96.04,61.1)
  GND5 w0.076: v5(96.04,61.1) 96.07,61.13 96.08,61.13 96.25,61.29 96.25,61.44 v6(96.12,61.57)
  BOTTOM w0.114: UCPU1.U7 79.2,71.9 v8(78.9,72.2) ; UH1.BL13 v6(96.12,61.57)
FDI_CTX_PRX_N1: length 25.9
  IN1 w0.071: v8(77.58,71.31) 77.58,71.04 77.68,70.94 78.03,70.94 78.28,70.69 78.28,70.21 78.48,70.01 80.61,70.01 81.05,69.57 84.3,69.57 86.58,67.29 86.58,66.12 87.48,65.23 92.72,65.23 94.5,63.45 94.83,63.45 95.51,62.76 96.11,62.76 96.29,62.59 96.29,62.36 96.38,62.27 v4(96.55,62.27)
  IN4 w0.071: v4(96.55,62.27) 96.69,62.27 v5(96.98,61.98)
  GND5 w0.076: v6(96.98,62.38) v5(96.98,61.98)
  BOTTOM w0.114: UCPU1.W11 77.58,71.19 v8(77.58,71.31) ; v5(96.98,61.98) v6(96.98,62.38)
FDI_CTX_PRX_N2: length 24.6
  IN1 w0.071: v4(98.76,61.13) 98.71,61.13 98.56,61.28 98.56,61.68 97.76,62.48 97.76,64.39 96.81,65.34 94.56,65.34 91.58,68.33 89.11,68.33 88.5,68.94 87.08,68.94 85.02,70.99 82.28,70.99 82.19,71.08 82.19,71.27 v8(82.46,71.54)
  IN4 w0.071: v4(98.76,61.13) 98.76,60.75 v5(98.87,60.64)
  GND5 w0.076: v6(98.87,61.1) v5(98.87,60.64)
  BOTTOM w0.114: UCPU1.W1 82.1,71.19 v8(82.46,71.54) ; UH1.BD12 v6(98.87,61.1)
FDI_CTX_PRX_N3: length 23.3
  IN1 w0.071: v4(96.45,60.41) 96.26,60.6 96.26,60.81 95.95,61.12 95.54,61.12 94.94,61.72 93.74,61.72 90.94,64.52 86.73,64.52 85.72,65.52 85.72,66.56 84.74,67.54 83.75,67.54 82.43,68.86 80.11,68.86 79.88,69.09 79.88,69.19 v8(80.09,69.41)
  IN4 w0.071: v5(96.56,59.92) 96.45,60.04 v4(96.45,60.41)
  GND5 w0.076: v5(96.56,59.92) 96.58,59.92 96.58,59.93 96.59,59.94 v6(96.98,59.94)
  BOTTOM w0.114: UCPU1.AA6 79.86,69.64 v8(80.09,69.41) ; UH1.BJ11 96.98,60.35 v6(96.98,59.94)
FDI_CTX_PRX_N4: length 38.7
  IN1 w0.071: v4(100.59,61.15) 100.59,61.25 100.46,61.38 100.29,61.38 100.21,61.3 100.21,60.92 100.38,60.76 100.88,60.76 101.01,60.88 101.01,61.8 100.85,61.96 100.85,63.24 100.81,63.28 100.81,63.85 100.85,63.89 100.85,64.22 100.66,64.41 100.6,64.47 99.74,64.47 98.47,65.74 98.21,65.74 97.15,66.79 95.72,66.79 93.67,68.84 93.67,69.24 93.47,69.44 92.15,69.44 89.48,72.11 87.53,72.11 86.19,73.46 84.44,73.46 83.82,72.83 82.79,72.83 81.76,73.86 80.72,73.86 80.49,74.09 79.38,74.09 78.32,73.02 78.32,72.12 79.01,71.43 79.01,70.81 79.22,70.6 79.22,70.44 79.22,70.44 79.34,70.32 79.48,70.32 79.59,70.43 v7(79.59,70.44)
  IN4 w0.071: v5(100.41,61.63) 100.29,61.51 100.29,61.33 100.46,61.15 v4(100.59,61.15)
  GND5 w0.076: v6(100.6,62.04) 100.41,61.85 v5(100.41,61.63)
  BOTTOM w0.114: UH1.AY15 v6(100.6,62.04) ; UCPU1.W6 79.86,70.85 79.59,70.59 v7(79.59,70.44)
FDI_CTX_PRX_N5: length 30.6
  IN1 w0.071: v4(100.53,60.17) 100.47,60.17 100.32,60.02 100.32,59.83 100.1,59.6 99.72,59.6 99.17,60.16 99.17,64.3 98.15,65.31 97.97,65.31 97.15,66.13 95.39,66.13 94.03,67.5 93.12,67.5 89.38,71.23 86.1,71.23 85.82,71.51 83.28,71.51 82.8,72 81.45,72 81.02,71.56 80.42,71.56 v8(80.22,71.36)
  IN4 w0.071: v4(100.53,60.17) 100.32,60.37 100.32,60.53 100.46,60.67 v5(100.51,60.67)
  GND5 w0.076: v5(100.51,60.67) 100.51,60.95 v6(100.64,61.07)
  BOTTOM w0.114: UH1.AY12 v6(100.64,61.07) ; UCPU1.V4 80.35,71.26 80.25,71.36 v8(80.22,71.36)
FDI_CTX_PRX_N6: length 24
  IN1 w0.071: v4(97.01,59.09) 96.79,59.09 96.69,59.18 96.69,59.49 96.3,59.88 94.64,59.88 90.69,63.83 86.46,63.83 84.02,66.27 84.02,66.62 v8(84.23,66.84)
  IN4 w0.071: v4(97.01,59.09) 97.01,59.1 96.78,59.32 v5(96.78,59.58)
  GND5 w0.076: v6(96.98,59.13) 96.78,59.33 v5(96.78,59.58)
  BOTTOM w0.114: UCPU1.Y2 81.78,70.66 83.02,70.66 83.74,69.93 83.74,67.8 84,67.54 84,67.07 v8(84.23,66.84) ; UH1.BJ9 v6(96.98,59.13)
FDI_CTX_PRX_N7: length 28.3
  IN1 w0.071: v4(98.46,59.42) 98.44,59.42 98.27,59.6 97.98,59.6 97.66,59.28 97.66,58.92 97.51,58.78 97.27,58.54 95.58,58.54 95.29,58.83 94.52,58.83 90.37,62.98 86.13,62.98 82.95,66.16 82.95,67 82.52,67.43 81.94,68.01 79.12,68.01 78.34,68.79 78.34,69.25 v7(78.16,69.43)
  IN4 w0.071: v5(98.01,59.68) 98.2,59.68 v4(98.46,59.42)
  GND5 w0.076: v6(98.01,60.11) v5(98.01,59.68)
  BOTTOM w0.114: UH1.BF10 v6(98.01,60.11) ; UCPU1.AC9 78.24,69.36 v7(78.16,69.43)
FDI_CTX_PRX_P0: length 26.6
  IN1 w0.071: v7(79.61,72.2) 79.36,71.95 79.36,71.77 79.8,71.32 79.8,71.16 80.2,70.76 81.58,70.76 82.01,70.33 84.75,70.33 87.44,67.64 91.31,67.64 94.53,64.41 96.79,64.41 97.12,64.08 97.12,61.84 97.07,61.79 97.07,61.54 v4(97.37,61.25)
  IN4 w0.071: v5(96.98,60.95) 97.07,60.95 v4(97.37,61.25)
  GND5 w0.076: v6(96.98,61.57) v5(96.98,60.95)
  BOTTOM w0.114: UH1.BJ13 v6(96.98,61.57) ; v7(79.61,72.2) 79.85,71.96 UCPU1.U6
FDI_CTX_PRX_P1: length 25.8
  IN1 w0.071: v7(77.58,70.42) 77.58,70.68 77.68,70.78 77.96,70.78 78.11,70.62 78.11,70.14 78.41,69.84 80.55,69.84 80.98,69.41 84.23,69.41 86.42,67.22 86.42,66.05 87.41,65.06 92.65,65.06 94.43,63.29 94.76,63.29 95.45,62.6 96.04,62.6 96.12,62.52 96.12,62.32 96.02,62.22 v4(95.69,62.22)
  IN4 w0.071: v5(96.12,61.98) 96.11,61.98 95.87,62.22 v4(95.69,62.22)
  GND5 w0.076: v6(96.12,62.38) v5(96.12,61.98)
  BOTTOM w0.114: v7(77.58,70.42) 77.91,70.75 UCPU1.W10 ; v5(96.12,61.98) v6(96.12,62.38)
FDI_CTX_PRX_P2: length 24.6
  IN1 w0.071: v4(98.2,61.13) 98.22,61.13 98.39,61.3 98.39,61.61 97.59,62.41 97.59,64.32 96.74,65.18 94.49,65.18 91.51,68.16 89.04,68.16 88.43,68.77 87.01,68.77 84.96,70.83 82.21,70.83 82.02,71.02 82.02,71.26 v7(81.72,71.56)
  IN4 w0.071: v5(98.01,60.67) 98.2,60.86 v4(98.2,61.13)
  GND5 w0.076: v6(98.01,61.1) v5(98.01,60.67)
  BOTTOM w0.114: UH1.BF12 v6(98.01,61.1) ; UCPU1.W3 81.38,71.22 v7(81.72,71.56)
FDI_CTX_PRX_P3: length 23.3
  IN1 w0.071: v4(95.89,60.43) 96.09,60.63 96.09,60.75 95.88,60.95 95.48,60.95 94.87,61.55 93.67,61.55 90.87,64.35 86.66,64.35 85.55,65.45 85.55,66.49 84.68,67.37 83.69,67.37 82.36,68.69 80.04,68.69 79.71,69.02 79.71,69.15 v7(79.46,69.41)
  IN4 w0.071: v4(95.89,60.43) 95.89,60.14 v5(95.69,59.94)
  GND5 w0.076: v6(96.12,59.94) v5(95.69,59.94)
  BOTTOM w0.114: UCPU1.AA7 79.21,69.86 79.46,69.61 v7(79.46,69.41) ; v6(96.12,59.94) 96.12,59.94 96.12,60.35 UH1.BL11
FDI_CTX_PRX_P4: length 38.7
  IN1 w0.071: v8(78.82,70.44) 78.82,71.38 78.15,72.05 78.15,73.09 79.32,74.26 80.56,74.26 80.78,74.03 81.83,74.03 82.85,73 83.75,73 84.37,73.62 86.26,73.62 87.6,72.28 89.55,72.28 92.21,69.61 93.53,69.61 93.83,69.31 93.83,68.91 95.79,66.95 97.22,66.95 98.27,65.9 98.54,65.9 99.81,64.63 100.67,64.63 100.77,64.53 101.01,64.29 101.01,63.82 100.97,63.78 100.97,63.35 101.02,63.3 101.02,62.03 101.17,61.87 101.17,60.81 100.95,60.59 100.31,60.59 100.05,60.85 100.05,60.93 v4(99.83,61.15)
  IN4 w0.071: v4(99.83,61.15) 100.12,61.44 100.12,61.51 99.99,61.63 v5(99.93,61.63)
  GND5 w0.076: v5(99.93,61.63) 99.93,61.85 v6(99.74,62.04)
  BOTTOM w0.114: v8(78.82,70.44) 79.21,70.82 UCPU1.W7 ; UH1.BB15 v6(99.74,62.04)
FDI_CTX_PRX_P5: length 30.7
  IN1 w0.071: v4(99.96,60.17) 100.07,60.17 100.16,60.08 100.16,59.9 100.03,59.77 99.79,59.77 99.33,60.23 99.33,64.37 98.22,65.48 98.04,65.48 97.22,66.3 95.46,66.3 94.09,67.67 93.19,67.67 89.45,71.4 86.17,71.4 85.89,71.68 83.35,71.68 82.86,72.16 81.39,72.16 80.95,71.73 80.44,71.73 80.27,71.89 v7(80.27,72.17)
  IN4 w0.071: v5(99.93,60.67) 100.02,60.67 100.16,60.53 100.16,60.37 v4(99.96,60.17)
  GND5 w0.076: v5(99.93,60.67) 99.93,60.87 v6(99.73,61.07)
  BOTTOM w0.114: UCPU1.T4 80.53,71.91 v7(80.27,72.17) ; UH1.BB12 99.74,61.06 v6(99.73,61.07)
FDI_CTX_PRX_P6: length 24
  IN1 w0.071: v8(83.6,66.84) 83.85,66.59 83.85,66.2 86.39,63.67 90.62,63.67 94.57,59.72 96.23,59.72 96.53,59.42 96.53,59.18 96.43,59.08 v4(96.17,59.08)
  IN4 w0.071: v5(96.35,59.58) 96.35,59.26 v4(96.17,59.08)
  GND5 w0.076: v6(96.12,59.13) 96.35,59.36 v5(96.35,59.58)
  BOTTOM w0.114: UH1.BL9 v6(96.12,59.13) ; UCPU1.AA3 81.66,70.04 81.97,70.36 82.01,70.4 82.91,70.4 83.48,69.83 83.48,67.69 83.75,67.43 83.75,66.99 v8(83.6,66.84)
FDI_CTX_PRX_P7: length 28.2
  IN1 w0.071: v4(98.43,60.01) 98.43,59.91 98.29,59.77 97.91,59.77 97.49,59.35 97.49,58.99 97.4,58.89 97.2,58.7 95.65,58.7 95.36,58.99 94.59,58.99 90.43,63.14 86.2,63.14 83.12,66.23 83.12,67.07 82.63,67.55 82.01,68.17 79.19,68.17 78.51,68.86 78.51,69.21 78.56,69.26 78.56,69.32 78.67,69.43 v7(78.82,69.43)
  IN4 w0.071: v5(98.87,59.7) 98.74,59.7 v4(98.43,60.01)
  GND5 w0.076: v6(98.87,60.11) v5(98.87,59.7)
  BOTTOM w0.114: UH1.BD10 v6(98.87,60.11) ; UCPU1.AC8 78.82,68.95 v7(78.82,69.43)
FDI_FSYNC0: length 27.1
  IN2 w0.094: v4(94.79,61.04) 93.19,61.04 90.58,63.64 84.11,63.64 80.55,67.2 80.55,67.56 79.46,68.64 v4(79.33,68.64)
  IN4 w0.071: v5(77.25,69.91) 77.38,69.79 77.38,68.82 77.83,68.36 78.87,68.36 79.15,68.64 v4(79.33,68.64) ; v5(97.41,60.75) 97.41,60.74 97.2,60.74 97.1,60.65 96.82,60.65 96.67,60.8 95.92,60.8 95.75,60.98 95.75,60.99 95.49,61.25 95,61.25 v4(94.79,61.04)
  GND5 w0.104: v5(77.25,69.91) 76.97,70.19 v6(76.97,70.29) ; v5(97.41,60.75) v6(97.41,61.16)
  BOTTOM w0.122: v6(76.97,70.29) 77.26,70.01 UCPU1.AA11 ; UH1.BH12 v6(97.41,61.16)
FDI_FSYNC1: length 25.9
  IN2 w0.094: v4(95.66,59.3) 95.66,59.3 95.66,59.3 94.01,59.3 90.32,62.99 83.87,62.99 80.08,66.78 79.19,66.78 77.88,68.08 v4(76.94,68.08)
  IN4 w0.071: v5(76.94,68.87) 76.94,68.86 v4(76.94,68.08) ; v5(96.12,58.6) 95.66,59.06 95.66,59.3 v4(95.66,59.3)
  GND5 w0.104: v6(96.55,58.73) 96.54,58.71 96.23,58.71 v5(96.12,58.6) ; v6(76.66,69.23) 76.94,68.96 v5(76.94,68.87)
  BOTTOM w0.122: UH1.BK8 v6(96.55,58.73) ; v6(76.66,69.23) 76.94,68.96 UCPU1.AC12
FDI_INT: length 33.7
  IN2 w0.094: v4(99.83,59.19) 99.83,59.5 98.89,60.44 98.25,60.44 97.87,60.82 95.57,60.82 94.93,61.47 93.09,61.47 90.7,63.86 84.18,63.86 80.96,67.08 80.96,69.13 80.14,69.94 77.38,69.94 77.15,70.17 77.15,72.22 v4(77.2,72.28)
  IN4 w0.071: v4(77.2,72.28) 77.25,72.23 v5(77.25,71.77) ; v4(99.83,59.19) 99.83,59.61 v5(99.73,59.71)
  GND5 w0.104: v6(77.25,72.25) v5(77.25,71.77) ; v5(99.73,59.71) 99.67,59.77 99.67,60.09 v6(99.71,60.12)
  BOTTOM w0.122: UCPU1.U11 v6(77.25,72.25) ; v6(99.71,60.12) 99.67,60.09 UH1.BB10
FDI_LSYNC0: length 24.9
  IN2 w0.094: v4(77.88,68.9) 78.98,67.81 79.97,67.81 80.22,67.55 80.22,67.23 84.03,63.42 90.47,63.42 93.48,60.41 v4(95.28,60.41)
  IN4 w0.071: v5(95.38,60.9) 95.38,60.52 v4(95.28,60.41) ; v5(77.91,69.89) 77.71,69.68 77.71,69.08 v4(77.88,68.9)
  GND5 w0.104: v6(95.88,60.73) 95.71,60.9 v5(95.38,60.9) ; v6(77.58,69.56) v5(77.91,69.89)
  BOTTOM w0.122: UCPU1.AA10 77.58,69.56 v6(77.58,69.56) ; v6(95.88,60.73) 95.92,60.76 UH1.BK12
FDI_LSYNC1: length 24.2
  IN2 w0.094: v4(79.2,67.35) 79.55,67.01 80.13,67.01 83.94,63.2 90.42,63.2 93.94,59.68 v4(97.26,59.68)
  IN4 w0.071: v5(78.7,67.37) 78.7,67.37 79.18,67.37 v4(79.2,67.35) ; v4(97.26,59.68) 97.49,59.45 v5(97.49,59.12)
  GND5 w0.104: v5(78.7,67.37) 78.7,67.63 v6(78.54,67.78) ; v6(97.47,59.54) 97.47,59.17 97.49,59.14 v5(97.49,59.12)
  BOTTOM w0.122: UCPU1.AG8 78.53,67.77 v6(78.54,67.78) ; UH1.BH8 97.42,59.48 v6(97.47,59.54)
GATEA20: length 40.5
  TOP w0.076: 138.23,62.23 139.05,61.42 139.25,61.42 139.31,61.35 139.67,61.35 U34.M2
  TOP w0.122: 138.23,62.23 v2(138.15,62.32) 137.41,62.32 RH174.1
  GND1 w0.104: v2(138.15,62.32) v3(137.8,62.66)
  IN1 w0.071: v4(112.15,56.71) 112.54,56.31 114,56.31 114.54,56.86 117.48,56.86 118.55,55.79 119.81,55.79 120.74,56.72 124.83,56.72 127.17,59.06 127.28,59.06 128.72,60.5 128.72,61.19 130.25,62.71 130.83,62.71 131.81,63.69 132.04,63.69 132.89,64.54 136.47,64.54 137.16,63.85 138.58,63.85 138.92,63.51 138.92,63.08 138.5,62.66 v3(137.8,62.66)
  IN4 w0.071: v5(110.42,57.09) 110.78,56.73 112.12,56.73 v4(112.15,56.71)
  GND5 w0.104: v6(110.07,57.54) 110.07,57.44 v5(110.42,57.09)
  BOTTOM w0.122: UH1.U3 110.07,57.01 v6(110.07,57.54)
GYRO_DRDY: length 33.5
  TOP w0.076: U636.G5 161.18,64.32 161.43,64.57 v2(161.87,64.57)
  TOP w0.122: U638.6 141.34,73.58 142.36,72.55 145.29,72.55 145.47,72.73 145.47,73.88 v1(146.36,74.76) 146.36,74.89 146.5,75.03 151.1,75.03 151.53,74.6 151.53,73.36 151.06,72.89 v7(151.06,71.39)
  GND1 w0.104: v3(161.34,64.57) v2(161.87,64.57)
  IN1 w0.071: v7(151.06,71.39) 151.34,71.67 151.84,71.67 152.39,71.11 153.5,71.11 154.36,70.25 154.36,69.44 154.55,69.24 154.55,67.12 155.29,66.38 156.22,66.38 157.14,65.46 160.45,65.46 v3(161.34,64.57)
GYRO_INT#: length 39.6
  TOP w0.122: U638.7 141.99,73.4 142.2,73.19 143.64,73.19 145.83,75.37 145.83,76.75 146.4,77.32 155.26,77.32 v1(155.77,76.81) 156.53,76.81 159.93,73.42 165.55,73.42 166.46,72.51 166.46,72.23 164.99,70.76 164.99,68.12 164.12,67.25 163.7,67.25 162.83,66.38 162.1,66.38 U636.H8
H_CATERR#: length 3
  TOP w0.122: v6(58.73,79.06) 58.86,78.93 T1.1
  GND1 w0.104: v6(58.73,79.06) v3(58.73,79.51)
  IN1 w0.071: v3(58.73,79.51) v4(58.73,79.01)
  IN4 w0.071: v4(58.73,79.01) v5(58.73,78.5)
  GND5 w0.104: v6(58.73,79.06) v5(58.73,78.5)
  BOTTOM w0.122: UCPU1.C49 v6(58.73,79.06)
H_CPU_SVIDALRT#: length 3.2
  TOP w0.122: RC94.1 v2(60.78,80.34)
  GND1 w0.104: v3(60.78,80.78) v2(60.78,80.34)
  IN1 w0.071: v4(61.32,80.28) 61.29,80.28 v3(60.78,80.78)
  IN4 w0.071: v5(61.14,79.79) 61.14,80.09 v4(61.32,80.28)
  GND5 w0.104: v5(61.14,79.79) v6(61.14,80.23)
  BOTTOM w0.122: UCPU1.A44 v6(61.14,80.23)
H_CPU_SVIDCLK: length 2.9
  TOP w0.122: v1(63.2,79.87) 63.13,79.87 62.77,80.23 v7(62.59,80.23) 62.56,80.26 RC92.1
  BOTTOM w0.122: v7(62.59,80.23) 62.08,80.23 61.69,79.84 UCPU1.B43
H_CPU_SVIDDAT: length 5
  TOP w0.122: RC96.1 RC95.1 v2(61.4,78.8) 61.91,79.31 v1(61.91,79.49)
  GND1 w0.104: v3(61.88,78.8) v2(61.4,78.8)
  IN1 w0.071: v4(62.52,78.98) 62.33,78.8 v3(61.88,78.8)
  IN4 w0.071: v5(62.01,78.98) v4(62.52,78.98)
  GND5 w0.104: v6(61.58,78.98) v5(62.01,78.98)
  BOTTOM w0.122: v6(61.58,78.98) 61.22,78.98 UCPU1.C44
H_CPUPWRGD: length 72
  IN1 w0.071: v4(101.78,61.4) 102.45,62.06 102.45,63.64 101.76,64.33 101.76,64.91 101.1,65.57 100.26,65.57 100.06,65.77 100.06,67.68 99.75,67.98 99.75,69.1 99.14,69.71 96.5,69.71 94.5,71.71 93.44,71.71 90.26,74.89 v4(87.87,74.89)
  IN4 w0.071: v4(101.78,61.4) 101.76,61.38 101.76,61.35 101.25,60.84 101.25,60.14 101.56,59.84 v5(101.56,59.73) ; v4(87.87,74.89) 86.91,74.89 82.72,79.08 81.24,79.08 77.77,82.55 75.5,82.55 73.71,84.33 47.73,84.33 v5(47.66,84.26)
  GND5 w0.104: v5(47.66,84.26) 47.66,84.29 v6(47.35,84.59) ; v5(101.56,59.73) 101.56,59.67 101.61,59.62 v6(101.61,59.32)
  BOTTOM w0.122: v6(47.35,84.59) 47.17,84.78 RC53.1 ; UH1.AU10 v6(101.61,59.32)
H_CPUPWRGD_R: length 19.6
  IN4 w0.071: v5(58.71,80.94) 58.59,81.06 52.99,81.06 52.33,80.4 49.14,80.4 48.84,80.1 48.24,80.1 v5(47.81,79.67)
  GND5 w0.104: v5(47.81,79.67) v6(47.81,80.4) ; v6(58.71,80.51) v5(58.71,80.94)
  BOTTOM w0.122: UCPU1.B46 59.01,79.41 58.71,79.72 v6(58.71,80.51) ; RC44.2 RC53.2 47.25,83.36 47.25,82.19 47.02,81.97 47.02,81.5 v1(47.1,81.42) 47.1,81.11 47.81,80.41 v6(47.81,80.4)
H_DRAMRST#: length 41.9
  TOP w0.122: v7(50.22,53.4) 49.84,53.02 RC77.1 49.37,52.38 49.34,52.34 RC74.2
  IN2 w0.094: v7(50.68,64.96) 52.36,63.28 58.2,63.28 58.29,63.2 58.78,63.2 60.55,64.96 60.55,66.26 61.77,67.48 64.57,67.48 67.32,64.73 67.32,64.33 67.72,63.92 v4(67.72,63.51)
  IN4 w0.084: v5(67.57,62.98) 67.57,63.36 v4(67.72,63.51)
  GND5 w0.104: v5(67.57,62.98) 67.83,62.73 67.85,62.73 v6(67.88,62.7)
  BOTTOM w0.122: UCPU1.AT30 67.82,62.7 v6(67.88,62.7) ; v7(50.68,64.96) 50.13,64.41 v1(50.13,64.16) 50.13,63.09 51.14,62.09 51.14,54.32 v7(50.22,53.4) 50.15,53.33 QC2.3
H_PECI: length 129.7
  TOP w0.122: v1(98.95,61.35) 98.95,60.71 99.95,59.71 RH175.2 99.95,59.63 100.56,59.02 v2(101.48,59.02) ; R240.2 140.7,68.03 v7(140.76,68.1)
  GND1 w0.104: v3(101.86,58.86) 101.63,58.86 v2(101.48,59.02)
  IN1 w0.071: v3(101.86,58.86) 102.34,58.38 103.36,58.38 103.69,58.71 103.69,59.8 103.43,60.07 103.43,62.34 103.84,62.75 104.32,62.75 104.76,63.18 104.76,63.72 104.27,64.2 104.12,64.2 102.32,66 101.28,66 101.02,66.26 101.02,67.4 100.16,68.26 100.16,69.33 99.35,70.14 96.68,70.14 94.72,72.1 93.61,72.1 92.39,73.32 92.39,74.41 92.36,74.43 v4(92.36,74.41)
  IN2 w0.094: v4(125.89,79.03) 126.54,78.38 127.44,78.38 128.04,77.79 129.36,77.79 129.99,77.16 131.88,77.16 133.41,75.63 133.41,74.21 136.35,71.26 137.03,71.26 137.37,70.92 137.37,70.73 140,68.1 v7(140.76,68.1)
  IN4 w0.071: v4(125.89,79.03) 125.69,79.24 124.95,79.24 123.83,80.35 119.64,80.35 117.96,82.03 111.59,82.03 111.03,81.47 108.73,81.47 106.66,79.4 97.38,79.4 92.39,74.41 v4(92.36,74.41) 91.44,73.49 90.64,73.49 89.92,72.77 86.28,72.77 84.06,74.99 81.59,74.99 76.38,80.21 70.51,80.21 69.62,79.32 63.22,79.32 63.08,79.46 61.81,79.46 61.17,78.83 60.76,78.83 60.22,79.38 60.19,79.38 59.16,80.41 v5(59.16,80.63)
  GND5 w0.104: v6(59.16,80.2) v5(59.16,80.63)
  BOTTOM w0.122: UCPU1.A48 v6(59.16,80.2)
H_PM_SYNC: length 59.5
  IN1 w0.071: v4(100.39,59.27) 100.71,59.59 100.71,59.82 100.93,60.04 100.93,60.24 101.39,60.7 101.39,61.65 101.68,61.94 101.68,61.99 101.81,62.12 101.81,62.12 101.9,62.22 101.9,62.52 101.81,62.62 101.81,63.58 101.24,64.15 101.24,64.56 100.77,65.04 100.08,65.04 99.63,65.49 99.63,67.17 99.32,67.48 99.32,68.92 98.92,69.32 96.27,69.32 96.22,69.37 96.21,69.37 95.97,69.61 95.89,69.61 94.18,71.32 93.28,71.32 90.99,73.62 88.12,73.62 86.39,75.35 86.14,75.35 83.57,77.91 79.18,77.91 v4(78.26,77)
  IN4 w0.071: v5(100.62,58.84) 100.59,58.87 100.59,58.89 100.41,59.07 100.41,59.25 v4(100.39,59.27) ; v5(60.21,78.92) 60.53,78.6 61.35,78.6 61.48,78.47 62.75,78.47 63.2,78.93 69.78,78.93 70.67,79.82 75.45,79.82 v4(78.26,77)
  GND5 w0.104: v6(100.11,58.89) 100.54,58.89 100.59,58.84 v5(100.62,58.84) ; v6(59.77,78.92) v5(60.21,78.92)
  BOTTOM w0.122: UH1.BB8 v6(100.11,58.89) ; v6(59.77,78.92) 59.78,78.92 59.64,79.06 UCPU1.C48
H_PROCHOT#: length 15.4
  TOP w0.122: v7(46.77,82.44) 46.77,82.37 47.06,82.08 47.2,82.08 47.44,82.33 47.44,82.76 47.4,82.8 47.05,82.8 46.97,82.89 46.97,83.55 R265.1 47.21,83.79 48.14,83.79 48.23,83.71 48.23,83.33 48.31,83.25 49.21,83.25 49.31,83.35 49.31,84.14 49.49,84.31 49.72,84.31 PC124.1 50.32,84 C656.1 50.59,84.92 51.3,84.22 U635.4
  BOTTOM w0.122: RC41.1 44.97,83.89 RC43.1 44.97,83.43 45.04,83.35 45.66,83.35 45.74,83.27 45.74,82.99 45.61,82.87 45.38,82.87 v1(45.35,82.84) 45.64,82.55 45.83,82.55 46.35,82.03 46.48,82.03 46.77,82.32 v7(46.77,82.44)
H_PROCHOT#_EC: length 127.2
  TOP w0.076: v2(143.17,61.3) 143.42,61.55 U34.E2
  TOP w0.122: v2(46.79,84.8) 47.63,84.8 v1(47.91,85.08) 48.78,85.94 48.78,86 49.04,86.27 49.82,86.27 R608.2 50.69,85.4 50.8,85.4 51.21,84.99 51.66,84.99 51.95,85.28 U635.2
  GND1 w0.104: v2(46.79,84.8) v3(47.3,84.8) ; v3(143.28,62.01) 143.28,61.4 v2(143.17,61.3)
  IN1 w0.071: v4(47.05,84.34) 47.05,84.52 47.3,84.77 v3(47.3,84.8) ; v3(143.28,62.01) 143.19,62.1 142.68,62.1 142.45,62.33 142.45,63.05 142.2,63.3 142.2,63.3 141.78,63.72 141.02,64.48 140.61,64.89 137.92,64.89 137.23,65.58 130.87,65.58 130.74,65.71 130.32,65.71 130.14,65.52 128.86,65.52 v4(128.48,65.14) ; v4(120.13,70.77) 119.99,70.77 118.37,69.15 116.18,69.15 115.77,69.57 115.55,69.78 115.45,69.89 115.12,69.89 114.92,69.68 114.92,69.08 114.74,68.9 109.28,68.9 109.05,69.13 108.06,69.13 107.4,69.78 107.4,70.92 107.12,71.2 106.32,71.2 105.52,70.4 105.01,70.4 104.25,71.16 103.74,71.16 102.78,72.12 102.42,72.12 101.73,71.44 101.23,71.44 100.9,71.77 100.57,71.77 99.88,71.08 97.26,71.08 96.53,71.82 96.53,72.3 94.34,74.49 94.34,75.58 v4(93.35,76.57)
  IN2 w0.094: v4(120.13,70.77) 120.42,70.77 122.37,72.72 124.87,72.72 127.64,69.95 127.64,67.09 128.48,66.26 v4(128.48,65.14)
  IN4 w0.071: v4(93.35,76.57) 93.07,76.29 91.69,76.29 90.44,75.04 90,75.04 89.28,74.33 86.93,74.33 82.56,78.69 81.08,78.69 77.61,82.16 75.21,82.16 73.42,83.94 48.07,83.94 47.99,83.86 47.48,83.86 47.05,84.29 v4(47.05,84.34)
H_PROCHOT#_R: length 38.4
  TOP w0.122: v7(40.04,76.23) 39.6,76.23 38.75,77.07 v1(38.75,79.93) 38.75,80.81 39.21,81.27 v7(39.96,81.27)
  IN4 w0.071: v7(40.04,76.23) 41.45,74.82 45.78,74.82 47.19,76.22 48.41,76.22 50.56,78.37 53.1,78.37 55.37,76.11 59.86,76.11 60.85,77.1 60.85,77.7 60.69,77.86 v5(60.69,78.3)
  GND5 w0.104: v6(60.65,78.79) 60.69,78.75 v5(60.69,78.3)
  BOTTOM w0.122: UCPU1.C45 60.55,78.79 v6(60.65,78.79) ; v7(39.96,81.27) 40.18,81.27 41.9,82.99 43.21,82.99 RC41.2
H_THERMTRIP#: length 79
  TOP w0.122: RH176.2 94.49,60.41 92.43,62.47 92.43,63.06 91.5,63.98 91.5,64.81 91.14,65.16 91.14,69.18 89.85,70.47 89.85,72.85 92.74,75.74 v1(92.88,75.74) v2(93.78,76.64)
  GND1 w0.104: v2(93.78,76.64) v3(93.78,77.08)
  IN1 w0.071: v4(92.97,77.56) 93,77.58 93.28,77.58 v3(93.78,77.08)
  IN4 w0.071: v4(92.97,77.56) 92.95,77.58 92.95,79.26 89.34,82.87 82.05,82.87 80.58,84.34 76.49,84.34 74.3,86.53 52.67,86.53 52.15,86 49.5,86 48.89,86.61 44.18,86.61 43.76,86.19 v7(43,86.19)
  BOTTOM w0.122: RC49.1 43.19,86 v7(43,86.19)
H_THERMTRIP#_C: length 7.1
  TOP w0.122: RH176.1 95.4,60 95.68,60.27 v1(96.67,60.27) 98.31,60.27 98.51,60.07 v2(98.51,59.52)
  GND1 w0.104: v2(98.51,59.52) 98.71,59.52 v3(98.94,59.75)
  IN1 w0.071: v3(98.94,59.75) 98.94,59.71 v4(99.28,59.37)
  IN4 w0.071: v5(99.28,60.11) v4(99.28,59.37)
  GND5 w0.104: v5(99.28,60.11) 99.27,60.1 v6(99.27,59.55)
  BOTTOM w0.122: UH1.BC9 99.14,59.42 v6(99.27,59.55)
H_THERMTRIP#_R: length 35.4
  TOP w0.122: v7(39.48,80.81) 39.19,80.52 39.19,77.25 39.59,76.85 v7(39.9,76.85)
  IN4 w0.071: v5(60.56,77.3) 60.56,77.17 59.87,76.48 55.54,76.48 53.06,78.96 50.6,78.96 48.25,76.61 47.03,76.61 45.61,75.19 41.68,75.19 40.02,76.85 v7(39.9,76.85)
  GND5 w0.104: v6(60.41,77.97) 60.56,77.81 v5(60.56,77.3)
  BOTTOM w0.122: v7(39.48,80.81) 39.48,81.42 39.85,81.79 40.08,81.79 v1(41.16,82.87) 41.71,83.43 42.75,83.43 RC49.2 ; UCPU1.D45 60.38,78 v6(60.41,77.97)
H_VCCP_SEL: length 1.4
  TOP w0.122: T223.1 71.35,59.17 71.15,59.17 70.87,59.45 v7(70.8,59.45)
  BOTTOM w0.122: v7(70.8,59.45) 71.11,59.14 T223.1
HDA_BIT_CLK: length 12.8
  TOP w0.122: RH27.2 115.57,68.12 115.41,67.96 114.99,67.96 114.87,68.08 114.87,68.39 114.74,68.52 v1(114.13,68.52) 113.52,68.52 113.39,68.39 113.39,68.16 113.52,68.03 113.72,68.03 113.9,67.86 113.9,67.53 114,67.43 114.53,67.43 114.64,67.32 114.64,67.12 114.53,67.01 114,67.01 113.9,66.91 113.9,66.69 113.77,66.56 113.51,66.56 113.38,66.69 113.38,67.61 112.94,68.06 112.94,68.9 113.06,69.02 113.8,69.02 v2(113.93,68.9)
  GND1 w0.104: v3(113.93,69.3) v2(113.93,68.9)
  IN1 w0.071: v4(113.93,69.79) v3(113.93,69.3)
  IN4 w0.071: v4(113.93,69.79) 113.93,70.22 v5(113.99,70.28)
  GND5 w0.104: v6(113.99,69.79) v5(113.99,70.28)
  BOTTOM w0.122: UH1.H35 v6(113.99,69.79)
HDA_BITCLK_AUDIO: length 150.3
  TOP w0.122: v7(17.37,44.44) 17.85,43.95 19.08,43.95 v1(19.34,44.21) 19.34,44.74 21.11,46.52 21.11,46.88 21.72,47.48 27.59,47.48 28.25,46.82 32.26,46.82 32.84,46.24 35.97,46.24 36.68,46.95 52.52,46.95 53.27,47.71 53.9,47.71 54.39,47.21 55.19,47.21 56.16,46.25 57.14,46.25 58.77,47.88 60.26,47.88 61.29,46.85 78.42,46.85 78.6,47.03 83.05,47.03 88.74,52.72 90.65,52.72 92.6,54.68 92.89,54.68 94.03,55.82 v7(94.03,56.26) ; RH27.1 116.48,68.44 116.9,68.86 118.32,68.86 118.41,68.77 118.41,68.59 118.33,68.52 117.53,68.52 117.38,68.36 117.38,68.03 117.25,67.91 116.72,67.91 116.59,67.78 116.59,67.6 116.39,67.4 116.26,67.4 116.14,67.53 116.14,67.84 116.01,67.97 115.83,67.97 115.7,67.84 115.7,67.68 115.58,67.55 114.99,67.55 114.87,67.42 114.87,67.2 114.99,67.07 116.01,67.07 116.14,66.94 116.14,65.97 CH117.1 116.57,65.96 116.57,67.07 v2(117.02,67.53)
  GND1 w0.104: v2(117.02,67.53) v3(116.59,67.53)
  IN1 w0.071: v3(116.59,67.53) 115.3,67.53 114.17,66.4 112.17,66.4 111.86,66.09 111.86,65.75 111.54,65.44 111.54,64.43 111.21,64.1 111.21,63.31 111.34,63.18 111.34,61.38 110.01,60.06 109.58,60.06 108.64,59.12 108.62,59.12 107.75,58.25 107.69,58.25 106.67,57.24 105.44,57.24 105.16,56.96 104.27,56.96 104.12,57.11 95.58,57.11 94.75,56.27 94.04,56.27 v7(94.03,56.26)
  IN2 w0.094: v4(15.07,26.4) 15.38,26.72 15.38,29 15.58,29.21 15.58,29.75 15.86,30.02 15.86,35.71 15.54,36.03 15.54,39.23 16.41,40.1 16.41,40.64 17.04,41.27 17.04,42.16 17.52,42.64 17.52,44.28 v7(17.37,44.44)
  IN4 w0.071: v5(15.15,27.37) 15.15,26.48 v4(15.07,26.4)
  GND5 w0.104: v5(15.15,27.37) 15.12,27.37 v6(14.76,27.01)
  BOTTOM w0.122: LH9.1 14.16,27.61 v6(14.76,27.01)
HDA_BITCLK_AUDIO_C: length 10.2
  BOTTOM w0.122: JIOL1.14 17.1,24.32 17.06,24.28 17.06,23.88 16.49,23.3 14.69,23.3 14.49,23.51 13.15,23.51 12.38,24.28 v1(12.38,26.41) LH9.2
HDA_RST#: length 12.9
  TOP w0.122: RH28.2 117.98,69.18 118.22,69.18 118.32,69.28 118.32,69.82 118.19,69.95 117.65,69.95 117.36,70.24 116.95,70.24 116.87,70.32 v1(116.87,70.42) 116.87,70.6 116.75,70.73 116.57,70.73 116.44,70.6 116.44,69.86 116.34,69.76 115.78,69.76 115.68,69.87 115.68,69.94 115.57,70.04 115.39,70.04 115.29,69.94 115.29,69.84 115.18,69.74 114.89,69.74 v2(114.76,69.86)
  GND1 w0.104: v2(114.76,69.86) 114.36,69.46 v3(114.36,69.3)
  IN1 w0.071: v4(114.48,69.79) 114.64,69.79 114.71,69.71 114.71,69.38 114.56,69.23 114.43,69.23 v3(114.36,69.3)
  IN4 w0.071: v5(114.85,70.28) 114.85,70.46 114.94,70.55 115.06,70.55 115.15,70.46 115.15,70.37 115.3,70.22 115.35,70.22 115.45,70.12 115.45,69.98 115.35,69.89 114.97,69.89 114.88,69.8 114.88,69.34 114.82,69.28 114.23,69.28 114.15,69.35 114.15,69.48 114.46,69.79 v4(114.48,69.79)
  GND5 w0.104: v6(114.85,69.77) v5(114.85,70.28)
  BOTTOM w0.122: UH1.F35 v6(114.85,69.77)
HDA_RST_AUDIO#: length 143.4
  TOP w0.122: v7(18.47,45.05) 18.78,45.35 18.78,45.97 20.78,47.98 27.8,47.98 28.46,47.32 32.46,47.32 33.04,46.74 35.76,46.74 36.47,47.45 52.31,47.45 53.07,48.2 54.1,48.2 54.6,47.71 55.4,47.71 56.36,46.74 56.94,46.74 58.57,48.38 60.46,48.38 61.5,47.34 78.21,47.34 78.4,47.53 82.84,47.53 88.53,53.22 90.44,53.22 92.09,54.88 92.09,55.09 v1(92.59,55.59) 92.92,55.92 92.92,56.63 93.23,56.93 93.54,56.93 v7(94.02,57.42) ; RH28.1 119.16,69.3 v2(119.34,69.13)
  GND1 w0.104: v2(119.34,69.13) v3(119.34,68.69)
  IN1 w0.071: v3(119.34,68.69) 119.25,68.6 115.61,68.6 113.78,66.77 111.5,66.77 110.8,66.08 110.8,65.34 110.6,65.14 109.76,65.14 108.77,64.15 108.77,63.04 108.63,62.9 108.63,61.98 107.85,61.19 107.85,60.63 107.4,60.19 107.09,60.19 106.97,60.3 106.07,60.3 103.35,57.59 94.19,57.59 v7(94.02,57.42)
  IN2 w0.094: v7(17.13,23.3) 17.13,24.24 16.84,24.54 16.84,29.47 16.63,29.67 16.63,39.7 16.85,39.92 16.85,40.46 17.48,41.09 17.48,41.98 18.03,42.53 18.03,44.61 v7(18.47,45.05)
  BOTTOM w0.122: JIOL1.20 18.6,24.24 18.65,24.19 18.65,23.55 18.5,23.39 17.76,23.39 17.69,23.32 17.14,23.32 v7(17.13,23.3)
HDA_SDIN0: length 148.2
  TOP w0.122: v7(17.23,45.66) 17.23,46.04 17.89,46.7 17.89,46.76 v1(18.8,47.67) 19.95,48.82 30.05,48.82 30.8,48.06 32.77,48.06 33.34,47.5 35.46,47.5 36.16,48.2 50.62,48.2 50.89,48.46 52.27,48.46 52.76,48.95 54.41,48.95 54.9,48.47 56.51,48.47 56.69,48.65 57.78,48.65 58.26,49.12 60.77,49.12 61.81,48.09 77.9,48.09 78.09,48.28 82.51,48.28 88.2,53.97 90.13,53.97 91.33,55.17 91.33,55.68 92.04,56.39 92.04,57.09 92.51,57.56 92.51,57.73 92.71,57.93 v7(93.09,58.3)
  IN1 w0.071: v4(115.29,69.51) 115.29,68.87 113.56,67.14 109.63,67.14 108.62,66.13 108.03,66.13 107.68,65.77 107.68,64.4 108.08,64 108.08,63.39 106.66,61.96 106.66,60.9 106.44,60.68 105.92,60.68 103.29,58.05 94.59,58.05 94.3,58.34 93.13,58.34 v7(93.09,58.3)
  IN2 w0.094: v7(16.34,22.8) 16.34,23.47 16.53,23.66 16.53,24.22 16.26,24.49 15.72,24.49 14.64,25.57 14.64,26.58 15.16,27.1 15.16,29.1 15.36,29.3 15.36,29.84 15.64,30.11 15.64,35.62 15.23,36.02 15.23,39.24 16.19,40.2 16.19,40.73 16.81,41.36 16.81,42.25 17.23,42.66 17.23,43.97 16.94,44.26 16.94,45.36 v7(17.23,45.66)
  IN4 w0.071: v5(115.45,70.51) 115.65,70.31 115.65,69.87 v4(115.29,69.51)
  GND5 w0.104: v6(115.45,70.1) v5(115.45,70.51)
  BOTTOM w0.122: JIOL1.26 20.1,23.46 19.53,22.89 18.1,22.89 17.41,22.19 17.01,22.19 16.4,22.8 v7(16.34,22.8) ; v5(115.45,70.51) v6(115.45,70.1)
HDA_SDO: length 41.6
  TOP w0.122: v2(119.48,70.34) 119.48,70.75 RH24.1 119.44,71.34 119.47,71.36 v1(119.81,71.36) ; U34.C1 144.42,62.55 144.72,62.85 v2(144.72,62.9)
  GND1 w0.104: v3(144.69,63.5) 144.72,63.46 v2(144.72,62.9) ; v2(119.48,70.34) 119.56,70.26 v3(119.56,69.87)
  IN1 w0.071: v4(144.37,62.95) 144.37,63.18 v3(144.69,63.5) ; v3(119.56,69.87) 119.86,70.17 v4(120.01,70.17)
  IN2 w0.094: v4(120.01,70.17) 119.64,70.53 119.64,70.87 119.92,71.15 120.5,71.15 122.31,72.96 124.94,72.96 127.88,70.02 127.88,67.67 129.14,66.41 129.14,65.04 128.77,64.68 128.77,64.2 129.8,63.17 131.27,63.17 132.33,62.11 132.33,61.94 132.61,61.66 133.4,61.66 133.9,62.16 136.1,62.16 136.76,62.82 136.76,63.39 137.36,63.99 143.33,63.99 v4(144.37,62.95)
HDA_SDOUT: length 18.1
  TOP w0.122: RH30.2 118.02,70.45 118.42,70.85 118.42,71.08 118.17,71.34 RH24.2 117.76,71.34 117.41,70.98 116.47,70.98 115.95,70.47 115.94,70.47 ; 115.94,70.47 115.94,70.82 115.87,70.89 114.9,70.89 114.84,70.95 114.84,71.15 CH103.1 115.22,71.53 115.22,71.69 114.92,72 114.5,72 114.24,71.74 114.24,71.4 v2(114.36,71.29) ; 115.94,70.47 RH42.2
  GND1 w0.104: v3(114.36,70.88) v2(114.36,71.29)
  IN1 w0.071: v4(113.88,71.11) 113.88,71.31 113.94,71.37 114.4,71.37 114.5,71.27 114.5,70.93 114.45,70.88 v3(114.36,70.88)
  IN4 w0.071: v5(113.57,70.73) 113.1,70.73 112.97,70.85 112.83,70.85 112.78,70.8 112.78,70.19 112.88,70.09 112.98,70.09 113.05,70.15 113.05,70.38 113.09,70.42 113.71,70.42 114.37,71.08 114.37,71.17 114.24,71.3 114.24,71.42 114.32,71.5 114.45,71.5 114.51,71.44 114.65,71.44 114.71,71.5 114.84,71.5 114.93,71.59 114.93,71.71 114.84,71.79 114.04,71.79 113.98,71.73 113.98,71.54 113.93,71.49 113.77,71.49 113.63,71.35 113.63,71.23 113.76,71.11 v4(113.88,71.11)
  GND5 w0.104: v6(113.13,70.71) 113.14,70.73 v5(113.57,70.73)
  BOTTOM w0.122: UH1.K37 113.1,71.3 112.95,71.3 112.87,71.22 112.87,71.07 113.13,70.82 v6(113.13,70.71)
HDA_SDOUT_AUDIO: length 162.8
  TOP w0.122: v2(118.99,69.9) 118.9,70 RH30.1 ; v7(93.6,57.92) 93.51,57.84 93.03,57.84 92.78,57.58 92.78,57.4 92.32,56.95 92.32,56.31 91.59,55.58 91.59,55.07 90.23,53.72 88.32,53.72 82.63,48.03 78.19,48.03 78,47.84 61.7,47.84 60.67,48.87 58.36,48.87 57.89,48.4 56.79,48.4 56.61,48.22 54.79,48.22 54.31,48.7 52.86,48.7 52.22,48.06 v1(51.61,48.06) 50.83,48.06 50.72,47.95 36.27,47.95 35.57,47.25 33.24,47.25 32.67,47.82 29.02,47.82 28.37,48.47 20.32,48.47 v7(18.09,46.24)
  GND1 w0.104: v3(119.26,69.56) 119.26,69.63 v2(118.99,69.9)
  IN1 w0.071: v3(119.26,69.56) 118.52,68.81 115.49,68.81 113.64,66.96 111.4,66.96 110.37,65.93 108.24,65.93 108.03,65.72 108.03,65.29 108.44,64.88 108.44,63.31 106.85,61.72 106.85,60.97 106.85,60.82 106.52,60.49 105.99,60.49 103.3,57.8 94.29,57.8 94.17,57.92 v7(93.6,57.92)
  IN2 w0.094: v7(17.2,22.64) 16.94,22.64 16.81,22.77 16.81,22.96 16.7,23.07 16.7,23.48 16.82,23.61 16.82,24.24 16.61,24.44 16.61,24.72 16.51,24.82 15.73,24.82 15.62,24.93 15.62,25.09 15.73,25.2 16.51,25.2 16.6,25.29 16.6,25.48 16.51,25.57 16.29,25.57 16.2,25.67 16.2,25.86 16.29,25.95 16.51,25.95 16.6,26.04 16.6,26.23 16.51,26.33 15.73,26.33 15.62,26.44 15.62,26.59 15.73,26.7 16.51,26.7 16.61,26.81 16.61,27.71 16.52,27.81 16.28,27.81 16.17,27.92 16.17,28.07 16.28,28.18 16.52,28.18 16.61,28.28 16.61,29.37 16.41,29.58 16.41,29.85 16.32,29.95 16.18,29.95 16.09,30.04 16.09,30.23 16.18,30.32 16.32,30.32 16.41,30.42 16.41,30.6 16.32,30.7 16.18,30.7 16.09,30.79 16.09,30.98 16.18,31.07 16.32,31.07 16.41,31.17 16.41,31.36 16.32,31.45 16.18,31.45 16.09,31.54 16.09,31.73 16.18,31.83 16.32,31.83 16.41,31.92 16.41,32.11 16.32,32.2 16.18,32.2 16.09,32.3 16.09,32.48 16.18,32.58 16.32,32.58 16.41,32.67 16.41,32.86 16.32,32.95 16.18,32.95 16.09,33.05 16.09,33.24 16.18,33.33 16.32,33.33 16.41,33.42 16.41,33.61 16.32,33.71 16.18,33.71 16.09,33.8 16.09,33.99 16.18,34.08 16.32,34.08 16.41,34.18 16.41,34.36 16.32,34.46 16.18,34.46 16.09,34.55 16.09,34.74 16.18,34.83 16.32,34.83 16.41,34.93 16.41,35.12 16.32,35.21 16.18,35.21 16.09,35.3 16.09,35.49 16.18,35.59 16.32,35.59 16.41,35.68 16.41,35.95 16.31,36.05 15.87,36.05 15.76,36.16 15.76,36.32 15.87,36.43 16.31,36.43 16.4,36.52 16.4,36.71 16.31,36.81 15.87,36.81 15.76,36.92 15.76,37.07 15.87,37.18 16.31,37.18 16.4,37.28 16.4,37.46 16.31,37.56 15.87,37.56 15.76,37.67 15.76,37.82 15.87,37.93 16.31,37.93 16.41,38.04 16.41,39.79 16.63,40.01 16.63,40.55 17.26,41.18 17.26,42.07 17.81,42.62 17.81,44.77 17.72,44.87 17.35,44.87 17.24,44.98 17.24,45.13 17.35,45.24 17.72,45.24 17.81,45.34 17.81,45.55 17.91,45.66 18.43,45.66 18.74,45.96 18.74,46.09 18.59,46.24 18.59,46.37 18.73,46.51 18.86,46.51 19.01,46.36 19.14,46.36 19.41,46.64 19.41,46.77 19.29,46.9 18.35,46.9 18.09,46.64 18.09,46.24 v7(18.09,46.24)
  BOTTOM w0.122: v7(17.2,22.64) 17.46,22.64 17.95,23.14 19.41,23.14 19.84,23.57 19.84,23.99 19.6,24.23 JIOL1.24
HDA_SPKR: length 149
  TOP w0.122: v7(16.59,43.98) 16.58,43.99 16.58,44.02 16.9,44.33 16.9,44.62 17.77,45.49 18.23,45.49 v1(18.42,45.68) 18.51,45.77 18.51,46.06 20.67,48.22 28.26,48.22 28.92,47.57 32.57,47.57 33.15,46.99 35.66,46.99 36.37,47.7 52.21,47.7 52.96,48.45 54.21,48.45 54.7,47.96 55.5,47.96 56.47,46.99 56.83,46.99 58.47,48.63 60.57,48.63 61.6,47.59 78.11,47.59 78.3,47.78 82.74,47.78 88.43,53.47 90.34,53.47 91.84,54.97 91.84,55.48 92.62,56.26 92.62,56.75 93.24,57.38 v7(93.26,57.38)
  IN1 w0.071: v7(111.28,55.77) 110.57,56.48 109.66,56.48 109.25,56.88 107.37,56.88 107.22,56.73 106.94,56.73 106.62,57.05 105.54,57.05 105.24,56.76 104.11,56.76 103.99,56.87 95.64,56.87 94.61,55.84 93.28,55.84 93,56.12 93,57.11 v7(93.26,57.38)
  IN2 w0.094: v7(16.59,43.98) 16.95,43.62 16.95,42.7 16.59,42.34 16.59,41.45 15.81,40.66 15.81,40.13 14.95,39.27 14.95,36 15.42,35.53 15.42,30.21 15.14,29.93 15.14,29.39 14.94,29.19 14.94,27.95 14.34,27.36 14.34,24.18 16.57,21.96 v7(16.59,21.96)
  BOTTOM w0.122: UH1.N1 111.65,56.13 v7(111.28,55.77) 111.61,55.77 111.74,55.64 111.74,55.32 111.61,55.2 111.23,55.2 111.11,55.07 111.11,54.9 111.23,54.78 112.25,54.78 112.38,54.66 112.38,54.48 112.25,54.36 111.38,54.36 111.26,54.24 111.26,54.07 111.38,53.95 112.51,53.95 112.63,53.82 112.63,53.73 112.03,53.14 112.03,50.6 112.58,50.05 RH37.2 ; v7(16.59,21.96) 16.62,21.93 17.51,21.93 18.21,22.63 19.69,22.63 20.6,23.54 JIOL1.28
HDA_SYNC: length 28.4
  TOP w0.122: RH36.2 RH279.2 131.39,68.99 v1(132.26,68.99) 133.05,68.99 QH1.1 133.85,70.45 133.47,70.83 132.65,70.83 v2(132.14,71.34)
  GND1 w0.104: v2(132.14,71.34) v3(131.78,71.69)
  IN1 w0.071: v3(131.78,71.69) 131.73,71.74 v4(131.12,71.74)
  IN4 w0.071: v5(114.51,70.79) 114.55,70.75 115.15,70.75 116.24,71.84 117.02,71.84 117.1,71.77 118.18,71.77 121.28,74.86 125.3,74.86 126.93,73.24 129.19,73.24 130.69,71.74 v4(131.12,71.74)
  GND5 w0.104: v6(113.99,70.79) v5(114.51,70.79)
  BOTTOM w0.122: UH1.H37 v6(113.99,70.79)
