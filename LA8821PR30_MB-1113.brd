# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BMON_OUT: length 1.1
  TOP w0.254: PR960.1 125.23,31.8 125.34,31.69 PU702.6
BOOT: length 4.1
  BOTTOM w0.122: PR23.1 144.3,38.83 143.8,39.33 v1(143.29,39.33)
  BOTTOM w0.254: PR23.1 144.79,37.82 145.23,37.82 145.54,37.51 PU2.25
BOOT0: length 3.9
  TOP w0.122: U636.A6 157.02,64.82 v1(156.85,64.66) 156.62,64.66 156.46,64.49 155.96,64.49 R819.2 155.82,63.88 155.89,63.81 R1092.1
BOOT1:
  vias: v1(27.72,78.04)
BOOT1G:
  vias: v1(20.43,76.64)
BOOT_1.35V: length 2.7
  TOP w0.203: PR300.2 34.99,20.98 33.97,22 33.59,22 33.56,21.97 PU300.18
BST1_3V: length 1.3
  TOP w0.254: PR206.1 187.34,55.77 187.55,55.97 PC208.1
BST1_5V: length 2.6
  TOP w0.122: v9(199,53.45) PC209.2
  TOP w0.254: PC209.2 PR207.2
BST_3V: length 5.5
  TOP w0.254: PU501.7 191.44,56.43 191.1,56.78 187.19,56.78 PR206.2
BST_5V: length 3
  TOP w0.254: PR207.1 196.97,56.73 195.85,56.73 195.82,56.71 195.82,56.71 195.55,56.43 PU501.19
BST_+V1.05S_VCCPP:
  vias: v9(127.79,45.2)
BT_RADIO_DIS#: length 87.2
  TOP w0.122: R731.1 179.71,51.42 179.71,47.58 179.32,47.18 v1(178.98,47.18) 178.75,47.18 178.29,46.72 177.32,46.72 176.7,46.1 RH294.1 175.39,45.92 v7(175.39,45.3)
  IN2 w0.094: v7(175.39,45.3) 175.01,45.3 172.31,48 170.82,48 169.9,48.92 159.77,48.92 158.41,47.56 148.5,47.56 144.91,51.15 144.91,53.26 143.03,55.14 139.02,55.14 137.89,56.27 137.89,56.43 137.13,57.19 136.53,57.19 136.09,56.74 128.21,56.74 127.52,57.44 126.93,57.44 126.8,57.32 125.53,57.32 125.38,57.16 120.86,57.16 120.61,56.91 119.74,56.91 118.67,55.84 117.8,55.84 117.08,56.57 116.07,56.57 115.08,55.58 114.13,55.58 113.27,56.43 112.74,56.43 112.55,56.62 112.55,57.15 112.38,57.33 112.38,57.57 112.1,57.85 111.01,57.85 v4(110.7,57.54)
  IN4 w0.071: v4(110.7,57.54) 110.9,57.34 v5(110.9,57.09)
  GND5 w0.104: v5(110.9,57.09) 110.91,57.09 v6(110.91,57.55)
  BOTTOM w0.122: v6(110.91,57.55) 110.9,57.54 UH1.R3
BUF_CPU_RST#: length 27.6
  TOP w0.122: v7(61.22,77.94) 61.22,77.76 60.38,76.92 60.38,73.49 60.26,73.37 60.08,73.37 59.95,73.49 59.95,77.13 60.64,77.81 60.64,78.19 60.51,78.32 60,78.32 59.87,78.19 59.87,77.69 59.75,77.56 59.57,77.56 59.41,77.72 59.41,78.07 59.28,78.19 58.73,78.19 58.08,78.84 58.08,79.2 58.22,79.34 58.22,79.72 58.34,79.83 58.48,79.83 58.6,79.71 58.6,79.59 58.73,79.46 58.99,79.46 v1(58.99,79.82) 58.99,80.1 58.86,80.23 57.46,80.23 56.66,79.43 56.53,79.43 56.35,79.62 56.35,79.74 57.08,80.48 57.08,81.24 56.95,81.37 56.95,82.13 56.73,82.36 56.73,82.54 56.85,82.66 57.06,82.66 57.59,82.13 57.59,80.99 57.68,80.89 RC34.1 58.54,80.89 58.57,80.93 RC33.2
  BOTTOM w0.122: v7(61.22,77.94) 61.22,78.23 UCPU1.D44
BUFO_CPU_RST#: length 111.3
  TOP w0.122: v1(125.27,80.38) 125.91,81.03 v7(125.91,81.11) ; v2(60.28,82.33) 60.28,82.21 RC32.2 59.41,81.81 59.37,81.84 RC33.1
  GND1 w0.104: v2(60.28,82.33) v3(60.28,81.9)
  IN1 w0.071: v3(60.28,81.9) 60.71,81.47 v4(60.71,81.45) ; v4(94.83,77.46) 95.89,77.46 96.88,78.45 101.43,78.45 102.28,77.6 106.65,77.6 107.78,78.73 111.64,78.73 112.82,79.91 121.13,79.91 122.69,81.47 125.56,81.47 v7(125.91,81.11)
  IN4 w0.071: v4(60.71,81.45) 62.05,82.78 72.94,82.78 74.73,80.99 77.13,80.99 80.59,77.53 82.08,77.53 86.45,73.16 89.76,73.16 90.48,73.88 91.25,73.88 v4(94.83,77.46)
  BOTTOM w0.122: v7(125.91,81.11) 126.04,80.99 RC130.2 126.38,80.07 128.61,80.07 128.8,80.26 128.8,84.91 128.92,85.04 129.32,85.04 129.45,84.92 129.45,80.45 129.57,80.33 129.81,80.33 129.93,80.45 129.93,84.92 130.06,85.04 130.3,85.04 130.42,84.92 130.42,82.02 130.54,81.9 130.79,81.9 130.91,82.02 130.91,84.92 131.03,85.04 131.39,85.04 131.52,84.91 131.52,81.86 130.92,81.27 130.92,80.19 130.53,79.79 129.6,79.79 129.2,79.39 UC2.4
CAB_DET_SINK: length 8.3
  BOTTOM w0.122: RV9.1 RV8.2 215.31,74.47 216.08,73.7 217.1,73.7 v1(217.15,73.65) 217.4,73.4 JMDP1.4
CAPS_LED: length 5
  TOP w0.122: JKB1.27 166.9,28.22 167,28.32 167.46,28.32 167.57,28.43 169.65,28.43 v1(169.99,28.77) 170.38,29.17 170.55,29.17 R943.2
CAPS_LED#: length 91.5
  TOP w0.076: U34.B3 145.17,61.35 145.52,61.35 145.64,61.35 v2(145.83,61.55)
  TOP w0.122: v1(166.28,33.41) 166.82,33.96 Q326.3 166.55,34.57 v7(165.7,35.43)
  GND1 w0.104: v2(145.83,61.55) 145.66,61.38 v3(145.35,61.38)
  IN1 w0.071: v3(145.35,61.38) 145.38,61.34 147.43,61.34 148.66,62.57 149.09,62.57 149.23,62.42 152.16,62.42 153.84,60.74 153.84,59.44 154.43,58.85 156.12,58.85 157.38,57.59 163.23,57.59 163.67,57.15 164.91,57.15 165.97,56.09 168.52,56.09 168.97,56.53 170.37,56.53 171.72,55.18 171.72,54.22 172.6,53.34 175.1,53.34 179.95,48.5 179.95,38.64 180.21,38.37 180.21,34.09 179.91,33.78 179.91,32.62 176.81,29.53 176.81,29.12 173.78,26.09 169.55,26.09 168.87,25.41 166.2,25.41 v4(165.23,26.38)
  IN4 w0.071: v4(165.23,26.38) 165.44,26.58 165.44,31.2 165.7,31.47 v7(165.7,35.43)
  BOTTOM w0.122: R990.1 v7(165.7,35.43)
CFG0: length 3.7
  TOP w0.122: T232.1 v2(57.74,79.84)
  GND1 w0.104: v2(57.74,79.84) v3(57.31,79.84)
  IN1 w0.071: v3(57.31,79.84) 57.56,79.84 v4(57.92,79.49)
  IN4 w0.071: v5(57.54,79.79) 57.84,79.49 v4(57.92,79.49)
  GND5 w0.104: v6(57.36,80.28) 57.54,80.1 v5(57.54,79.79)
  BOTTOM w0.122: v6(57.36,80.28) 57.54,80.1 57.54,79.62 T232.1
CFG1: length 3.7
  TOP w0.122: T208.1 57.35,79.25 v2(57.61,78.98)
  GND1 w0.104: v2(57.61,78.98) v3(58.05,78.98)
  IN1 w0.071: v4(57.36,79.34) 57.72,78.98 v3(58.05,78.98)
  IN4 w0.071: v5(58.05,78.99) 58.04,78.98 57.72,78.98 v4(57.36,79.34)
  GND5 w0.104: v6(57.61,78.99) v5(58.05,78.99)
  BOTTOM w0.122: v6(57.61,78.99) 57.26,78.99 UCPU1.C51
CFG2: length 4.9
  TOP w0.122: RC78.1 53.65,80.42 v1(54.33,79.74) 54.68,79.39 v2(55.33,79.39)
  GND1 w0.104: v3(55.76,79.39) v2(55.33,79.39)
  IN1 w0.071: v4(55.28,79.39) v3(55.76,79.39)
  IN4 w0.071: v5(55.77,79.39) v4(55.28,79.39)
  GND5 w0.104: v5(55.77,79.39) 55.77,79.01 v6(55.71,78.96)
  BOTTOM w0.122: v6(55.71,78.96) 55.77,79.01 UCPU1.B54
CFG3: length 3.6
  TOP w0.122: v6(56.06,78.68) 56.32,78.42 T209.1
  GND1 w0.104: v6(56.06,78.68) 56.34,78.4 v5(56.42,78.4)
  IN1 w0.071: v4(57.18,78.12) 57,78.3 56.53,78.3 v5(56.42,78.4)
  IN4 w0.071: v4(57.18,78.12) 57,78.3 56.53,78.3 v5(56.42,78.4)
  GND5 w0.104: v5(56.42,78.4) 56.37,78.45 56.29,78.45 v6(56.06,78.68)
  BOTTOM w0.122: v6(56.06,78.68) 56.29,78.45 56.39,78.45 T209.1
CFG4: length 29.4
  IN4 w0.071: v8(39.63,77.43) 39.98,77.43 41.84,75.57 45.43,75.57 46.87,77 48.09,77 50.43,79.34 54.03,79.34 54.43,78.93 55.76,78.93 v5(56.34,79.51)
  GND5 w0.104: v5(56.34,79.51) 56.5,79.67 v6(56.78,79.67)
  BOTTOM w0.122: UCPU1.A51 56.9,79.79 v6(56.78,79.67) ; v8(39.63,77.43) 39.45,77.61 39.45,79.96 38.88,80.53 38.88,81.95 40.8,83.87 RC81.1
CFG5: length 6.8
  TOP w0.122: v2(55.71,78.96) 53.78,78.96 v1(53.04,79.69) 53.04,80.61 RC87.1
  GND1 w0.104: v2(55.71,78.96) 55.79,79.03 56.29,79.03 v5(56.32,79.06)
  IN1 w0.071: v4(56.8,79.06) v5(56.32,79.06)
  IN4 w0.071: v5(56.32,79.06) v4(56.8,79.06)
  GND5 w0.104: v6(56.75,79.06) v5(56.32,79.06)
  BOTTOM w0.122: UCPU1.C53 v6(56.75,79.06)
CFG6: length 8.3
  BOTTOM w0.122: UCPU1.C55 55.21,79.35 55.56,79.69 55.56,79.97 54.78,80.75 51.4,80.75 50.02,82.13 RC86.1
CFG7: length 3.3
  TOP w0.122: RC89.1 58.3,77.34 v2(58.3,77.66)
  GND1 w0.104: v2(58.3,77.66) v3(58.3,77.23)
  IN1 w0.071: v4(58.78,77.08) 58.64,77.23 v3(58.3,77.23)
  IN4 w0.071: v4(58.78,77.08) 58.53,77.08 v5(58.22,76.77)
  GND5 w0.104: v6(57.82,76.61) 57.98,76.77 v5(58.22,76.77)
  BOTTOM w0.122: UCPU1.H49 v6(57.82,76.61)
CFG8: length 6.7
  BOTTOM w0.122: UCPU1.A55 54.52,80.48 51.14,80.48 50.25,81.37 T213.1
CFG9: length 3.6
  TOP w0.122: v2(57.28,76.8) 57.28,76.31 T210.1
  GND1 w0.104: v3(57.69,76.59) 57.49,76.8 v2(57.28,76.8)
  IN1 w0.071: v3(57.69,76.59) 57.69,77.15 v4(57.67,77.18)
  IN4 w0.071: v5(57.23,76.77) 57.26,76.77 v4(57.67,77.18)
  GND5 w0.104: v5(57.23,76.77) 57.23,76.72 56.83,76.31 v6(56.83,76.29)
  BOTTOM w0.122: UCPU1.H51 v6(56.83,76.29)
CFG10: length 3.6
  TOP w0.122: v6(58.25,74.87) 58.25,73.89 T211.1
  GND1 w0.104: v6(58.25,74.87) v5(58.71,74.87)
  IN1 w0.071: v5(58.71,74.87) 58.48,74.87 v4(58.25,74.64)
  IN4 w0.071: v4(58.25,74.64) 58.48,74.87 v5(58.71,74.87)
  GND5 w0.104: v6(58.25,74.87) v5(58.71,74.87)
  BOTTOM w0.122: UCPU1.K49 v6(58.25,74.87)
CFG11: length 3.3
  TOP w0.122: T212.1 55.86,75.54 v2(55.84,75.56)
  GND1 w0.104: v2(55.84,75.56) v3(56.27,75.56)
  IN1 w0.071: v4(56.17,75.02) 56.27,75.12 v3(56.27,75.56)
  IN4 w0.071: v4(56.17,75.02) 55.86,74.71 v5(55.86,74.64)
  GND5 w0.104: v6(55.86,75.1) v5(55.86,74.64)
  BOTTOM w0.122: v6(55.86,75.1) 55.86,75.15 UCPU1.K53
CFG12: length 3.7
  TOP w0.122: v6(55.84,77.51) 55.55,77.51 T235.1
  GND1 w0.104: v6(55.84,77.51) 55.71,77.64 v5(55.71,77.94)
  IN1 w0.071: v4(55.91,78.6) 55.91,78.45 55.71,78.24 v5(55.71,77.94)
  IN4 w0.071: v5(55.71,77.94) 55.71,78.24 55.91,78.45 v4(55.91,78.6)
  GND5 w0.104: v6(55.84,77.51) 55.71,77.64 v5(55.71,77.94)
  BOTTOM w0.122: UCPU1.F53 v6(55.84,77.51)
CFG13: length 3.6
  TOP w0.122: T236.1 56.22,76.34 v2(55.7,76.86)
  GND1 w0.104: v2(55.7,76.86) 56.08,76.86 v3(56.19,76.97)
  IN1 w0.071: v3(56.19,76.97) 56.17,76.97 v4(55.79,77.36)
  IN4 w0.071: v5(56.17,76.9) 55.79,77.28 v4(55.79,77.36)
  GND5 w0.104: v6(55.71,76.86) 56.13,76.86 v5(56.17,76.9)
  BOTTOM w0.122: UCPU1.G53 v6(55.71,76.86)
CFG14: length 2.8
  TOP w0.122: T237.1 v2(57.67,75.03)
  GND1 w0.104: v2(57.67,75.03) v3(57.23,75.03)
  IN1 w0.071: v4(57.77,74.99) 57.28,74.99 v3(57.23,75.03)
  IN4 w0.071: v5(57.28,74.99) v4(57.77,74.99)
  GND5 w0.104: v6(57.72,74.99) v5(57.28,74.99)
  BOTTOM w0.122: UCPU1.L51 v6(57.72,74.99)
CFG15: length 3.6
  TOP w0.122: v2(56.65,77.86) 56.92,77.59 T238.1
  GND1 w0.104: v2(56.65,77.86) 56.47,78.04 56.17,78.04 v3(56.14,78.07)
  IN1 w0.071: v4(56.62,77.89) 56.45,78.07 v3(56.14,78.07)
  IN4 w0.071: v5(57.31,77.59) 57.28,77.59 57.14,77.74 56.78,77.74 v4(56.62,77.89)
  GND5 w0.104: v5(57.31,77.59) v6(56.83,77.59)
  BOTTOM w0.122: T238.1 v6(56.83,77.59)
CFG16: length 3.7
  TOP w0.122: v6(57.08,77.98) 57.08,77.98 T214.1
  GND1 w0.104: v6(57.08,77.98) v5(57.08,78.63)
  IN1 w0.071: v4(57.82,78.52) 57.72,78.63 v5(57.08,78.63)
  IN4 w0.071: v4(57.82,78.52) 57.72,78.63 v5(57.08,78.63)
  GND5 w0.104: v6(57.08,77.98) v5(57.08,78.63)
  BOTTOM w0.122: v6(57.08,77.98) 57.08,77.99 T214.1
CFG17: length 3.6
  TOP w0.122: v2(56.72,74.91) 56.72,73.87 T215.1
  GND1 w0.104: v2(56.72,74.91) v3(56.72,75.35)
  IN1 w0.071: v4(56.75,74.86) 56.72,74.89 v3(56.72,75.35)
  IN4 w0.071: v4(56.75,74.86) 56.73,74.84 v5(56.73,74.36)
  GND5 w0.104: v6(56.73,74.91) v5(56.73,74.36)
  BOTTOM w0.122: UCPU1.L53 v6(56.73,74.91)
CLK_BCLK_ITP: length 5.4
  TOP w0.122: T240.1 101.66,58.64 101.82,58.8 101.82,59.41 v2(102.06,59.65)
  GND1 w0.104: v3(102.06,59.25) v2(102.06,59.65)
  IN1 w0.071: v3(102.06,59.25) v4(102.57,59.25)
  IN4 w0.071: v5(102.55,60.62) 102.55,60.52 102.57,60.49 v4(102.57,59.25)
  GND5 w0.104: v5(102.55,60.62) 102.57,60.59 v6(102.57,60.16)
  BOTTOM w0.122: UH1.AR10 v6(102.57,60.16)
CLK_BCLK_ITP#: length 4
  TOP w0.122: T239.1 102.57,59.14 v2(102.57,60.16)
  GND1 w0.104: v2(102.57,60.16) 102.57,60.54 102.52,60.59 v3(102.55,60.59)
  IN1 w0.071: v4(102.29,61.15) 102.32,61.13 102.32,61.05 102.55,60.82 v3(102.55,60.59)
  IN4 w0.071: v4(102.29,61.15) v5(102.65,61.51)
  GND5 w0.104: v5(102.65,61.51) 102.65,61.1 v6(102.57,61.02)
  BOTTOM w0.122: UH1.AR12 v6(102.57,61.02)
CLK_CPU_DMI: length 27.7
  IN1 w0.071: v4(81.41,76.57) 81.41,76.6 81.54,76.72 81.54,77.07 81.71,77.24 83.43,77.24 85.8,74.87 86.1,74.87 87.88,73.1 90.39,73.1 92.39,71.11 92.39,71.01 92.98,70.42 94.29,70.42 95.07,69.64 95.07,68.75 95.28,68.54 96.13,67.69 97.25,67.69 98.52,66.42 99.15,66.42 v4(99.22,66.48)
  IN4 w0.071: v5(100.6,65.49) 100.52,65.49 99.64,66.38 99.33,66.38 v4(99.22,66.48) ; v4(81.41,76.57) 81.6,76.38 81.6,76.07 v5(81.54,76.01)
  GND5 w0.089: v5(81.54,76.01) 81.54,76.16 v6(81.29,76.42) ; v5(100.6,65.49) v6(100.6,65.9)
  BOTTOM w0.104: UH1.AY24 v6(100.6,65.9) ; UCPU1.J3 81.29,76.06 v6(81.29,76.42)
CLK_CPU_DMI#: length 27.5
  IN1 w0.071: v4(81.97,76.57) 81.87,76.57 81.79,76.65 81.79,76.72 81.73,76.78 81.73,76.91 81.81,76.99 83.33,76.99 85.69,74.63 86,74.63 87.78,72.85 90.29,72.85 92.14,71 92.14,70.9 92.87,70.17 94.19,70.17 94.83,69.53 94.83,68.64 95.1,68.36 96.03,67.44 97.15,67.44 98.42,66.17 99.01,66.17 99.06,66.11 99.11,66.11 99.22,66 v4(99.22,65.9)
  IN4 w0.071: v4(99.22,65.9) 99.22,66 99.35,66.13 99.54,66.13 100.11,65.56 100.11,65.47 100.03,65.39 99.84,65.39 v5(99.74,65.49) ; v4(81.97,76.57) 81.85,76.45 81.85,76.1 v5(81.95,76.01)
  GND5 w0.089: v5(81.95,76.01) 81.95,76.19 v6(82.18,76.42) ; v6(99.74,65.9) v5(99.74,65.49)
  BOTTOM w0.104: UCPU1.H2 82.06,76.53 v6(82.18,76.42) ; UH1.BB24 v6(99.74,65.9)
CLK_CPU_DPLL: length 28.2
  IN2 w0.089: v4(103.03,60.57) 102.92,60.45 102.33,60.45 102.02,60.76 100.21,60.76 100.21,60.76 99.69,60.76 99.4,61.05 99.4,61.33 99.01,61.72 98.43,61.72 98.3,61.84 95.54,61.84 95.15,62.22 93.35,62.22 90.67,64.9 84.93,64.9 83.15,66.68 83.15,67.21 82.86,67.5 82.23,67.5 81.97,67.25 81.97,66.94 v4(81.82,66.79)
  IN4 w0.071: v4(81.82,66.79) 81.54,67.07 v5(81.54,67.22) ; v5(103.54,60.64) 103.38,60.49 103.11,60.49 v4(103.03,60.57)
  GND5 w0.089: v6(81.54,67.65) v5(81.54,67.22) ; v6(103.54,61.1) v5(103.54,60.64)
  BOTTOM w0.104: v6(81.54,67.65) 81.54,67.37 UCPU1.AG3 ; UH1.AN12 v6(103.54,61.1)
CLK_CPU_DPLL#: length 28.1
  IN2 w0.089: v4(82.46,66.79) 82.28,66.79 82.23,66.84 82.23,66.95 82.19,66.99 82.19,67.16 82.32,67.28 82.77,67.28 82.94,67.12 82.94,66.59 84.84,64.68 90.58,64.68 93.26,62.01 95.06,62.01 95.45,61.62 98.21,61.62 98.34,61.5 98.92,61.5 99.18,61.24 99.18,60.96 99.6,60.55 100.12,60.55 100.12,60.54 101.93,60.54 102.24,60.24 102.85,60.24 103.03,60.06 v4(103.03,59.96)
  IN4 w0.071: v4(103.03,59.96) 103.31,59.96 v5(103.54,59.73) ; v5(82.15,67.22) 82.15,67.09 v4(82.46,66.79)
  GND5 w0.089: v5(82.15,67.22) 82.1,67.26 v6(82.1,67.65) ; v6(103.54,60.18) v5(103.54,59.73)
  BOTTOM w0.104: v6(103.54,60.18) 103.54,60.18 UH1.AN10 ; UCPU1.AG1 82.02,67.29 82.02,67.57 v6(82.1,67.65)
CLK_LPC_DEBUG: length 123.7
  IN1 w0.071: v7(160,46.42) 158.51,44.93 155.69,44.93 154.9,44.14 152.22,44.14 151.12,45.24 148.42,45.24 146.85,46.8 146.03,46.8 145.47,47.36 v4(145.47,48.07)
  IN2 w0.094: v7(160,46.42) 160,46.62 160.52,47.14 166.45,47.14 167.18,46.42 171.63,46.42 176.26,41.8 v7(176.26,35.17) ; v7(119.51,77.15) 118.55,77.15 118.14,76.75 111.88,76.75 111.18,76.05 111.18,75.74 110.65,75.21 110.65,74.43 109.18,72.96 109.18,72 108.82,71.64 108.82,70.83 108.67,70.68 108.67,68.97 108.74,68.9 108.74,68.17 108.15,67.58 107.83,67.58 107.37,67.12 107.37,66.32 107.47,66.22 107.47,64.47 107.91,64.03 107.91,63.16 106.66,61.91 106.66,60.64 106,59.98 106,58.76 106.31,58.46 106.31,57.06 106.53,56.83 106.53,56.31 107.32,55.52 107.32,55.39 108.25,54.46 121.09,54.46 121.29,54.66 129.58,54.66 129.64,54.6 130.62,54.6 131.01,55 134.58,55 135.49,54.09 136.45,54.09 137.18,53.37 142.27,53.37 143.14,52.5 143.14,50.42 145.47,48.08 v4(145.47,48.07)
  BOTTOM w0.122: JWLAN1.19 179.09,34.95 178.72,34.58 v1(177.27,34.58) 176.84,34.58 v7(176.26,35.17) ; RH305.1 119.72,76.95 v7(119.51,77.15)
CLK_PCH_14M: length 11.7
  TOP w0.122: v2(114.6,75.68) 114.6,75.21 114.76,75.04 115.27,75.04 v1(115.42,75.2) 116,75.77 117.63,75.77 118.51,76.64 119.68,76.64 120.39,77.36 120.39,78.16 RH84.1 121.43,78.35 RH86.2
  GND1 w0.104: v2(114.6,75.68) 114.54,75.62 v3(114.18,75.62)
  IN1 w0.071: v4(114.18,76.11) v3(114.18,75.62)
  IN4 w0.071: v5(113.75,76.43) 113.92,76.43 114.18,76.17 v4(114.18,76.11)
  GND5 w0.104: v6(113.34,76.33) 113.66,76.33 v5(113.75,76.43)
  BOTTOM w0.122: UH1.J49 v6(113.34,76.33)
CLK_PCI0: length 12
  IN2 w0.094: v7(119.92,77.72) 118.74,78.9 118.74,79.4 118.63,79.51 118.16,79.51 118.02,79.37 118.02,77.74 117.8,77.52 114.02,77.52 v7(114,77.53)
  BOTTOM w0.122: v7(119.92,77.72) 120.27,78.07 120.53,78.07 CH107.1 120.83,78.37 121.25,78.37 121.75,77.87 RH164.1 ; v7(114,77.53) 114.15,77.38 UH1.G51
CLK_PCI1: length 8.8
  TOP w0.122: v2(117.77,77.38) 117.69,77.47 117.69,78.19 CH99.1 118.24,78.74 RH165.2 118.24,80.37 v1(118.45,80.58)
  GND1 w0.104: v3(117.69,76.44) 117.77,76.53 v2(117.77,77.38)
  IN1 w0.071: v3(117.69,76.44) 117.66,76.42 115.78,76.42 115.48,76.11 v4(115.25,76.11)
  IN4 w0.071: v4(115.25,76.11) 114.92,76.11 v5(114.61,76.42)
  GND5 w0.104: v6(114.56,75.9) 114.56,76.36 v5(114.61,76.42)
  BOTTOM w0.122: UH1.E49 v6(114.56,75.9)
CLK_PCI2: length 11.8
  TOP w0.122: v7(121.16,77.61) v1(121.16,77.06)
  IN1 w0.071: v4(113.16,75.53) 113.37,75.32 115.68,75.32 116.15,75.79 119.35,75.79 120.86,77.31 120.86,77.32 v7(121.16,77.61)
  IN4 w0.071: v4(113.16,75.53) 113.16,75.21 v5(112.99,75.03)
  GND5 w0.104: v6(113.37,75.24) 113.36,75.24 113.15,75.03 v5(112.99,75.03)
  BOTTOM w0.122: v7(121.16,77.61) 121.12,77.57 121.12,76.96 RH305.2 ; v6(113.37,75.24) 113.59,75.47 UH1.H48
CLK_PCI3: length 3.4
  TOP w0.122: T166.1 113.57,72.58 v2(113.65,72.66)
  GND1 w0.104: v3(114.05,72.66) v2(113.65,72.66)
  IN1 w0.071: v4(114.28,72.17) 114.28,72.43 v3(114.05,72.66)
  IN4 w0.071: v5(113.59,72.86) 113.6,72.86 v4(114.28,72.17)
  GND5 w0.104: v5(113.59,72.86) v6(113.59,73.29)
  BOTTOM w0.122: UH1.J43 113.72,73.42 v6(113.59,73.29)
CLK_PCI4: length 3.8
  TOP w0.122: v2(114.13,73.83) 114.13,74.14 T204.1
  GND1 w0.104: v2(114.13,73.83) 114.31,73.65 v3(114.71,73.65)
  IN1 w0.071: v4(114.23,73.62) 114.26,73.65 v3(114.71,73.65)
  IN4 w0.071: v4(114.23,73.62) 114.69,73.16 114.83,73.16 v5(114.83,73.16)
  GND5 w0.104: v5(114.83,73.16) v6(114.83,73.72)
  BOTTOM w0.122: v6(114.83,73.72) 114.82,73.72 114.82,73.75 114.29,74.27 T204.1
CLK_PCI_LPBACK: length 38.5
  BOTTOM w0.122: RH164.2 121.85,78.51 121.99,78.37 122.66,78.37 122.72,78.43 RH89.2 122.72,79.2 122.64,79.28 122.64,79.57 122.23,79.97 121.95,79.97 121.37,79.39 121,79.39 120.8,79.59 119.3,79.59 119.18,79.7 119.18,80.43 119.06,80.56 118.8,80.56 118.68,80.43 118.68,79.7 118.58,79.6 118.27,79.6 118.17,79.7 118.17,80.07 118.04,80.2 117.79,80.2 117.66,80.07 v1(117.66,79.72) 117.66,79.21 117.79,79.08 119.18,79.08 119.31,78.96 119.31,78.7 119.18,78.57 117.79,78.57 117.66,78.45 117.66,78.19 117.79,78.07 119.16,78.07 119.26,77.97 119.26,77.84 118.88,77.46 118.88,76.82 118.8,76.75 118.54,76.75 118.07,76.28 117.98,76.28 117.8,76.45 117.8,76.67 118.37,77.24 118.37,77.43 118.24,77.56 117.94,77.56 117.81,77.43 117.38,77.43 117.33,77.48 117.33,77.71 117.14,77.9 115.89,77.9 115.82,77.98 115.82,78.35 115.88,78.41 116.25,78.41 116.4,78.56 116.4,78.7 115.79,79.31 112.59,79.31 111.5,78.22 110.76,78.22 110.6,78.05 110.6,77.57 110.79,77.38 111.42,77.38 112.71,78.66 114.65,78.66 114.97,78.35 UH1.E51
CLK_PCI_LPC: length 52.9
  TOP w0.122: v2(137.82,60.45) 137.8,60.45 ; 137.8,60.45 R226.1 ; 137.8,60.45 137.82,60.43 138.14,60.43 138.54,60.03 139.35,60.03 U34.N5 ; v7(123.27,80.99) 123.18,81.08 120.84,81.08 v1(120.19,80.43) 119.35,79.59 RH165.1
  GND1 w0.104: v3(137.4,60.36) 137.74,60.36 v2(137.82,60.45)
  IN1 w0.071: v3(137.4,60.36) 137.19,60.36 136.7,60.85 135.06,60.85 134.82,60.61 134.19,60.61 132.65,59.07 v4(132.5,59.07)
  IN4 w0.071: v5(132.24,59.67) 132.5,59.4 v4(132.5,59.07) ; v5(139.2,74.66) 138.9,74.66 137.81,73.57 134.29,73.57 132.93,74.93 132.93,76.2 130.91,78.23 128.65,78.23 127.62,79.26 127.62,79.69 127.06,80.25 124.82,80.25 124.09,80.99 v7(123.27,80.99)
  GND5 w0.104: v6(139.2,74.21) v5(139.2,74.66) ; v6(132.67,59.67) v5(132.24,59.67)
  BOTTOM w0.122: v6(139.2,74.21) 139.2,71.83 136.98,69.61 136.98,69.06 135.91,68 135.62,68 133.5,65.87 133.5,60.49 v6(132.67,59.67)
CLK_PCI_TPM: length 81.6
  TOP w0.122: v7(165.81,70.64) 165.81,69.71 v1(166.07,69.44) 166.07,68.51 165.86,68.29 165.86,65.98 166.05,65.79 166.05,60.05 165.12,59.12 165.12,58.73 163.93,57.53 162.37,57.53 161.46,58.45 159,58.45 158.82,58.62 157.16,58.62 156.47,57.94 156.47,56.34 156.43,56.3 156.43,55.28 156.66,55.06 157.37,55.06 R976.1 158.02,55.47 158.02,54.24 158.4,53.86 158.93,53.86 159.1,54.02 U652.21 ; RH296.2 v2(123.88,77.94)
  GND1 w0.104: v2(123.88,77.94) v3(123.88,78.37)
  IN1 w0.071: v3(123.88,78.37) 124.13,78.63 v4(124.77,78.63)
  IN4 w0.071: v7(165.81,70.64) 165.81,70.95 166.68,71.83 166.68,72.22 163.81,75.09 148.62,75.09 147.36,73.84 139.96,73.84 139.64,73.52 138.6,73.52 137.99,72.91 136.45,72.91 136.23,72.68 135.06,72.68 134.93,72.81 134.21,72.81 132.34,74.68 132.34,75.96 130.66,77.64 127.92,77.64 127.01,78.55 125.64,78.55 125.56,78.63 v4(124.77,78.63)
CLK_PCIE_MINI1: length 141.8
  IN4 w0.071: v5(109.07,76.29) 108.95,76.16 108.95,75.86 108.31,75.23 105.23,75.23 105.21,75.21 101.47,75.21 100.54,74.28 100.54,72.81 99.87,72.14 98.24,72.14 97.43,71.32 94.91,71.32 93.62,70.03 92.2,70.03 91.65,69.48 91.65,67.41 92.92,66.14 92.92,64.49 92.4,63.97 92.4,60.87 93.95,59.32 93.95,58.51 95.64,56.81 95.64,56.23 98.21,53.67 102.38,53.67 104,52.05 105.73,52.05 105.87,51.9 118.85,51.9 119.02,51.74 122.22,51.74 122.36,51.88 126.67,51.88 127.15,52.36 129.74,52.36 129.93,52.17 131.76,52.17 133.42,50.51 136.11,50.51 136.29,50.33 145.82,50.33 148.08,48.07 157.89,48.07 158.26,48.44 168.04,48.44 169.48,47 171.33,47 174.24,44.09 174.24,39.95 175.01,39.18 175.01,33.41 175.88,32.55 175.88,30.31 177.17,29.02 177.55,29.02 177.63,29.1 177.63,29.3 v7(177.58,29.35)
  GND5 w0.089: v6(108.87,76.76) 108.87,76.49 v5(109.07,76.29)
  BOTTOM w0.104: v7(177.58,29.35) 177.58,29.3 177.79,29.08 v7(178.24,29.08) 178.86,29.08 179.13,29.35 JWLAN1.13 ; v6(108.87,76.76) UH1.AA51
CLK_PCIE_MINI1#: length 141.8
  IN4 w0.071: v5(108.59,76.29) 108.7,76.18 108.7,75.96 108.21,75.48 105.13,75.48 105.11,75.46 101.36,75.46 100.29,74.39 100.29,72.91 99.76,72.38 98.14,72.38 97.33,71.57 94.81,71.57 93.52,70.28 92.09,70.28 91.4,69.58 91.4,67.31 92.67,66.04 92.67,64.59 92.15,64.07 92.15,60.77 93.7,59.22 93.7,58.41 95.39,56.71 95.39,56.13 98.1,53.42 102.28,53.42 103.9,51.8 105.62,51.8 105.77,51.66 118.75,51.66 118.92,51.49 122.32,51.49 122.46,51.63 126.77,51.63 127.25,52.11 129.63,52.11 129.82,51.92 131.65,51.92 133.32,50.26 136.01,50.26 136.18,50.08 145.71,50.08 147.97,47.82 158,47.82 158.36,48.19 167.94,48.19 169.37,46.75 171.23,46.75 173.99,43.99 173.99,39.85 174.76,39.08 174.76,33.31 175.63,32.44 175.63,30.21 177.07,28.77 177.4,28.77 v8(177.58,28.59)
  GND5 w0.089: v6(108.87,75.9) 108.87,76.01 v5(108.59,76.29)
  BOTTOM w0.104: v8(177.58,28.59) 177.81,28.82 178.85,28.82 179.11,28.55 JWLAN1.11 ; v6(108.87,75.9) UH1.AA49
CLK_RES_ITP: length 3.9
  TOP w0.122: T233.1 52.79,74.94 v2(52.97,74.76)
  GND1 w0.104: v3(53.42,74.76) v2(52.97,74.76)
  IN1 w0.071: v4(53.65,73.55) 53.42,73.77 v3(53.42,74.76)
  IN4 w0.071: v5(53.27,73.24) 53.58,73.55 v4(53.65,73.55)
  GND5 w0.104: v5(53.27,73.24) 52.99,73.52 v6(52.99,73.57)
  BOTTOM w0.122: v6(52.99,73.57) 53.12,73.57 UCPU1.N59
CLK_RES_ITP#: length 3
  TOP w0.122: v2(53.83,74.18) 54.12,73.89 T234.1
  GND1 w0.104: v2(53.83,74.18) 54.13,73.88 v3(54.13,73.85)
  IN1 w0.071: v3(54.13,73.85) 54.13,73.72 v4(54.44,73.42)
  IN4 w0.071: v4(54.44,73.42) 54.44,73.47 54.11,73.8 v5(54.11,73.88)
  GND5 w0.104: v6(54.44,73.55) v5(54.11,73.88)
  BOTTOM w0.122: v6(54.44,73.55) 54.13,73.85 T234.1
CLK_SMB: length 9
  TOP w0.122: v1(124.87,25.3) 125.01,25.3 125.18,25.13 v7(125.41,25.13) 125.41,24.68 PR913.1 124.57,23.84 PD904.2
  BOTTOM w0.122: v7(125.41,25.13) 125.87,24.67 JBATT9.7
CLKFLEX0: length 12.7
  TOP w0.122: v2(122.19,78.49) 122.39,78.29 RH296.1
  GND1 w0.104: v3(121.8,78.7) 121.98,78.7 v2(122.19,78.49)
  IN1 w0.071: v3(121.8,78.7) 121.39,78.3 118.8,78.3 117.61,77.1 113.82,77.1 113.57,77.36 v7(113.57,78.07)
  BOTTOM w0.122: v7(113.57,78.07) 113.49,77.99 113.49,77.28 113.75,77.03 UH1.H50
CLKIN_DMI: length 5.9
  TOP w0.122: v2(97.77,62.8) 96.76,63.82 v1(96.43,63.82) 95.88,63.82 RH79.1
  GND1 w0.104: v3(98.13,62.57) 97.87,62.83 97.8,62.83 v2(97.77,62.8)
  IN1 w0.071: v3(98.13,62.57) 98.13,63.12 98.13,63.13 v4(98.13,63.12)
  IN4 w0.071: v4(98.13,63.12) 98.13,62.74 v5(98.01,62.61)
  GND5 w0.104: v6(98.01,63.07) v5(98.01,62.61)
  BOTTOM w0.122: UH1.BF17 v6(98.01,63.07)
CLKIN_DMI2: length 5.1
  TOP w0.122: v2(100.61,67.44) RH78.1 100.14,66.42 99.74,66.42 v1(99.28,65.96)
  GND1 w0.104: v2(100.61,67.44) 100.51,67.34 v3(100.51,66.97)
  IN1 w0.071: v3(100.51,66.97) 100.51,66.03 v4(100.57,65.98)
  IN4 w0.071: v4(100.57,65.98) 100.57,66.43 v5(100.59,66.46)
  GND5 w0.104: v5(100.59,66.46) 100.6,66.47 v6(100.6,66.87)
  BOTTOM w0.122: UH1.AY26 v6(100.6,66.87)
CLKIN_DMI2#: length 7.5
  TOP w0.122: RH76.1 96.12,64.99 v1(97.23,66.1) 98.66,67.53 v2(99.09,67.53)
  GND1 w0.104: v3(99.09,67.12) v2(99.09,67.53)
  IN1 w0.071: v3(99.09,67.12) 98.76,66.79 v4(98.74,66.79)
  IN4 w0.071: v4(98.74,66.79) 98.91,66.97 v5(99.32,66.97)
  GND5 w0.104: v6(99.32,66.45) v5(99.32,66.97)
  BOTTOM w0.122: UH1.BB26 v6(99.32,66.45)
CLKIN_DMI#: length 5.7
  TOP w0.122: RH77.1 v1(96.76,62.08) 98.09,62.08 v2(98.18,62.17)
  GND1 w0.104: v3(98.53,62.57) 98.51,62.57 98.53,62.55 98.53,62.53 v2(98.18,62.17)
  IN1 w0.071: v4(98.69,62.1) 98.69,62.09 98.53,62.25 v3(98.53,62.57)
  IN4 w0.071: v4(98.69,62.1) 98.87,62.28 v5(98.87,62.57)
  GND5 w0.104: v6(98.87,63.06) v5(98.87,62.57)
  BOTTOM w0.122: UH1.BD17 v6(98.87,63.06)
CLKIN_DOT96: length 5.1
  TOP w0.122: RH81.1 114.48,65.97 v2(114.48,66.54) 115.34,66.54 v1(115.54,66.74)
  GND1 w0.104: v3(114.48,66.11) v2(114.48,66.54)
  IN1 w0.071: v4(113.52,65.01) 113.52,65.19 113.93,65.6 114.1,65.6 114.48,65.97 v3(114.48,66.11)
  IN4 w0.071: v5(113.13,65.36) 113.18,65.36 v4(113.52,65.01)
  GND5 w0.104: v5(113.13,65.36) 113.41,65.36 v6(113.53,65.48)
  BOTTOM w0.122: UH1.K24 v6(113.53,65.48)
CLKIN_DOT96#: length 4.5
  TOP w0.122: v1(113.93,64.13) 113.93,64.73 113.64,65.02 RH80.1 112.85,65.02 v2(112.73,65.14)
  GND1 w0.104: v3(112.63,64.73) 112.73,64.83 v2(112.73,65.14)
  IN1 w0.071: v3(112.63,64.73) 112.3,65.06 v4(112.26,65.06)
  IN4 w0.071: v5(112.85,65.06) 112.84,65.06 v4(112.26,65.06)
  GND5 w0.104: v5(112.85,65.06) 112.27,65.06 v6(112.26,65.05)
  BOTTOM w0.122: UH1.M24 v6(112.26,65.05)
CLKIN_SATA: length 3.1
  TOP w0.122: RH83.1 104.81,57.9 v2(105.07,58.17)
  GND1 w0.104: v2(105.07,58.17) 105.18,58.17 v3(105.44,57.9)
  IN1 w0.071: v4(104.97,57.77) 105.31,57.77 v3(105.44,57.9)
  IN4 w0.071: v4(104.97,57.77) 104.72,58.03 v5(104.5,58.03)
  GND5 w0.104: v6(104.5,58.43) v5(104.5,58.03)
  BOTTOM w0.122: v5(104.5,58.03) v6(104.5,58.43)
CLKIN_SATA#: length 6.4
  TOP w0.122: v2(103.92,58.28) 103.95,58.28 RH82.1 104.15,58.86 v1(103.25,59.77)
  GND1 w0.104: v3(104.2,57.72) 103.92,58 v2(103.92,58.28)
  IN1 w0.071: v3(104.2,57.72) 104.2,57.7 v4(104.55,57.34)
  IN4 w0.071: v5(104.43,58.89) 104.2,58.66 104.2,57.7 v4(104.55,57.34)
  GND5 w0.104: v6(104.91,58.89) v5(104.43,58.89)
  BOTTOM w0.122: UH1.AK8 v6(104.91,58.89)
COMP: length 7.8
  TOP w0.122: v1(27.69,75.54) 27.5,75.73 27.5,77.43 26.59,78.35
  TOP w0.254: PR734.1 27.06,78.35 27.31,78.6 v7(27.31,79.18)
  BOTTOM w0.254: PU700.18 26.77,79.54 27.13,79.18 v7(27.31,79.18) 27.36,79.13 PC729.1 28.71,79.13 PC730.1
CPU1.5V_S3_GATE: length 223
  TOP w0.076: v2(142.23,61.25) 142.69,61.25 142.87,61.07 142.87,60.65 U34.F4
  TOP w0.254: RC11.1 136.49,46.61 135.26,47.84 135.26,50.2 135.52,50.46 135.52,51.22 134.28,52.45 v7(134.28,52.73) ; v7(74.15,49.67) 73.79,49.31 63.57,49.31 62.57,50.31 56.67,50.31 56.02,49.66 55.39,49.66 54.56,50.48 v7(53.42,50.48) 53.42,52.39 51.44,54.37 v9(50.25,54.37) 48.11,54.37 44.77,51.03 v7(34.01,51.03)
  GND1 w0.104: v3(141.9,61.67) 142.23,61.34 v2(142.23,61.25)
  IN1 w0.071: v7(134.28,52.73) 134.58,52.44 135.94,52.44 137.93,54.42 137.93,56.3 137.43,56.79 137.43,58.31 138.54,59.41 138.54,59.97 138.91,60.34 140.24,60.34 140.44,60.54 140.44,61.07 140.82,61.45 141.68,61.45 v3(141.9,61.67)
  IN2 w0.254: v7(10.09,21.93) 12.49,24.33 12.49,28.63 13.93,30.07 13.93,30.43 14.21,30.71 14.21,35.03 13.74,35.5 13.74,40.75 14.32,41.33 14.32,42.02 15.02,42.71 15.02,43.77 15.27,44.02 15.27,44.5 15.71,44.95 15.71,45.97 18.05,48.31 25.8,48.31 26.35,47.76 30.74,47.76 v7(34.01,51.03) ; v7(82.66,41.52) 83.52,42.38 83.52,42.71 93.58,52.77 94.25,52.77 97.61,56.12 102.67,56.12 104.59,54.2 105.97,54.2 106.26,53.91 106.26,53.06 106.75,52.57 119.03,52.57 119.22,52.38 122.18,52.38 122.67,52.86 128.53,52.86 128.62,52.78 132.1,52.78 132.3,52.97 134.04,52.97 v7(134.28,52.73)
  BOTTOM w0.254: v7(53.42,50.48) 53.32,50.58 53.32,52.46 53.86,53 QC6.2 ; PR323.1 26.85,24.04 25.84,23.03 25.84,21.15 25.61,20.92 24.04,20.92 23.4,20.28 23.4,18.9 22.96,18.45 14,18.45 12.8,19.66 12.29,19.66 10.09,21.86 v7(10.09,21.93) ; v7(82.66,41.52) 82.61,41.47 81.52,41.47 79.51,43.47 76.59,43.47 74.84,45.22 74.84,47.16 75.79,48.11 RC107.1 74.24,49.67 v7(74.15,49.67)
CPU_EDP_HPD#: length 15.8
  TOP w0.122: v7(76.99,66.84) 76.99,67.03 RC137.1 78.35,67.02 81.15,67.02 83.23,64.94 v1(84.88,64.94) 86.75,64.94 87.18,65.37 QC5.1
  BOTTOM w0.122: UCPU1.AG11 77.23,67.33 76.99,67.09 v7(76.99,66.84)
CPU_RSVD6: length 3.1
  TOP w0.122: RC143.1 v2(59.52,76.19)
  GND1 w0.104: v2(59.52,76.19) 59.52,76.59 v3(59.47,76.64)
  IN1 w0.071: v4(59.37,77.25) 59.47,77.15 v3(59.47,76.64)
  IN4 w0.071: v5(59.27,76.77) 59.27,77.15 v4(59.37,77.25)
  GND5 w0.104: v5(59.27,76.77) v6(59.27,76.28)
  BOTTOM w0.122: UCPU1.H48 v6(59.27,76.28)
CPU_RSVD7: length 5.1
  TOP w0.122: v1(59.52,73.18) v2(59.52,75.24) RC144.1
  GND1 w0.104: v2(59.52,75.24) v3(59.09,75.24)
  IN1 w0.071: v4(59.27,74.79) 59.09,74.97 v3(59.09,75.24)
  IN4 w0.071: v4(59.27,74.79) 59.6,75.12 v5(59.6,75.15)
  GND5 w0.104: v5(59.6,75.15) 59.27,75.48 v6(59.27,75.63)
  BOTTOM w0.122: UCPU1.K48 v6(59.27,75.63)
CRT_IREF: length 4.3
  TOP w0.122: RH140.1 111.61,76.67 v2(111.42,76.48)
  TOP w0.127: RH140.1 v1(112.36,75.74)
  GND1 w0.104: v3(111.17,76.15) 111.17,76.24 v2(111.42,76.48)
  IN1 w0.071: v3(111.17,76.15) 111.49,76.15 v4(111.66,75.98)
  IN4 w0.071: v4(111.66,75.98) 111.62,76.02 111.62,76.08 111.36,76.34 v5(111.31,76.34)
  GND5 w0.104: v6(111.31,76.76) v5(111.31,76.34)
  BOTTOM w0.122: UH1.R51 v6(111.31,76.76)
CS_1.35V: length 3.1
  TOP w0.254: PU300.13 31.37,19.64 v7(31.22,19.49) 31.22,19.26 v1(30.85,18.88) 29.85,18.88 PR301.2
CSIN: length 6.2
  TOP w0.122: PC21.2 146.06,37 v9(145.55,36.49)
  TOP w0.254: PR15.2 143.63,39.07 PC20.2 145.23,39.07 v7(145.35,38.95) 145.5,38.8 145.5,38.6 146.02,38.07 PC21.2
  BOTTOM w0.254: v7(145.35,38.95) 145.35,38.77 145.81,38.31 PU2.27
CSIP: length 6
  TOP w0.122: PR14.2 143.63,39.99 142.93,40.69 v1(142.93,40.96)
  TOP w0.254: PR14.2 143.64,39.98 PC20.1 144.85,39.98 v7(145.24,39.59) 145.75,39.59 146.03,39.31 PC19.1
  BOTTOM w0.254: v7(145.24,39.59) 145.45,39.59 145.85,39.18 145.85,38.82 145.97,38.71 PU2.28
CSON: length 3.3
  TOP w0.254: PR30.1 PC31.2 149.46,33.77 149.13,34.1 v7(149.13,34.12)
  BOTTOM w0.254: v7(149.13,34.12) 149,34.25 149,34.63 148.72,34.91 PU2.17
CSON_B: length 34.2
  TOP w0.254: v7(149.33,30.95) 149.33,31.53 PR30.2 ; PR25.2 127.79,35.12 128.02,34.89 128.02,33.49 v7(127.87,33.34) 127.73,33.2 PR962.2
  IN1 w0.254: v7(127.87,33.34) 128,33.21 128,30.11 132.16,25.95 133.89,25.95 134.58,25.26 138.18,25.26 139.82,26.9 143.85,26.9 146.93,29.98 148.64,29.98 149.33,30.68 v7(149.33,30.95)
  BOTTOM w0.122: v7(149.33,30.95) 149.33,30.51 v1(149.47,30.37)
CSOP: length 3.8
  TOP w0.122: v7(148.5,34.12) 148.5,34.57 v1(148.58,34.66)
  TOP w0.254: v7(148.5,34.12) 148.55,34.07 PC31.1 148.55,32.59 PR29.2
  BOTTOM w0.254: PU2.18 148.32,34.77 148.62,34.47 148.62,34.25 v7(148.5,34.12)
CSOP_B: length 32.8
  TOP w0.254: PR963.1 128.62,33.25 v7(128.53,33.34) 128.4,33.46 128.4,34.91 128.61,35.12 PR25.3 ; PR29.1 148.7,31.53 v7(148.7,30.95)
  IN1 w0.254: v7(148.7,30.95) 148.7,30.61 148.48,30.39 146.84,30.39 143.7,27.25 139.67,27.25 138.04,25.62 134.72,25.62 134.04,26.3 132.35,26.3 128.38,30.27 128.38,33.19 v7(128.53,33.34)
  BOTTOM w0.122: v7(148.7,30.95) 148.46,30.95 v1(148.1,30.59)
DAT_SMB: length 12.1
  TOP w0.122: PR917.1 PD904.3 126.5,21.81 127.08,22.39 v1(127.08,23.41) 127.08,24.47 v7(126.75,24.8)
  BOTTOM w0.122: JBATT9.6 124.37,24.78 125.18,25.59 125.97,25.59 v7(126.75,24.8)
DC_TEST_A59_C59: length 1
  BOTTOM w0.305: UCPU1.C59 UCPU1.A59 53.23,80.08
DC_TEST_A61_C61: length 1
  BOTTOM w0.305: 52.58,80.06 UCPU1.A61 UCPU1.C61
DC_TEST_BE61_BE59: length 1.2
  BOTTOM w0.305: 52.07,57.92 UCPU1.BE61 UCPU1.BE59
DC_TEST_BG1_BE1: length 1.1
  BOTTOM w0.305: 82,56.79 UCPU1.BG1 UCPU1.BE1
DC_TEST_BG3_BE3: length 1.1
  BOTTOM w0.305: 81.35,56.77 UCPU1.BG3 UCPU1.BE3
DC_TEST_C4_D3: length 0.7
  BOTTOM w0.305: UCPU1.D3 81.35,78.6 UCPU1.C4
DCIN: length 5.2
  TOP w0.122: PR24.2 145.83,42.54 v1(146.06,42.77)
  TOP w0.254: PC23.1 147.84,39.79 v7(147.25,40.37) 147.02,40.6 146.82,40.6 146.06,41.36 PR24.2
  BOTTOM w0.254: v7(147.25,40.37) 147.52,40.1 PU2.2
DCIN_GND:
  vias: v1(193.24,74.24)
DDR3_DRAMRST#: length 214.3
  TOP w0.102: 71.52,23.46 71.52,21.88 73.35,20.04 73.81,20.04 v10(74.24,20.48) ; 104.67,23.46 104.67,21.88 106.5,20.04 106.96,20.04 v10(107.39,20.48) ; v10(58.75,25.56) 58.32,25.12 57.86,25.12 56.03,26.96 56.03,28.54 ; v10(25.6,25.56) 25.17,25.12 24.71,25.12 22.88,26.96 22.88,28.54 ; 93.62,23.46 93.62,21.88 95.45,20.04 95.91,20.04 v10(96.34,20.48) ; 33.93,28.54 33.93,26.96 35.76,25.12 36.22,25.12 v10(36.65,25.56) ; 44.98,28.54 44.98,26.96 46.81,25.12 47.27,25.12 v10(47.7,25.56) ; v10(85.29,20.48) 84.86,20.04 84.4,20.04 82.57,21.88 82.57,23.46
  TOP w0.104: UD14.N2 33.93,28.54 33.93,28.54 ; 56.03,28.54 56.02,28.54 UD10.N2 ; UD6.N2 82.57,23.46 ; 71.52,23.46 71.52,23.46 UD8.N2 ; 93.62,23.46 93.62,23.46 UD4.N2 ; UD16.N2 22.88,28.54 ; UD2.N2 104.67,23.46 ; UD12.N2 44.98,28.54
  TOP w0.16: RC76.1 30.36,49.75 v7(30.61,49.49)
  IN3 w0.122: v10(107.39,20.48) 106.85,21.02 105.8,21.02 105.39,21.42 97.26,21.42 96.34,20.5 v10(96.34,20.48) 95.82,20.99 94.95,20.99 94.29,21.65 86.42,21.65 85.29,20.53 v10(85.29,20.48) 84.8,20.97 84.03,20.97 83.6,21.4 74.81,21.4 74.49,21.08 74.49,20.72 v10(74.24,20.48) 73.47,21.25 72.14,21.25 70.72,22.67 68.51,22.67 67.52,23.66 v4(64.7,23.66)
  IN4 w0.091: v7(30.61,49.49) 30.96,49.15 30.96,47.79 30.69,47.52 30.15,47.52 27.52,44.89 26.45,44.89 20.58,39.03 20.58,37.73 20.91,37.4 21.52,37.4 21.95,36.97 21.95,35.65 21.67,35.37 21.47,35.37 21.22,35.12 21.22,34.66 21.6,34.28 21.6,32.3 21.22,31.92 21.22,29.04 24.14,26.12 25.46,26.12 25.6,25.98 v10(25.6,25.56) 25.6,25.56 26.65,26.61 34.6,26.61 35.06,26.15 36.06,26.15 v10(36.65,25.56) 37.35,26.25 47,26.25 v10(47.7,25.56) 47.7,25.61 48.44,26.35 48.67,26.35 50.21,27.89 55.77,27.89 57.56,26.1 58.2,26.1 v10(58.75,25.56) 59.19,26 62.54,26 64.7,23.84 v4(64.7,23.66)
  BOTTOM w0.102: UD13.N2 39.29,28.32 39.29,26.62 38.64,25.97 37.07,25.97 v10(36.65,25.56) ; UD7.N2 76.88,23.24 76.88,21.54 76.24,20.89 74.66,20.89 v10(74.24,20.48) ; v10(85.29,20.48) 85.71,20.89 87.28,20.89 87.93,21.54 87.93,23.24 UD5.N2 ; v10(58.75,25.56) 59.17,25.97 60.74,25.97 61.39,26.62 61.39,28.32 UD9.N2 ; v10(107.39,20.48) 107.81,20.89 109.38,20.89 110.03,21.54 110.03,23.24 UD1.N2 ; UD3.N2 98.98,23.24 98.98,21.54 98.33,20.89 96.76,20.89 v10(96.34,20.48) ; UD11.N2 50.34,28.32 50.34,26.62 49.69,25.97 48.12,25.97 v10(47.7,25.56) ; v10(25.6,25.56) 26.02,25.97 27.59,25.97 28.24,26.62 28.24,28.32 UD15.N2
DDR3_DRAMRST#_R: length 28.4
  TOP w0.122: RC74.1 48.04,52.09 v1(48.04,53.38) ; RC74.1 47.81,50.55 34.06,50.55 33.75,50.24 RC76.2 ; RC74.1 48.98,51.43 RC75.2 49.42,49.89 49.42,49 v7(49.77,48.65)
  BOTTOM w0.122: v7(49.77,48.65) 49.77,48.81 50.32,49.36 50.48,49.36 51.11,50 QC2.1
DDR_A_BS0: length 168.7
  TOP w0.076: v10(73.86,27.63) 73.47,28.02 72.98,28.02 72.27,27.31 71.83,27.31 UD8.J2 ; v10(84.91,27.63) 84.52,28.02 84.03,28.02 83.32,27.31 82.88,27.31 UD6.J2 ; UD4.J2 93.93,27.31 94.37,27.31 95.08,28.02 95.57,28.02 v10(95.96,27.63) ; v10(107.01,27.63) 106.62,28.02 106.13,28.02 105.42,27.31 104.98,27.31 UD2.J2
  TOP w0.16: R1078.1 v2(114.99,30.8)
  GND1 w0.102: v2(114.99,30.8) v3(114.99,30.37)
  IN1 w0.127: v4(114.69,29.88) 114.69,29.91 114.99,30.21 v3(114.99,30.37)
  IN2 w0.122: v4(114.69,29.88) 114.05,29.25 112.73,29.25 112.11,28.63 108.75,28.63 108.17,28.04 107.42,28.04 v10(107.01,27.63) 106.56,28.08 105.52,28.08 105.36,28.25 105.36,29.37 105.23,29.49 104.8,29.49 104.67,29.37 104.67,28.68 104.54,28.55 102.99,28.55 102.87,28.68 102.87,29.21 102.33,29.75 101.07,29.75 99.95,28.63 98.03,28.63 97.9,28.75 97.25,28.75 97.13,28.63 97.13,28.2 96.97,28.04 96.37,28.04 v10(95.96,27.63) 95.51,28.08 94.48,28.08 94.31,28.25 94.31,29.37 94.18,29.49 93.75,29.49 93.62,29.37 93.62,28.68 93.49,28.55 92.91,28.55 92.78,28.68 92.78,28.93 92.66,29.06 92.3,29.06 92.17,28.93 92.17,28.65 92.05,28.53 91.67,28.53 91.54,28.65 91.54,30.27 91.28,30.53 91.28,30.53 91.04,30.77 91.04,30.77 90.69,31.13 90.69,31.74 90.56,31.86 89.67,31.86 89.54,31.74 89.54,30.88 89.93,30.49 89.93,30.48 90.01,30.4 90.01,29.39 89.61,28.98 88.82,28.98 88.55,28.72 87.59,28.72 87.07,28.2 86.08,28.2 85.92,28.04 85.32,28.04 v10(84.91,27.63) 84.48,28.06 83.45,28.06 83.26,28.25 83.26,29.37 83.13,29.49 82.7,29.49 82.57,29.37 82.57,28.68 82.45,28.55 80.9,28.55 80.77,28.68 80.77,29.21 80.24,29.75 78.97,29.75 77.64,28.41 77.14,28.41 76.8,28.75 76.25,28.75 76.12,28.63 76.12,28.46 76,28.33 75.76,28.33 75.64,28.46 75.64,28.63 75.51,28.75 75.16,28.75 75.03,28.63 75.03,28.2 74.87,28.03 74.26,28.03 v10(73.86,27.63) 73.41,28.08 72.93,28.08 72.78,28.23 72.78,29.71 72.63,29.86 72.4,29.86 72.27,29.73 72.27,27.95 72.57,27.65 72.57,27.34 72.4,27.17 72.04,27.17 71.86,27.34 71.86,27.68 71.74,27.8 71.74,28.05 71.62,28.17 71.33,28.17 71.2,28.3 71.2,28.53 71.33,28.66 71.62,28.66 71.74,28.78 71.74,29.74 71.62,29.86 70.87,29.86 70.72,29.71 70.72,28.26 70.59,28.13 69.48,28.13 69.35,28.26 69.35,28.61 69.48,28.74 69.78,28.74 69.91,28.87 69.91,29.56 69.76,29.71 69.24,29.71 69.1,29.56 v4(69.1,28.97)
  IN3 w0.122: v4(69.1,28.97) 68.89,28.97 68.79,28.87 68.79,28.5 68.92,28.37 69.52,28.37 69.64,28.25 69.64,28 69.52,27.88 68.94,27.88 68.82,27.75 68.82,26.07 68.69,25.94 68.12,25.94 68,26.06 68,26.15 67.87,26.28 67.64,26.28 67.51,26.15 67.51,26.06 67.39,25.94 67.07,25.94 66.42,26.59 66.42,26.94 66.55,27.06 66.73,27.06 67.05,26.74 68,26.74 68.29,27.03 68.29,29.3 68.41,29.43 68.89,29.43 69.02,29.55 69.02,29.75 68.76,30.01 68.04,30.01 67.87,30.18 67.87,30.31 68.16,30.59 68.69,30.59 68.82,30.72 68.82,31.5 68.7,31.63 68.52,31.63 68.4,31.75 68.4,31.99 68.52,32.11 68.7,32.11 68.82,32.24 68.82,32.48 68.7,32.6 68.52,32.6 68.4,32.72 68.4,32.97 68.52,33.09 68.7,33.09 68.82,33.21 68.82,33.46 68.7,33.58 68.52,33.58 68.4,33.7 68.4,33.94 68.52,34.06 68.7,34.06 68.83,34.19 68.83,34.47 70.01,35.65 70.01,36.49 70.16,36.64 70.31,36.64 70.61,36.34 71.4,36.34 72.27,37.21 72.27,37.44 72.27,38.43 72.02,38.68 72.02,39.01 72.27,39.26 72.27,40.36 72.05,40.58 72.05,52.06 71.92,52.18 71.51,52.18 71.38,52.31 71.38,53.05 71.25,53.18 70.96,53.18 70.84,53.06 70.84,52.28 70.75,52.18 70.45,52.18 70.35,52.28 70.35,53.17 70.23,53.3 69.98,53.3 69.86,53.17 69.86,52.36 69.73,52.23 68.49,52.23 68.36,52.36 68.36,52.62 68.49,52.74 68.82,52.74 68.94,52.87 68.94,53.1 68.82,53.23 67.93,53.23 67.8,53.1 67.8,52.31 67.67,52.18 64.19,52.18 64.06,52.31 64.06,52.49 64.06,54.37 65.29,55.59 65.29,56.68 65.36,56.76 65.36,57.19 64.81,57.74 64.81,58.95 64.12,59.63 v4(64.12,59.63)
  IN4 w0.091: v5(64.57,59.37) 64.32,59.63 v4(64.12,59.63)
  GND5 w0.102: v5(64.57,59.37) 64.57,59.16 v6(64.4,58.98)
  BOTTOM w0.076: v10(95.96,27.63) 95.96,27.56 96.29,27.22 97.37,27.22 97.47,27.32 98.1,27.32 UD3.J2 ; v10(84.91,27.63) 84.91,27.56 85.24,27.22 86.32,27.22 86.42,27.32 87.05,27.32 UD5.J2 ; UD1.J2 109.15,27.32 108.52,27.32 108.42,27.22 107.34,27.22 107.01,27.56 v10(107.01,27.63) ; UD7.J2 76,27.32 75.37,27.32 75.27,27.22 74.19,27.22 73.86,27.56 v10(73.86,27.63)
  BOTTOM w0.16: UCPU1.BD37 v6(64.4,58.98)
DDR_A_BS1: length 168.5
  TOP w0.076: v10(84.81,26.45) 85.19,26.83 86.3,26.83 86.48,26.65 86.92,26.65 UD6.K8 ; v10(106.91,26.45) 107.29,26.83 108.4,26.83 108.58,26.65 109.02,26.65 UD2.K8 ; UD4.K8 97.97,26.65 97.53,26.65 97.35,26.83 96.24,26.83 v10(95.86,26.45) ; UD8.K8 75.87,26.65 75.43,26.65 75.25,26.83 74.14,26.83 v10(73.76,26.45)
  TOP w0.16: R1082.1 116.77,31.34 v2(116.77,30.8)
  GND1 w0.102: v3(116.47,30.44) 116.47,30.49 v2(116.77,30.8)
  IN1 w0.127: v3(116.47,30.44) 116.47,30.21 v4(116.21,29.96)
  IN2 w0.122: v4(69.4,26.94) 69.65,26.69 69.65,26.53 70.03,26.15 70.47,26.15 70.7,26.38 72.37,26.38 72.75,26 73.31,26 v10(73.76,26.45) 73.76,26.45 73.76,26.55 74.09,26.88 75.31,26.88 75.43,26.75 75.43,26.34 75.56,26.22 75.87,26.22 75.99,26.34 75.99,26.93 76.15,27.08 77.67,27.08 78.44,27.85 78.44,28.38 78.57,28.51 79.46,28.51 79.59,28.38 79.59,27.18 79.71,27.05 80.58,27.05 80.72,27.19 80.72,27.46 81.18,27.92 82.39,27.92 83.22,27.09 84.16,27.09 v10(84.81,26.45) 84.81,26.45 84.81,26.55 85.14,26.88 86.36,26.88 86.48,26.75 86.48,26.34 86.61,26.22 86.92,26.22 87.04,26.34 87.04,26.85 87.27,27.08 88.08,27.08 88.54,26.62 89.33,26.62 89.48,26.77 89.48,28.19 89.61,28.32 89.9,28.32 90.03,28.19 90.03,26.69 90.15,26.57 90.4,26.57 90.52,26.69 90.52,27.8 90.64,27.92 90.88,27.92 91.01,27.8 91.01,26.69 91.13,26.57 91.87,26.57 91.97,26.67 91.97,27.28 91.84,27.41 91.62,27.41 91.49,27.54 91.49,27.8 91.61,27.92 93.44,27.92 94.27,27.09 95.21,27.09 v10(95.86,26.45) 95.86,26.45 95.86,26.55 96.19,26.88 97.41,26.88 97.53,26.75 97.53,26.34 97.66,26.22 97.96,26.22 98.09,26.34 98.09,26.93 98.24,27.08 99.77,27.08 100.54,27.85 100.54,28.38 100.67,28.51 101.56,28.51 101.68,28.38 101.68,27.18 101.81,27.05 102.67,27.05 102.8,27.18 102.8,27.44 103.28,27.92 104.49,27.92 105.31,27.09 106.26,27.09 v10(106.91,26.45) 106.91,26.45 106.91,26.55 107.29,26.93 108.03,26.93 108.45,27.34 111.6,27.34 112.87,28.61 114.87,28.61 v4(116.21,29.96)
  IN3 w0.122: v4(69.4,26.94) 69.4,25.99 69.98,25.41 71.46,25.41 71.58,25.29 71.58,24.14 71.71,24.02 72.4,24.02 72.75,23.66 76.13,23.66 76.26,23.53 76.26,22.72 76.13,22.59 72.35,22.59 72.22,22.72 72.22,23.28 72.09,23.41 71.18,23.41 71.06,23.53 71.06,23.89 70.93,24.02 70.71,24.02 70.57,23.87 70.57,23.53 70.45,23.41 69.32,23.41 69.2,23.54 69.2,24.42 69.32,24.54 69.63,24.54 69.76,24.66 69.76,24.91 69.63,25.03 69.32,25.03 69.2,25.15 69.2,25.42 68.95,25.67 67.97,25.67 67.84,25.55 67.84,24.47 67.72,24.35 67.48,24.35 67.36,24.47 67.36,25.55 67.24,25.67 66.96,25.67 66.15,26.48 66.15,27.37 66.33,27.55 66.89,27.55 67.04,27.39 67.04,27.14 67.16,27.01 67.89,27.01 68.01,27.14 68.01,29.64 67.59,30.06 67.59,30.42 68.12,30.95 68.12,34.17 69.74,35.78 69.74,36.62 70.09,36.97 70.36,36.97 70.72,36.61 71.28,36.61 71.99,37.32 71.99,38.32 71.6,38.71 71.6,39.02 71.99,39.41 71.99,40.24 71.74,40.5 71.74,41.9 71.55,42.08 71.55,42.36 71.78,42.58 71.78,51.78 71.65,51.9 63.91,51.9 63.78,52.03 63.78,52.61 63.78,52.61 63.78,54.48 64.95,55.65 64.95,56.58 64.93,56.6 64.93,56.96 v4(64.95,56.98)
  IN4 w0.091: v5(64.98,57.49) 64.95,57.47 v4(64.95,56.98)
  GND5 w0.102: v6(65.06,57.08) 65.06,57.42 v5(64.98,57.49)
  BOTTOM w0.076: v10(95.86,26.45) 95.86,26.26 95.61,26.01 95.09,26.01 94.48,26.62 93.93,26.62 93.62,26.31 UD3.K8 ; UD1.K8 104.67,26.31 104.98,26.62 105.53,26.62 106.14,26.01 106.66,26.01 106.91,26.26 v10(106.91,26.45) ; UD7.K8 71.52,26.31 71.83,26.62 72.38,26.62 72.99,26.01 73.51,26.01 73.76,26.26 v10(73.76,26.45) ; v10(84.81,26.45) 84.81,26.26 84.56,26.01 84.04,26.01 83.43,26.62 82.88,26.62 82.57,26.31 UD5.K8
  BOTTOM w0.16: UCPU1.BF36 v6(65.06,57.08)
DDR_A_BS2: length 167.2
  TOP w0.076: UD4.J3 94.42,27 94.23,27 94.1,26.87 94.1,26.65 94.23,26.52 94.75,26.52 95.3,27.07 v10(95.3,27.63) ; v10(73.2,27.63) 73.2,27.07 72.65,26.52 72.13,26.52 72.01,26.65 72.01,26.87 72.13,27 72.32,27 UD8.J3 ; UD6.J3 83.37,27 83.18,27 83.05,26.87 83.05,26.65 83.18,26.52 83.7,26.52 84.25,27.07 v10(84.25,27.63) ; UD2.J3 105.47,27 105.28,27 105.15,26.87 105.15,26.65 105.28,26.52 105.8,26.52 106.35,27.07 v10(106.35,27.63)
  TOP w0.16: R1080.1 115.88,31.35 v2(115.88,30.8)
  GND1 w0.102: v2(115.88,30.8) v3(115.88,30.37)
  IN1 w0.127: v4(115.45,29.96) 115.86,30.37 v3(115.88,30.37)
  IN2 w0.122: v4(71.43,34.69) 71.05,34.69 70.28,33.92 69.7,33.92 69.07,33.29 69.07,32.58 69.19,32.46 69.43,32.46 69.55,32.34 69.55,32.09 69.43,31.97 69.19,31.97 69.07,31.85 69.07,30.11 68.66,29.71 68.66,28.79 69.02,28.44 69.02,27.55 69.15,27.42 69.68,27.42 69.81,27.55 69.81,27.7 69.93,27.83 71.26,27.83 71.51,27.58 71.51,27.21 71.84,26.89 73.07,26.89 73.2,27.01 v10(73.2,27.63) 73.63,27.2 74.77,27.2 75.44,27.88 75.85,27.88 76.01,27.72 76.01,27.53 76.13,27.41 77.35,27.41 77.47,27.53 77.47,27.72 77.59,27.84 77.88,27.84 78.01,27.97 78.01,28.4 78.93,29.31 80.24,29.31 80.36,29.19 80.36,28.84 80.24,28.71 80.12,28.71 79.99,28.59 79.99,27.97 80.16,27.8 80.67,27.8 81.1,28.23 82.69,28.23 83.29,27.63 v10(84.25,27.63) 84.25,27.46 84.51,27.2 85.95,27.2 86.07,27.32 86.07,27.74 86.2,27.87 86.43,27.87 86.56,27.74 86.56,27.32 86.68,27.2 86.94,27.2 87.12,27.38 87.12,27.77 87.25,27.89 87.47,27.89 87.59,27.77 87.59,27.48 87.72,27.36 87.96,27.36 88.08,27.48 88.08,27.77 88.2,27.89 88.54,27.89 88.67,27.77 88.67,27.56 88.8,27.43 89.02,27.43 89.15,27.56 89.15,28.55 89.28,28.68 89.81,28.68 90.32,29.19 90.32,30.2 90.5,30.38 90.95,30.38 91.18,30.15 91.18,29.92 91.06,29.8 90.83,29.8 90.7,29.67 90.7,29.39 90.83,29.26 91.11,29.26 91.23,29.14 91.23,28.83 91.11,28.71 90.5,28.71 90.37,28.58 90.37,28.35 90.5,28.23 93.74,28.23 94.34,27.63 v10(95.3,27.63) 95.3,27.6 95.7,27.2 96.87,27.2 97.51,27.84 97.98,27.84 98.11,27.72 98.11,27.53 98.23,27.41 98.47,27.41 98.69,27.62 98.99,27.62 99.2,27.41 99.45,27.41 99.57,27.53 99.57,27.72 99.69,27.84 99.98,27.84 100.11,27.97 100.11,28.4 101.03,29.31 102.33,29.31 102.46,29.19 102.46,28.84 102.33,28.71 102.22,28.71 102.09,28.59 102.09,27.97 102.22,27.84 102.81,27.84 103.2,28.23 104.79,28.23 105.39,27.63 v10(106.35,27.63) 106.35,27.6 106.75,27.2 107.92,27.2 108.33,27.62 111.49,27.62 112.84,28.97 114.46,28.97 v4(115.45,29.96)
  IN3 w0.122: v4(68.55,60.1) 68.55,59.87 68.68,59.74 70.1,59.74 70.32,59.51 70.32,59.12 70.5,58.94 71.2,58.94 72.63,57.52 73.11,57.52 78.67,51.97 78.67,50.44 80.23,48.87 80.46,48.87 81.02,48.31 81.17,48.31 81.78,47.7 81.78,47.3 81.87,47.21 82.51,47.21 82.63,47.08 82.63,46.27 82.51,46.14 81.91,46.14 81.78,46.01 81.78,45.74 81.9,45.62 82.99,45.62 83.11,45.49 83.11,45.25 82.99,45.13 81.9,45.13 81.78,45.01 81.78,44.74 81.91,44.62 82.99,44.62 83.11,44.49 83.11,44.21 82.99,44.08 82.7,44.08 82.58,43.95 82.58,42.71 82.7,42.58 82.99,42.58 83.11,42.46 83.11,41.14 82.99,41.01 81.97,41.01 81.85,41.14 81.85,42.02 81.72,42.15 80.96,42.15 80.83,42.28 80.83,43.33 80.7,43.46 79.37,43.46 78.86,43.96 77.9,43.96 77.27,43.33 77.27,42.89 77.27,41.27 77.67,40.86 77.67,39.13 77.55,39 76.76,39 76.63,38.87 76.63,38.6 76.76,38.48 78.04,38.48 78.16,38.35 78.16,38.14 78.04,38.01 76.76,38.01 76.63,37.88 76.63,36.89 76.76,36.77 76.99,36.77 77.12,36.89 77.12,37.4 77.25,37.53 77.48,37.53 77.6,37.4 77.6,35.83 77.48,35.7 76.99,35.7 76.87,35.57 76.87,34.29 76.71,34.12 76.38,34.12 76.26,34.25 76.26,34.63 76.18,34.71 74.51,34.71 74.38,34.84 74.38,35.2 74.26,35.33 73.98,35.33 73.77,35.33 73.64,35.2 73.64,34.62 73.51,34.49 71.99,34.49 71.84,34.34 71.84,34.33 71.74,34.23 70.8,34.23 70.67,34.35 70.67,34.61 70.8,34.73 71.39,34.73 v4(71.43,34.69)
  IN4 w0.091: v4(68.55,60.1) 68.61,60.16 v5(69.33,60.16)
  GND5 w0.102: v5(69.33,60.16) 69.32,60.16 69.09,60.39 68.98,60.39 v6(68.97,60.38)
  BOTTOM w0.076: UD5.J3 86.51,26.94 84.91,26.94 84.25,27.6 v10(84.25,27.63) ; UD1.J3 108.61,26.94 107.01,26.94 106.35,27.6 v10(106.35,27.63) ; UD3.J3 97.56,26.94 95.96,26.94 95.3,27.6 v10(95.3,27.63) ; v10(73.2,27.63) 73.2,27.6 73.86,26.94 75.46,26.94 UD7.J3
  BOTTOM w0.16: UCPU1.BA28 68.78,60.15 68.97,60.34 v6(68.97,60.38)
DDR_A_CAS#: length 173.3
  TOP w0.076: UD2.G3 105.47,28.84 106.1,29.48 106.1,30.06 106.59,30.54 v10(106.59,30.96) ; v10(73.44,30.96) 73.44,30.54 72.96,30.06 72.96,29.48 72.32,28.84 UD8.G3 ; UD4.G3 94.42,28.84 95.05,29.48 95.05,30.06 95.54,30.54 v10(95.54,30.96) ; v10(84.49,30.96) 84.49,30.54 84,30.06 84,29.48 83.37,28.84 UD6.G3
  TOP w0.16: v2(114.99,35.04) R1074.1
  GND1 w0.102: v2(114.99,35.04) 114.59,35.45 v3(114.59,35.52)
  IN1 w0.127: v3(114.59,35.52) 114.8,35.74 v4(115.23,35.74)
  IN3 w0.122: v4(63.55,57.29) 62.44,56.17 62.44,52.05 62.44,50.63 62.54,50.53 63.36,50.53 63.49,50.41 63.49,49.79 63.61,49.67 63.85,49.67 63.97,49.79 63.97,50.41 64.1,50.53 64.98,50.53 65.08,50.43 65.08,49.77 65.18,49.67 66.11,49.67 66.24,49.79 66.24,50.41 66.36,50.53 67.22,50.53 67.32,50.43 67.32,49.77 67.42,49.67 68.32,49.67 68.44,49.79 68.44,49.93 68.45,49.94 68.45,50.42 68.57,50.53 69.45,50.53 69.55,50.43 69.55,48.76 69.43,48.63 64.95,48.63 64.83,48.5 64.83,48.22 65.11,47.94 65.11,47.88 65.43,47.57 70.31,47.57 70.43,47.45 70.43,47.19 70.31,47.08 65.16,47.08 65.03,46.95 65.03,46.67 65.66,46.05 66.94,46.05 67.04,45.95 67.04,45.03 66.94,44.93 65.84,44.93 65.72,44.8 65.72,44.41 66.3,43.83 66.5,43.83 66.63,43.95 66.63,44.32 66.76,44.44 67.62,44.44 67.75,44.32 67.75,43.98 67.88,43.85 69.48,43.85 69.6,43.72 69.6,43.47 69.48,43.35 67.96,43.35 67.88,43.26 67.88,43.07 69.04,41.9 69.73,41.9 70.38,41.24 70.38,39.73 70.24,39.58 70.23,39.58 70.13,39.48 70.13,38.27 70.38,38.02 70.38,37.38 70.26,37.25 69.96,37.25 69.31,36.6 v4(69.31,36.31)
  IN4 w0.091: v4(63.55,57.29) 63.99,57.29 v5(64.04,57.24) ; v4(115.23,35.74) 109.54,35.74 107.75,33.95 107.75,32.21 107.76,32.2 107.76,31.84 107.75,31.83 107.75,31.79 107.37,31.41 107.03,31.41 v10(106.59,30.96) 105.88,31.66 105.44,31.66 105.31,31.79 104.78,31.79 103.64,32.93 103.64,33.79 103.39,34.05 102.29,34.05 102.06,33.82 102.06,32.45 101.99,32.37 99.35,32.37 99.14,32.16 99.14,31.1 98.86,30.82 97.72,30.82 97.47,31.08 97.47,31.33 97.13,31.66 96.61,31.66 96.61,31.66 96.57,31.66 96.28,31.37 95.94,31.37 v10(95.54,30.96) 94.84,31.66 94.72,31.66 94.38,32.01 94.38,33.37 94.67,33.67 94.67,34.38 92.95,36.11 88.06,36.11 87.17,35.21 87.17,35.18 87.15,35.17 87.15,33.42 87.41,33.17 87.41,31.25 87.09,30.92 86.7,30.92 85.96,31.66 85.52,31.66 85.27,31.41 84.93,31.41 v10(84.49,30.96) 83.79,31.66 83.34,31.66 83.21,31.79 82.68,31.79 81.54,32.93 81.54,33.79 81.29,34.05 79.53,34.05 78.16,32.68 78.16,30.83 78.04,30.71 75.84,30.71 74.86,31.69 74.5,31.69 74.22,31.41 73.88,31.41 v10(73.44,30.96) 73.37,31.03 72.65,31.03 72.5,31.18 72.5,31.54 72.65,31.69 72.96,31.69 73.11,31.83 73.11,32.48 73.23,32.6 73.48,32.6 73.72,32.84 73.72,33.01 73.84,33.13 74.48,33.13 74.58,33.03 74.58,32.68 74.68,32.58 75.45,32.58 75.55,32.68 75.55,33.49 75.65,33.59 76.74,33.59 76.84,33.69 76.84,35.88 76.74,35.98 73.59,35.98 71.36,38.21 70.31,38.21 69.88,37.78 69.88,37.05 69.31,36.47 v4(69.31,36.31)
  GND5 w0.102: v6(64,57.66) 64,57.27 v5(64.04,57.24)
  BOTTOM w0.076: v10(84.49,30.96) 84.49,30.9 84.94,30.44 85.45,30.44 85.48,30.42 85.63,30.42 85.88,30.16 85.88,29.1 86.38,28.6 UD5.G3 ; UD3.G3 97.43,28.6 96.93,29.1 96.93,30.16 96.68,30.42 96.53,30.42 96.5,30.44 95.99,30.44 95.54,30.9 v10(95.54,30.96) ; UD1.G3 108.48,28.6 107.98,29.1 107.98,30.16 107.73,30.42 107.58,30.42 107.55,30.44 107.04,30.44 106.59,30.9 v10(106.59,30.96) ; v10(73.44,30.96) 73.44,30.9 73.9,30.44 74.4,30.44 74.43,30.42 74.58,30.42 74.84,30.16 74.84,29.1 75.33,28.6 UD7.G3
  BOTTOM w0.16: UCPU1.BE39 63.77,57.89 v6(64,57.66)
