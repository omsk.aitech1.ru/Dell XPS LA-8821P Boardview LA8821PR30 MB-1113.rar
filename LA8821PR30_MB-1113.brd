# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_JTAG_TDI: length 11.6
  TOP w0.122: RH40.2 105.83,54.63 RH46.1 105.54,54.92 105.54,56.54 v9(106.05,57.05) 106.31,57.05 106.86,57.61 v2(106.86,57.92)
  GND1 w0.104: v3(106.86,58.33) v2(106.86,57.92)
  IN1 w0.071: v3(106.86,58.33) 106.99,58.46 107.69,58.46 109.48,60.24 109.94,60.24 110.29,60.6 110.29,61.15 v4(110.29,61.15)
  IN4 w0.071: v5(110.29,60.67) v4(110.29,61.15)
  GND5 w0.104: v6(110.29,61.07) v5(110.29,60.67)
  BOTTOM w0.122: UH1.U12 v6(110.29,61.07)
PCH_JTAG_TDO: length 8.9
  TOP w0.122: RH38.2 115.95,54.69 115.95,55.61 v1(115.96,55.63) 115.82,55.77 115.82,56.16 115.21,56.77 115.21,57.14 114.76,57.59 RH44.1 114.28,58.04 114.28,59 113.75,59.54 113.75,59.91 v2(113.55,60.11)
  GND1 w0.104: v2(113.55,60.11) 113.53,60.12 v3(113.14,60.12)
  IN1 w0.071: v4(112.55,60.24) 112.57,60.22 113.04,60.22 v3(113.14,60.12)
  IN4 w0.071: v4(112.55,60.24) 112.26,60.53 v5(112.26,60.64)
  GND5 w0.104: v6(112.26,60.24) v5(112.26,60.64)
  BOTTOM w0.122: UH1.M12 v6(112.26,60.24)
PCH_JTAG_TMS: length 12.9
  TOP w0.122: v2(114,61.04) 114,60.83 115.56,59.27 115.75,59.27 116.16,58.86 116.16,58.34 116.42,58.09 116.42,57.49 v1(116.66,57.25) 117.02,56.88 117.02,56.71 117.81,55.92 RH39.2 118.5,55.45 119.28,55.45 119.71,55.88 RH45.1
  GND1 w0.104: v2(114,61.04) 114,61.28 v3(114.26,61.53)
  IN1 w0.071: v3(114.26,61.53) 113.93,61.86 v4(113.93,61.89)
  IN4 w0.071: v4(113.93,61.89) 112.83,61.89 v5(112.67,62.05)
  GND5 w0.104: v6(112.26,62.05) v5(112.67,62.05)
  BOTTOM w0.122: UH1.M15 v6(112.26,62.05)
PCH_LID_SW_IN#: length 29
  TOP w0.122: RH336.1 120.12,54.38 122.01,54.38 122.31,54.08 v7(122.83,54.08) ; v7(126.23,61.75) 126.68,61.3 RH319.1
  IN2 w0.094: v4(117.18,65.57) 117.89,65.57 118.94,64.52 124.69,64.52 126.23,62.98 v7(126.23,61.75)
  IN4 w0.071: v4(117.18,65.57) 117.18,65.39 v5(116.9,65.11)
  GND5 w0.104: v6(116.34,65.23) 116.45,65.11 v5(116.9,65.11)
  BOTTOM w0.122: UH1.C23 v6(116.34,65.23) ; v7(126.23,61.75) 126.5,61.48 126.5,60.89 125.82,60.22 124.26,60.22 123.32,59.27 123.32,57.55 123.71,57.16 123.83,57.16 124.77,56.21 124.77,55.37 124.23,54.83 123.31,54.83 122.83,54.34 v7(122.83,54.08)
PCH_PECI_R: length 4.3
  TOP w0.122: RH175.1 101.3,59.65 v1(101.78,60.13) 101.78,60.44 v2(101.61,60.62)
  GND1 w0.104: v3(101.28,60.17) 101.28,60.29 v2(101.61,60.62)
  IN1 w0.071: v3(101.28,60.17) v4(101.76,60.17)
  IN4 w0.071: v4(101.76,60.17) 101.56,60.37 v5(101.56,60.72)
  GND5 w0.104: v6(101.61,61.12) 101.56,61.07 v5(101.56,60.72)
  BOTTOM w0.122: UH1.AU12 v6(101.61,61.12)
PCH_PLTRST#: length 54.8
  TOP w0.122: UH5.2 136.9,74.88 136.77,74.76 136.34,74.76 136.25,74.84 UH5.1 136.25,75.92 136.2,75.97 135.63,75.97 133.71,77.89 RH183.2 130.97,77.42 130.97,76.11 131.3,75.78 131.63,75.78 132.26,76.42 RH168.2 132.44,75.7 v7(131.88,75.15)
  IN2 w0.094: v7(131.88,75.15) 130.52,75.15 130.09,75.58 128.71,75.58 128.01,74.88 127.78,74.88 127.29,74.4 125.41,74.4 124.98,74.83 121.77,74.83 120.17,73.23 115.95,73.23 115.7,72.99 112.33,72.99 111.64,72.3 111.64,71.32 110.93,70.61 110.93,69.22 111.69,68.47 111.69,67.22 112.05,66.87 112.05,65.49 111.87,65.32 111.87,64.29 111.23,63.65 111.23,63.28 111.34,63.18 111.34,62.52 112.17,61.68 113.37,61.68 115.08,59.97 115.08,59.51 114.61,59.04 v4(114.46,59.04)
  IN4 w0.071: v5(114.85,58.74) 114.78,58.81 114.69,58.81 v4(114.46,59.04)
  GND5 w0.104: v5(114.85,58.74) 114.85,58.62 v6(114.59,58.36)
  BOTTOM w0.122: v6(114.59,58.36) 114.85,58.62 UH1.F7 ; v1(132.05,74.49) 131.88,74.65 v7(131.88,75.15)
PCH_PWR_EN#: length 15.7
  TOP w0.122: C355.1 129.12,56.98 Q41.2 ; Q41.2 129.39,56.21 128.84,55.65 R894.1 129.23,54.57 130.42,54.57 130.81,54.19 Q5.2 130.5,52.17 v1(129.79,51.46) ; Q41.2 129.64,56.71 131.31,58.38 131.31,59.08 129.52,60.87 QH7.2
PCH_PWROK: length 38.9
  TOP w0.122: RH299.1 147.06,61.18 v2(147.04,61.2) ; v2(144.3,60.48) 143.93,60.1 U34.D5 ; v1(125.81,60.21) 125.73,60.13 v2(125.73,59.78) 125.55,59.6 124.49,59.6 124.06,59.17 123.79,59.17 123.57,58.94 122.73,58.94 RH131.1 122.26,59.51 121.64,60.13 119.8,60.13 119.51,60.41 RH130.1
  GND1 w0.104: v3(144.6,60.81) 144.6,60.79 144.6,60.79 144.6,60.78 144.3,60.49 v2(144.3,60.48) ; v2(125.73,59.78) v3(125.73,60.44) ; v2(147.04,61.2) 146.34,61.9 v3(146.34,62.01)
  IN1 w0.071: v3(146.34,62.01) 145.88,62.01 145.63,62.27 145.13,62.27 144.83,61.97 144.83,61.04 v3(144.6,60.81) 144.43,60.81 143.52,61.72 143.15,61.72 142.95,61.93 142.61,61.93 142.25,62.29 142.25,62.99 141.65,63.59 140.67,64.56 140.52,64.71 137.85,64.71 137.15,65.41 131.24,65.41 130.8,64.97 130.1,64.97 129.98,65.09 129.55,65.09 128.34,63.88 127.98,63.88 126.83,62.73 126.83,61.35 125.91,60.44 v3(125.73,60.44)
PCH_RSMRST#: length 27
  TOP w0.076: v2(144.11,61.26) 144.11,60.8 U34.D4
  TOP w0.122: v2(129.19,64.76) 129.04,64.91 129.04,66.21 128.34,66.9 126.85,66.9 v1(126.14,66.2) 125.9,65.96 125.74,65.96 125.24,65.45 125.24,65.43 125.22,65.41 125.22,64.66 124.78,64.21 RH159.1 125.19,64.13 125.22,64.17 RH133.2
  GND1 w0.104: v3(143.92,60.87) 144.11,61.06 v2(144.11,61.26) ; v3(129.83,64.78) 129.8,64.76 v2(129.19,64.76)
  IN1 w0.071: v3(129.83,64.78) 130.88,64.78 131.33,65.23 137.08,65.23 137.77,64.54 140.43,64.54 142.06,62.92 142.06,62.24 142.55,61.75 142.87,61.75 143.07,61.54 143.25,61.54 v3(143.92,60.87)
PCH_RSMRST#_R: length 17
  TOP w0.122: v7(126.68,65.74) 126.58,65.64 RH126.2 126.27,65.04 126.23,65.08 RH133.1
  IN1 w0.071: v7(126.68,65.74) 125.7,64.77 124.17,64.77 123.35,63.94 123.35,63.29 122.69,62.63 122.69,61.49 122.48,61.28 120.47,61.28 120.39,61.36 120.39,62.26 v4(120.18,62.47)
  IN4 w0.071: v4(120.18,62.47) v5(120.18,62.99)
  GND5 w0.104: v6(119.51,62.94) 120.12,62.94 v5(120.18,62.99)
  BOTTOM w0.122: v6(119.51,62.94) 119.51,62.94 v1(118.95,63.5) 118.3,64.15 116.95,64.15 116.9,64.1 116.4,64.1 UH1.B20
PCH_RTCRST#: length 13.8
  TOP w0.122: CLRP1.2 CH4.2 RH25.2 122.26,58.51 121.15,59.61 v1(121.06,59.61) 119.55,59.61 119.2,59.97 117.5,59.97 116.07,61.4 116.07,61.9 v2(115.48,62.5)
  GND1 w0.104: v2(115.48,62.5) 115.68,62.7 v3(115.68,62.95)
  IN1 w0.071: v4(115.18,62.95) v3(115.68,62.95)
  IN4 w0.071: v5(115.8,63.6) 115.18,62.98 v4(115.18,62.95)
  GND5 w0.104: v6(115.34,63.59) 115.79,63.59 v5(115.8,63.6)
  BOTTOM w0.122: v6(115.34,63.59) 115.31,63.55 UH1.F19
PCH_RTCX1: length 5.4
  TOP w0.122: YH1.1 120.96,62.95 CH2.1 119.73,63.09 RH2.1 118.82,62.88 v7(118.32,62.88)
  BOTTOM w0.122: v7(118.32,62.88) 118.23,62.97 118.13,62.97 117.76,63.33 117.01,63.33 UH1.A19
PCH_RTCX2: length 6.6
  TOP w0.122: YH1.2 120.33,63.83 CH3.1 119.21,63.83 RH2.2 118.79,64 v7(118.29,63.51)
  GND5 w0.104: v6(117.18,63.69) 117.09,63.6 v6(116.33,63.6)
  BOTTOM w0.122: v6(117.18,63.69) 117.38,63.89 117.91,63.89 v7(118.29,63.51) ; UH1.C19 v6(116.33,63.6)
PCH_SATALED#: length 11
  IN2 w0.094: v4(110.01,56.02) 110.22,56.22 110.22,58.15 109.86,58.51 109.52,58.51 109.23,58.8 v4(109.23,58.86)
  IN4 w0.071: v4(110.01,56.02) 109.99,55.99 v5(109.53,55.99) ; v5(109.28,59.75) 109.23,59.7 v4(109.23,58.86)
  GND5 w0.104: v6(109.74,59.75) v5(109.28,59.75) ; v5(109.53,55.99) 109.53,55.71 v6(109.38,55.56)
  BOTTOM w0.122: UH1.W10 v6(109.74,59.75) ; RH35.2 107.51,52.34 108.04,52.88 108.04,53.11 108.13,53.2 108.13,53.58 107.96,53.76 v1(107.58,53.76) v6(109.38,55.56)
PCH_SMBCLK: length 103.7
  TOP w0.122: v7(80.12,50.66) 80.12,51.85 79.38,52.6 UD18.6 74.37,52.6 73.33,51.56 71.27,51.56 70.94,51.23 70.55,51.23 70.16,51.63 68.97,51.63 68.76,51.83 UD17.6 ; DE2.2 130.31,26.2 130.31,27.09 v7(129.75,27.65) ; RH98.1 133.85,23.13 134.73,23.13 135.04,23.44 QH3.1 135.04,23.74 134.72,24.07 RH105.2 133.38,24.07 132.93,24.52 132.93,24.9 v1(134.7,26.68) 134.87,26.85 136.42,26.85 v7(136.63,26.63)
  IN2 w0.094: v7(80.12,50.66) 81.35,49.43 81.35,45.01 80.1,43.76 80.1,42.07 80.56,41.61 82.49,39.68 89.17,39.68 89.97,38.87 92.7,38.87 95.27,36.31 116.31,36.31 117.76,34.86 117.76,34.39 119.9,32.25 124.3,32.25 128.18,28.37 129.03,28.37 v7(129.75,27.65) 131.29,26.11 134.69,26.11 135.34,26.76 136.51,26.76 v7(136.63,26.63)
  BOTTOM w0.122: v7(136.63,26.63) 137.75,26.63 138.25,27.13 JTP1.6
PCH_SMBDATA: length 98.9
  TOP w0.122: QH3.4 136.34,24.67 136.64,24.38 RH111.2 RH99.1 138.51,26.35 139.39,26.35 139.47,26.28 v7(139.91,26.28) ; UD17.5 v1(69.96,51.18) 70.25,51.18 70.45,50.99 71.05,50.99 71.38,51.31 73.44,51.31 74.07,51.95 UD18.5 79.48,51.95 79.66,51.77 v7(79.66,51.12) ; DE2.3 v7(129.01,27.77)
  IN2 w0.094: v7(79.66,51.12) 79.66,50.51 81.16,49.01 81.16,45.09 79.9,43.84 79.9,41.99 80.48,41.41 80.48,41.41 82.4,39.48 88.75,39.48 89.64,38.6 92.62,38.6 95.1,36.12 116.12,36.12 117.33,34.91 117.33,34.52 119.84,32 124.24,32 128.47,27.77 v7(129.01,27.77) 130.88,25.91 139.54,25.91 v7(139.91,26.28)
  BOTTOM w0.122: v7(139.91,26.28) 139.25,26.94 JTP1.5
PCH_SMLCLK: length 57.8
  TOP w0.076: U34.B8 145.17,58.85 146.31,58.85 v2(146.37,58.92)
  TOP w0.122: QH4.1 127.17,57.48 127.25,57.56 128.3,57.56 128.54,57.8 128.54,59.97 128.81,60.24 128.81,61.96 129.32,62.47 v2(132.29,62.47) 132.53,62.71 133.48,62.71 133.87,63.09 133.87,65.31 135.31,66.76 135.31,70.08 136.3,71.07 136.3,73.08 135.5,73.88 v1(134.8,73.88) 130.99,73.88 129.85,75.02 R983.2 ; R244.1 147.66,56.69 147.17,57.18 147.17,57.78 146.95,58.01 146.95,58.47 146.55,58.86 146.43,58.86 v2(146.37,58.92)
  GND1 w0.104: v3(146.59,59.66) 146.59,59.45 146.37,59.23 v2(146.37,58.92) ; v2(132.29,62.47) 132.24,62.42 v3(132.24,62.01)
  IN1 w0.071: v3(132.24,62.01) 131.81,62.01 v4(131.71,61.91) ; v3(146.59,59.66) 146.63,59.7 147.33,59.7 v4(147.35,59.68)
  IN2 w0.094: v4(131.71,61.91) 132.35,61.27 135.28,61.27 135.43,61.11 136.41,61.11 137.82,62.52 139.12,62.52 139.62,63.02 142.12,63.02 145.7,59.43 146.51,59.43 146.74,59.65 147.33,59.65 v4(147.35,59.68)
PCH_SMLDATA: length 57.4
  TOP w0.076: U34.A6 145.61,59.41 145.91,59.41 145.93,59.43 v2(145.93,59.43) 146.22,59.43 146.27,59.48 146.66,59.48 146.69,59.45 146.69,59.45
  TOP w0.122: 146.69,59.45 146.72,59.45 147.66,58.51 R247.1 ; v7(129.24,63.08) 129.24,62.8 128.56,62.12 128.56,60.36 127.65,59.45 126.83,59.45 126.59,59.69 126.27,59.69 125.91,59.33 125.36,59.33 124.8,58.78 QH4.4 ; R984.2 134.25,79.91 133.37,79.91 132.8,80.48 132.19,80.48 131.43,79.72 v7(131.12,79.72)
  GND1 w0.104: v3(146.51,60.07) 146.17,59.72 146.17,59.66 v2(145.93,59.43)
  IN1 w0.071: v4(146.98,60.17) 146.88,60.07 v3(146.51,60.07)
  IN2 w0.094: v7(129.24,63.08) 129.45,62.88 131.28,62.88 132.11,62.05 132.11,61.88 132.52,61.47 135.36,61.47 135.47,61.35 136.37,61.35 137.74,62.73 139.03,62.73 139.52,63.21 142.2,63.21 145.78,59.63 146.43,59.63 v4(146.98,60.17)
  BOTTOM w0.122: v7(131.12,79.72) 130.73,79.32 130.07,79.32 129.9,79.16 129.9,78.91 129.62,78.63 128.96,78.63 128.51,78.17 128.51,77.25 129.04,76.72 129.04,75.83 128.51,75.3 v1(128.51,73.83) 128.94,73.39 128.94,71.03 128.18,70.27 128.18,68.64 128.1,68.57 128.1,67.32 127.93,67.14 127.93,64.39 v7(129.24,63.08)
PCH_SPI_CLK: length 6.2
  TOP w0.122: v2(106.51,58.64) 106.76,58.38 107.43,58.38 RH255.2 107.86,57.93 106.99,57.07 CH118.2
  GND1 w0.104: v3(106.79,58.94) 106.51,58.66 v2(106.51,58.64)
  IN1 w0.084: v3(106.79,58.94) 106.94,59.09 v4(106.94,59.63)
  IN4 w0.071: v4(106.94,59.63) 107.5,60.19 v5(107.8,60.19)
  GND5 w0.104: v6(107.4,60.19) v5(107.8,60.19)
  BOTTOM w0.122: UH1.AD12 v6(107.4,60.19)
PCH_SPI_CLK_R: length 60.8
  TOP w0.122: RH255.1 107.88,56.63 v2(107.65,56.4)
  GND1 w0.104: v3(107.65,55.97) v2(107.65,56.4)
  IN1 w0.071: v4(107.98,56.32) 107.65,55.99 v3(107.65,55.97)
  IN2 w0.094: v7(136.63,81.42) 136.48,81.57 127.44,81.57 126.04,82.97 125.79,82.97 124.54,81.72 124.54,81.45 123.5,80.4 121.61,80.4 120.7,79.49 120.7,77.18 119.59,76.07 116.2,76.07 115.46,75.32 114.11,75.32 113.36,76.07 112.57,76.07 111.14,74.63 111.14,74.2 109.63,72.69 109.63,71.82 110.04,71.41 110.04,68.29 109.99,68.24 109.99,66.15 109.76,65.92 108.06,65.92 107.87,65.72 107.87,65.45 108.67,64.64 108.67,62.24 108.08,61.66 108.08,59.36 107.17,58.45 107.17,57.62 107.98,56.81 v4(107.98,56.32)
  BOTTOM w0.122: U48.6 135.96,83.15 136.18,82.93 v1(136.18,82.45) 136.18,81.88 v7(136.63,81.42) 137.57,80.48 RH256.2
PCH_SPI_CS#: length 49.2
  IN2 w0.094: v4(107.88,57.9) 107.88,58.28 108.52,58.92 108.52,59.37 109.68,60.54 109.68,61.85 110.29,62.46 110.29,63.32 110.78,63.8 110.78,64.19 110.67,64.3 110.67,64.78 111.04,65.15 111.04,66.5 111.11,66.57 111.11,68.38 110.52,68.96 110.52,71.5 110.08,71.95 110.08,72.5 110.85,73.28 111.89,73.28 112.88,74.27 116.06,74.27 116.79,74.99 120.52,74.99 121.46,75.93 121.59,75.93 121.88,75.65 122.01,75.65 122.14,75.78 122.14,75.91 121.86,76.2 121.86,76.33 121.99,76.46 122.12,76.46 122.41,76.18 122.54,76.18 122.67,76.31 122.67,76.44 122.39,76.73 122.39,76.86 122.52,77 122.65,77 122.94,76.71 123.07,76.71 123.21,76.84 123.21,76.98 122.92,77.26 122.92,77.4 123.01,77.48 123.26,77.48 123.36,77.58 123.36,77.92 123.45,78.02 123.64,78.02 123.73,77.92 123.73,77.58 123.83,77.48 124.01,77.48 124.11,77.58 124.11,77.92 124.2,78.02 124.39,78.02 124.48,77.92 124.48,77.58 124.58,77.48 125.43,77.48 125.67,77.72 125.67,78.42 125.46,78.63 125.46,79.21 v4(125.86,79.62)
  IN4 w0.071: v5(107.88,58.43) 107.88,58.43 v4(107.88,57.9) ; v5(125.33,79.64) 125.36,79.62 v4(125.86,79.62)
  GND5 w0.104: v6(125.1,80.2) 125.33,79.97 v5(125.33,79.64) ; v5(107.88,58.43) 108.34,58.43 v6(108.36,58.46)
  BOTTOM w0.122: U48.1 127.06,80.61 125.22,82.45 RH57.1 v1(125.07,81.22) 125.07,80.24 v6(125.1,80.2) ; UH1.AB8 v6(108.36,58.46)
PCH_SPI_HOLD#: length 4.9
  BOTTOM w0.122: U48.7 135.39,81.88 135.96,81.31 135.96,79.48 135.43,78.96 RH56.1 v1(135.41,77.99)
PCH_SPI_SI: length 58.7
  TOP w0.122: v7(133.76,84.95) v1(130.08,84.95)
  IN2 w0.094: v7(133.76,84.95) 133.51,85.2 131.5,85.2 131.22,84.91 127.74,84.91 126.77,83.93 125.42,83.93 123.45,81.97 120.15,81.97 119.23,81.04 115.33,81.04 113.82,79.54 112.68,79.54 108.52,75.37 108.05,75.37 107.59,74.92 107.59,73.88 106.53,72.82 106.53,71.96 105.18,70.6 104.43,70.6 103.99,70.17 103.99,69.02 103.79,68.82 103.79,68.21 103.69,68.11 103.69,66.36 103.41,66.08 103.41,65.24 104.66,64 104.66,62.95 104.63,62.93 v4(104.63,62.45)
  IN4 w0.071: v5(108.77,59.35) 108.34,58.92 106.15,58.92 105.41,59.66 105.41,61.36 104.63,62.14 v4(104.63,62.45)
  GND5 w0.104: v6(109.33,59.35) v5(108.77,59.35)
  BOTTOM w0.122: 134.87,84.42 134.29,84.42 v7(133.76,84.95) ; UH1.W8 v6(109.33,59.35)
PCH_SPI_SO: length 42.5
  IN2 w0.094: v8(126.4,81.9) 125.76,81.9 124.35,80.49 124.35,80.11 119.95,75.7 116.13,75.7 115.52,75.1 113.05,75.1 111.45,73.49 110.74,73.49 109.87,72.63 109.87,71.86 110.32,71.41 110.32,67.11 110.8,66.63 110.8,65.26 110.53,65 109.82,65 109.57,64.75 109.57,64.49 109.94,64.12 109.94,63.28 109.51,62.85 109.51,62.24 108.31,61.05 108.31,59.14 107.5,58.33 107.5,57.66 108.89,56.27 v7(108.89,55.81)
  BOTTOM w0.122: v8(126.4,81.9) 126.42,81.88 U48.2 ; UH1.Y2 108.87,55.82 v7(108.89,55.81)
PCH_SPI_WP#: length 2.6
  BOTTOM w0.122: U48.3 126.28,83.15 v1(126.09,83.34) RH54.1
PCH_SRTCRST#: length 6.6
  TOP w0.122: v7(119.19,66.36) 119.19,66.25 118.94,66 CLRP2.1
  BOTTOM w0.122: v7(119.19,66.36) 120,65.55 RH23.2 120,65.07 120.07,65 CH5.1 120.05,64.6 119.48,65.16 v1(118.47,65.16) 116.81,65.16 UH1.A23
PCH_SUSWARN#: length 7.1
  TOP w0.076: U34.D8 144.31,58.99 v2(144.34,58.99)
  GND1 w0.104: v2(144.34,58.99) 144.36,59 v3(144.79,59) ; v3(149.7,59.45) 149.73,59.48 v2(149.73,60.16)
  IN1 w0.071: v3(144.79,59) 144.85,58.94 145.59,58.94 145.68,59.03 146.01,59.03 146.15,58.89 146.68,58.89 146.83,58.74 147.79,58.74 148.47,59.41 149.01,59.41 149.05,59.45 v3(149.7,59.45)
PCI_PIRQA#: length 9.4
  IN4 w0.071: v5(117.69,75.81) 117.3,76.19 v5(115.73,76.19)
  GND5 w0.104: v5(115.73,76.19) 115.5,76.19 115.4,76.29 v6(115.15,76.29) ; v5(117.69,75.81) 117.69,75.43 v6(117.98,75.13)
  BOTTOM w0.122: v6(117.98,75.13) 118.34,75.13 118.95,75.74 120,75.74 120.09,75.65 v1(120.59,75.65) 121.97,75.65 122.38,76.06 RH333.2
  BOTTOM w0.254: UH1.D49 115.28,76.15 v6(115.15,76.29)
PCI_PIRQB#: length 8.9
  IN4 w0.071: v5(117.23,75.78) 116.26,75.78 v5(116.21,75.83)
  GND5 w0.104: v5(116.21,75.83) 116.16,75.78 v6(115.78,75.78) ; v6(117.43,75.13) 117.41,75.16 117.41,75.6 v5(117.23,75.78)
  BOTTOM w0.122: RH334.2 122.55,76.92 v1(122.02,76.4) 121.61,75.99 118.84,75.99 118.33,75.48 117.77,75.48 v6(117.43,75.13)
  BOTTOM w0.254: v6(115.78,75.78) 115.99,75.57 UH1.C48
PCI_PIRQC#: length 7.8
  GND5 w0.104: v6(116.75,74.57) 116.75,74.59 116.72,74.59 v6(116.33,74.98)
  BOTTOM w0.122: v6(116.75,74.57) 118.13,74.57 119,75.44 119.77,75.44 119.91,75.31 121.82,75.31 v1(122.02,75.11) 122.86,75.11 RH332.2 ; UH1.C47 v6(116.33,74.98)
PCI_PIRQD#: length 9.1
  TOP w0.122: v2(116.45,74.04) 116.45,74.14 v1(116.82,74.51) 117.32,75.01 117.93,75.01 118.36,75.44 122.14,75.44 RH327.2
  GND1 w0.104: v2(116.45,74.04) 116.45,73.58 v3(116.42,73.55)
  IN1 w0.071: v4(116.78,73.9) 116.77,73.9 v3(116.42,73.55)
  IN4 w0.071: v5(116.29,73.77) 116.42,73.9 v4(116.78,73.9)
  GND5 w0.104: v5(116.29,73.77) 116.28,73.76 v6(115.88,73.76)
  BOTTOM w0.122: UH1.C45 115.88,73.76 v6(115.88,73.76)
PCIE_MCARD1_DET#: length 84.2
  TOP w0.122: RH262.1 179.61,41.82 179.61,42.23 179.43,42.42 v1(179.29,42.42) 179.12,42.42 178.67,41.97 v7(178.54,41.97)
  IN2 w0.094: v4(111.94,57.47) 111.67,57.2 111.67,56.5 112,56.17 112.95,56.17 113.77,55.35 115.16,55.35 116.08,56.27 117.09,56.27 117.71,55.65 118.75,55.65 119.82,56.72 120.69,56.72 120.93,56.96 125.31,56.96 125.84,56.42 127.73,56.42 127.85,56.55 136.25,56.55 136.67,56.97 137.07,56.97 137.4,56.64 137.4,56.45 138.9,54.95 142.95,54.95 144.72,53.18 144.72,51.07 148.42,47.37 158.49,47.37 159.85,48.72 169.82,48.72 170.74,47.8 172.23,47.8 178.06,41.97 v7(178.54,41.97)
  IN4 w0.071: v5(111.71,57.04) 111.94,57.27 v4(111.94,57.47)
  GND5 w0.104: v6(111.71,57.55) 111.71,57.04 v5(111.71,57.04)
  BOTTOM w0.122: UH1.N3 111.71,57.55 v6(111.71,57.55) ; v7(178.54,41.97) 178.72,42.15 JWLAN1.37
PCIE_PRX_WLANTX_N3: length 120.2
  IN4 w0.071: v5(176.28,36.39) 176.4,36.5 176.59,36.5 176.84,36.75 176.84,38.23 175.02,40.06 175.02,41.07 175.46,41.51 175.46,43.82 171.64,47.64 171.18,47.64 169.76,49.06 158,49.06 157.63,48.69 148.58,48.69 145.73,51.55 140.68,51.55 140.59,51.64 138.17,51.64 137.6,52.21 133.85,52.21 132.98,53.09 132.06,53.09 131.76,52.79 130.33,52.79 130.14,52.98 122.57,52.98 121.97,52.37 119.29,52.37 119.13,52.53 106.14,52.53 106,52.67 104.26,52.67 102.57,54.36 98.99,54.36 94.59,58.76 94.59,59.59 93.06,61.11 93.06,63.75 93.56,64.24 93.56,66.4 92.31,67.64 92.31,69.2 92.51,69.39 93.95,69.39 94.51,69.95 96.85,69.95 97.1,70.2 97.1,70.4 97.23,70.52 v5(97.24,70.52)
  GND5 w0.076: v6(175.85,36.39) 175.99,36.53 176.14,36.53 v5(176.28,36.39) ; v5(97.24,70.52) 97.24,70.74 v6(97.41,70.92)
  BOTTOM w0.114: v6(97.41,70.92) UH1.BH36 ; v6(175.85,36.39) 175.91,36.45 v7(176.49,36.45) 176.83,36.45 177.24,36.86 178.28,36.86 178.41,36.74 178.94,36.74 179.13,36.55 JWLAN1.23
PCIE_PRX_WLANTX_P3: length 120.2
  IN4 w0.071: v5(176.28,36.82) 176.44,36.66 176.52,36.66 176.68,36.82 176.68,38.16 174.85,39.99 174.85,41.14 175.3,41.58 175.3,43.76 171.58,47.48 171.11,47.48 169.69,48.89 158.06,48.89 157.7,48.53 148.52,48.53 145.66,51.38 140.61,51.38 140.52,51.47 138.1,51.47 137.53,52.04 133.78,52.04 132.91,52.92 132.13,52.92 131.83,52.63 130.27,52.63 130.08,52.82 122.64,52.82 122.03,52.21 119.22,52.21 119.06,52.36 106.07,52.36 105.93,52.5 104.19,52.5 102.5,54.19 98.92,54.19 94.42,58.69 94.42,59.52 92.89,61.04 92.89,63.82 93.39,64.31 93.39,66.33 92.15,67.57 92.15,69.27 92.44,69.56 93.88,69.56 94.44,70.12 96.78,70.12 96.93,70.27 96.93,70.5 96.86,70.57 96.76,70.57 v5(96.7,70.52)
  GND5 w0.076: v5(176.28,36.82) 176.16,36.69 175.99,36.69 v6(175.85,36.83) ; v6(96.55,70.92) 96.7,70.76 v5(96.7,70.52)
  BOTTOM w0.114: UH1.BK36 v6(96.55,70.92) ; v6(175.85,36.83) 175.98,36.71 176.72,36.71 177.13,37.12 v7(177.83,37.12) 178.39,37.12 178.51,37 178.68,37 179.03,37.35 JWLAN1.25
PCIE_PTX_WLANRX_N3: length 3.8
  BOTTOM w0.114: JWLAN1.31 178.92,39.75 178.69,39.98 v7(178.11,39.98) 177.51,39.98 177.22,40.27 176.89,40.27 CH11.1
PCIE_PTX_WLANRX_N3_C: length 112.7
  IN4 w0.071: v5(175.52,40.22) 175.52,40.25 175.62,40.35 175.69,40.35 175.83,40.49 176.97,40.49 177.87,41.39 177.87,44.78 176.65,46 174.26,46 171.85,48.41 171.38,48.41 170.11,49.68 157.72,49.68 157.36,49.33 148.84,49.33 144.71,53.45 136.96,53.45 136.49,53.92 135.05,53.92 134.42,54.55 132.56,54.55 131.43,53.42 130.68,53.42 130.47,53.62 122.18,53.62 121.64,53.07 119.51,53.07 118.48,54.1 115.33,54.1 114.87,53.63 110.6,53.63 110.41,53.82 106.62,53.82 106.2,54.24 103.64,54.24 102.81,55.07 99.95,55.07 96.74,58.28 96.01,58.28 95.27,59.02 95.27,59.78 94.21,60.84 94.21,63.43 94.32,63.54 94.32,65.84 96.35,67.87 96.35,68.34 97.78,69.77 98.25,69.77 98.38,69.64 98.38,69.55 98.24,69.41 v5(98.23,69.41)
  GND5 w0.076: v6(98.01,69.76) 98.14,69.76 98.25,69.65 98.25,69.42 v5(98.23,69.41) ; v5(175.52,40.22) 175.4,40.34 175.23,40.34 v6(175.09,40.2)
  BOTTOM w0.114: v6(98.01,69.76) UH1.BF33
  BOTTOM w0.127: v6(175.09,40.2) 175.19,40.3 175.34,40.3 CH11.2
PCIE_PTX_WLANRX_P3: length 3.8
  BOTTOM w0.114: CH16.1 176.92,40.53 177.33,40.53 177.62,40.24 178.65,40.24 178.96,40.55 JWLAN1.33
PCIE_PTX_WLANRX_P3_C: length 112.8
  IN4 w0.071: v5(98.64,69.41) 98.64,69.42 98.55,69.5 98.55,69.71 98.32,69.94 97.72,69.94 96.18,68.41 96.18,67.94 94.15,65.9 94.15,63.61 94.04,63.5 94.04,60.77 95.11,59.71 95.11,58.96 95.94,58.12 96.67,58.12 99.88,54.9 102.75,54.9 103.57,54.08 106.14,54.08 106.56,53.66 110.34,53.66 110.53,53.47 114.93,53.47 115.4,53.94 118.41,53.94 119.44,52.91 121.7,52.91 122.25,53.45 130.41,53.45 130.61,53.25 131.5,53.25 132.63,54.38 134.36,54.38 134.98,53.76 136.42,53.76 136.89,53.29 144.64,53.29 148.77,49.16 157.43,49.16 157.78,49.52 170.05,49.52 171.32,48.25 171.78,48.25 174.2,45.83 176.58,45.83 177.71,44.71 177.71,41.46 176.9,40.65 v5(175.52,40.65)
  GND5 w0.076: v5(98.64,69.41) 98.64,69.55 v6(98.87,69.79) ; v5(175.52,40.65) 175.37,40.51 175.21,40.51 v6(175.09,40.63)
  BOTTOM w0.114: v6(98.87,69.79) UH1.BD33
  BOTTOM w0.127: CH16.2 175.39,40.57 175.15,40.57 v6(175.09,40.63)
PEG_A_CLKRQ#: length 7.8
  TOP w0.122: v2(111.16,58.92) 110.9,58.66 110.9,56.99 v1(111.64,56.25) 111.75,56.13 111.75,55.55 111.32,55.12 RH141.1
  GND1 w0.104: v2(111.16,58.92) 111.16,58 v3(111.21,57.95)
  IN1 w0.071: v3(111.21,57.95) 111.21,58.33 v4(111.11,58.43)
  IN4 w0.071: v4(111.11,58.43) 111.19,58.51 v5(111.19,58.92)
  GND5 w0.104: v5(111.19,58.92) 111.19,59.33 v6(111.21,59.35)
  BOTTOM w0.122: v6(111.21,59.35) 111.26,59.3 UH1.R8
PEG_B_CLKREQ#: length 5.4
  BOTTOM w0.122: 116.31,57.14 116.31,57.11 116.62,56.81 116.62,56.47 116.8,56.29 116.8,54.61 117.77,53.63 RH112.2
  BOTTOM w0.305: 116.31,57.14 116.31,57.14 UH1.C4
PEG_COMP: length 9.5
  BOTTOM w0.122: 85.38,76.09 85.38,76.64 84.46,77.56 81.85,77.56 UCPU1.G3 80.83,77.09 UCPU1.G4
  BOTTOM w0.381: RC2.2 84.72,76.09 v1(84.09,76.72) 82.91,76.72 82.55,77.09 UCPU1.G1
PHASE: length 3.3
  BOTTOM w1.016: 143.38,36.42 144.88,36.42 144.9,36.4 ; 143.38,36.42 PC22.2 ; 143.38,36.42 v9(141.74,36.42) 141.67,36.42
  vias: v7(134.73,32.96) v7(134.73,32.32) v7(135.47,32.98) v7(135.47,32.35) v7(136.2,32.98) v7(136.2,32.35)
PHASE1: length 24.1
  TOP w0.508: PQ1218.9 28.65,69.69 PR743.1
  GND1 w0.254: v6(26.73,63.84) v5(27.19,63.84) ; v5(27.16,62.73) v6(26.73,62.73) ; v5(27.16,63.28) v6(26.73,63.28) ; v5(27.19,62.17) v2(26.75,62.17)
  IN1 w0.254: v4(27.92,62.73) v5(27.16,62.73) ; v4(27.67,62.17) v5(27.19,62.17) ; v4(28,63.84) v5(27.19,63.84) ; v4(27.64,63.28) v5(27.16,63.28)
  IN1 w1.016: 27.24,65.5 27.24,75.27 26.47,76.03
  IN4 w0.254: v4(27.67,62.17) v5(27.19,62.17) ; v5(27.16,62.73) v4(27.92,62.73) ; v4(28,63.84) v5(27.19,63.84) ; v5(27.16,63.28) v4(27.64,63.28)
  GND5 w0.254: v6(26.73,63.84) v5(27.19,63.84) ; v6(26.73,62.17) v5(27.19,62.17) ; v6(26.73,62.73) v5(27.16,62.73) ; v6(26.73,63.28) v5(27.16,63.28)
  vias: v7(24.26,64.02) v7(24.26,63.39) v7(24.29,62.75) v7(24.29,62.12) v7(24.29,61.48) v7(24.9,64.02) v7(24.9,63.39) v7(24.92,62.75) v7(24.92,62.12) v7(24.92,61.48) v7(25.51,77.13) v7(25.53,64.02) v7(25.53,63.39) v7(25.56,62.75) v7(25.56,62.12) v7(25.56,61.48) v7(26.09,76.87) v7(26.17,64.02) v7(26.17,63.39) v7(26.19,62.75) v7(26.19,62.12) v7(26.19,61.46) v7(26.77,60.96) v7(26.84,60.24) v7(26.84,59.56) v7(27.41,64.45) v7(27.46,60.95) v7(27.54,60.26) v7(27.54,59.56) v7(28.07,64.48) v7(28.23,60.22) v7(28.23,59.59)
PHASE1G: length 13.4
  GND1 w0.254: v6(20.45,72.89) 20.48,72.86 v5(20.48,72.45) ; v6(20.05,72.5) v5(20.05,72.07) ; v5(20.28,70.22) 20.48,70.42 v6(20.66,70.42) ; v6(19.51,69.91) v5(19.95,69.91)
  IN1 w0.254: v5(20.48,72.45) 20.48,72.91 v4(20.45,72.94) ; v5(19.95,69.91) v4(19.95,69.41) ; v5(20.05,72.07) 20.05,72.1 20.07,72.07 20.43,72.07 v4(20.53,71.97) ; v4(20.63,69.86) v5(20.28,70.22)
  IN1 w1.016: 21.77,74 21.77,74 21.78,75.09 21.27,75.6 21.27,79.59
  IN4 w0.254: v4(20.63,69.86) v5(20.28,70.22) ; v4(19.95,69.41) v5(19.95,69.91) ; v4(20.53,71.97) 20.43,72.07 v5(20.05,72.07) ; v5(20.48,72.45) 20.48,72.91 v4(20.45,72.94)
  GND5 w0.254: v5(20.05,72.07) v6(20.05,72.5) ; v5(20.48,72.45) 20.48,72.86 v6(20.45,72.89) ; v6(20.66,70.42) 20.48,70.42 v5(20.28,70.22) ; v5(19.95,69.91) v6(19.51,69.91)
  vias: v7(19.44,78.3) v7(19.54,78.93) v7(19.51,72.25) v7(19.72,71.64) v7(19.72,70.42) v7(19.92,71.03) v7(20.56,70.95) v7(20.76,73.49) v7(21.52,72.91) v7(21.52,72.28) v7(22.16,73.42) v7(22.16,72.78) v7(22.16,72.15) v7(22.36,71.08) v7(22.36,70.35) v7(22.79,73.49) v7(22.79,72.86) v7(22.79,72.22) v7(22.79,71.59) v7(22.92,70.75) v7(22.94,69.99) v7(23.43,73.49) v7(23.43,71.59) v7(23.45,72.86) v7(23.45,72.22)
PLT_RST#: length 398.5
  TOP w0.076: U34.M5 139.67,59.85 139.27,59.85 139.05,59.63 v2(138.86,59.63)
  TOP w0.122: RH171.1 RH168.1 133.36,75.8 133.71,75.44 133.71,74.49 133.55,74.34 133.2,74.34 133.1,74.43 133.1,74.92 132.98,75.04 132.72,75.04 132.6,74.92 132.6,74.54 132.39,74.34 131.24,74.34 130.64,74.94 v1(130.64,75.63) 130.44,75.83 v2(130.44,78.19) 130.63,78.38 133.82,78.38 135.79,76.42 137.09,76.42 137.55,76.88 UH5.4 ; v7(158.27,58.01) 157.89,57.63 R929.2 157.98,57.27 U652.16 161.57,57.27 v7(163.99,54.85) 163.99,54.09 164.4,53.68 v7(164.4,52.59)
  GND1 w0.104: v2(130.44,78.19) v3(130.44,78.63) ; v3(139.42,60.04) 139.26,60.04 v2(138.86,59.63)
  IN1 w0.071: v3(130.44,78.63) v4(129.93,78.63) ; v3(139.42,60.04) 139.31,60.04 139.1,59.82 v4(138.95,59.82) ; v7(126.8,79.62) 126.8,78.93 127.58,78.15 131.94,78.15 133.45,79.66 151.33,79.66 151.81,79.18 v7(154.52,79.18)
  IN2 w0.094: v4(129.93,78.63) 130.55,78 132.28,78 134.55,75.73 135.85,75.73 136.15,75.43 136.15,73.77 136.81,73.11 137.95,73.11 138.08,72.99 138.08,71.78 138.27,71.59 140.94,71.59 141.79,70.74 142.59,70.74 143.36,69.96 147.21,69.96 147.3,69.87 147.3,69.34 147.59,69.05 147.59,68.69 148.08,68.21 150.25,68.21 150.78,67.68 152.84,67.68 153.39,68.22 153.39,68.36 153.21,68.54 153.21,68.67 153.41,68.87 153.54,68.87 153.72,68.69 153.85,68.69 154.41,69.25 154.41,70.7 154.54,70.83 160.14,70.83 160.27,70.95 160.27,71.56 160.14,71.69 154.56,71.69 154.44,71.81 154.44,71.98 154.56,72.1 158.07,72.1 158.2,72.22 158.2,72.96 158.33,73.09 164.59,73.09 164.68,73.18 164.68,73.39 164.57,73.49 158.63,73.49 158.5,73.62 158.5,73.77 158.63,73.9 165.87,73.9 166,74.03 166,74.18 165.87,74.31 158.63,74.31 158.5,74.43 158.5,74.61 158.6,74.71 165.93,74.71 166.05,74.83 166.05,74.99 165.93,75.11 158.6,75.11 158.5,75.2 158.5,75.43 158.6,75.52 165.8,75.52 165.92,75.64 165.92,75.81 165.8,75.93 158.58,75.93 158.38,76.14 158.22,76.14 158.1,76.02 158.1,73.69 157.98,73.57 157.81,73.57 157.69,73.69 157.69,75.98 157.56,76.11 157.41,76.11 157.28,75.98 157.28,73.18 157.16,73.06 157,73.06 156.88,73.18 156.88,75.48 156.76,75.6 156.59,75.6 156.47,75.48 156.47,72.68 156.34,72.56 156.17,72.56 156.06,72.66 156.06,74.67 155.95,74.79 155.79,74.79 155.66,74.66 155.66,73.88 155.53,73.75 154.7,73.75 154.58,73.63 154.58,73.45 154.69,73.34 155.53,73.34 155.66,73.21 155.66,73.04 155.53,72.91 154.06,72.91 153.93,72.78 153.93,70.89 153.04,70 153.04,69.87 153.26,69.64 153.26,69.51 153.06,69.31 152.93,69.31 152.71,69.53 152.57,69.53 152.38,69.34 152.38,69.2 152.6,68.98 152.6,68.85 152.4,68.65 152.27,68.65 152.05,68.86 151.9,68.86 151.66,68.62 148.27,68.62 148.02,68.87 148.02,69.21 147.73,69.49 147.73,70.07 147.43,70.37 147.12,70.37 147.02,70.47 147.02,70.96 146.9,71.08 146.74,71.08 146.62,70.96 146.62,70.47 146.51,70.37 146.31,70.37 146.21,70.47 146.21,70.68 146.11,70.78 145.9,70.78 145.8,70.68 145.8,70.47 145.7,70.37 143.57,70.37 143.47,70.47 143.47,70.68 143.57,70.78 145.09,70.78 145.19,70.88 145.19,71.08 145.09,71.18 142.01,71.18 141.89,71.3 141.89,71.47 142.01,71.59 145.09,71.59 145.19,71.69 145.19,71.89 145.09,72 138.59,72 138.49,72.1 138.49,72.3 138.59,72.4 144.77,72.4 144.89,72.52 144.89,72.69 144.77,72.81 138.59,72.81 138.49,72.91 138.49,73.11 138.59,73.22 144.06,73.22 144.18,73.33 144.18,73.5 144.06,73.62 137.15,73.62 137.01,73.75 137.01,73.92 137.12,74.03 143.25,74.03 143.36,74.15 143.36,74.32 143.25,74.43 142.82,74.43 142.72,74.53 142.72,74.96 142.63,75.06 142.44,75.06 142.35,74.96 142.35,74.53 142.25,74.43 142.07,74.43 141.97,74.53 141.97,74.96 141.88,75.06 141.69,75.06 141.6,74.96 141.6,74.53 141.5,74.43 141.31,74.43 141.22,74.53 141.22,74.96 141.13,75.06 140.94,75.06 140.84,74.96 140.84,74.53 140.75,74.43 140.56,74.43 140.47,74.53 140.47,74.96 140.37,75.06 140.19,75.06 140.09,74.96 140.09,74.53 140,74.43 139.81,74.43 139.72,74.53 139.72,74.96 139.62,75.06 139.43,75.06 139.34,74.96 139.34,74.53 139.25,74.43 139.06,74.43 138.96,74.53 138.96,74.96 138.87,75.06 138.68,75.06 138.59,74.96 138.59,74.53 138.5,74.43 138.31,74.43 138.21,74.53 138.21,74.96 138.12,75.06 136.68,75.06 136.56,75.18 136.56,75.53 136.68,75.65 136.76,75.65 136.86,75.76 136.86,75.91 136.71,76.06 136.47,76.06 136.35,76.18 136.35,77.03 136.2,77.18 134.93,77.18 134.83,77.08 134.83,76.46 134.71,76.34 134.54,76.34 134.42,76.46 134.42,77.08 134.32,77.18 133.84,77.18 133.71,77.3 133.71,77.46 133.84,77.58 135.32,77.58 135.44,77.7 135.44,77.87 135.32,77.99 133.27,77.99 133.15,78.11 133.15,78.28 133.27,78.4 134.51,78.4 134.63,78.52 134.63,78.68 134.51,78.8 131.88,78.8 131.5,78.42 130.92,78.42 130.23,79.11 129.65,79.11 129.55,79.21 129.55,79.7 129.43,79.82 129.26,79.82 129.14,79.7 129.14,78.8 129.04,78.7 128.84,78.7 128.73,78.8 128.73,79.62 128.12,80.23 127.95,80.23 127.82,80.1 127.82,79.51 127.72,79.41 127.52,79.41 127.41,79.51 127.41,80.1 127.29,80.23 126.93,80.23 126.8,80.1 v7(126.8,79.62) ; v7(164.4,52.59) 163.71,51.9 160.67,51.9 158.06,54.51 158.06,54.52 157.35,55.22 146.51,55.22 143.87,57.86 143.87,58.39 142.68,59.58 140.72,59.58 140.23,59.08 139.28,59.08 138.95,59.42 v4(138.95,59.82) ; v7(163.99,54.85) 164.27,55.13 168.28,55.13 168.81,55.66 169.61,55.66 170.23,56.28 173.43,56.28 174.22,55.49 175.41,55.49 177.31,53.58 177.93,53.58 178.83,52.68 178.83,51.89 180.42,50.3 180.42,46 181.2,45.23 181.2,40.47 181.53,40.14 181.53,36.63 181.73,36.42 181.73,36.28 181.86,36.15 JWLAN1.22
  BOTTOM w0.122: v7(126.8,79.62) 126.68,79.5 RC130.1 R1017.1 126.84,78.54 126.94,78.45 UC2.2 127.85,78.45 128,78.3 128,77.92 127.87,77.8 UC2.1 ; v7(154.52,79.18) 154.06,78.72 154.06,75.38 153.74,75.06 153.74,73.81 152.95,73.02 152.95,72.37 154.06,71.27 154.06,70.62 154.5,70.18 154.5,67.3 155.39,66.41 156.08,66.41 156.6,65.9 156.6,60.79 157.88,59.51 157.88,58.41 v7(158.27,58.01)
PM_CLKRUN#: length 72.5
  TOP w0.122: v7(161.11,58) 161.03,57.92 U652.15
  IN4 w0.071: v5(111.06,50.3) 111.53,50.77 112,50.77 112.66,50.11 115.72,50.11 116.38,50.77 118.14,50.77 119.27,49.64 122.44,49.64 123.44,50.65 127.16,50.65 127.66,51.14 129.23,51.14 129.42,50.95 131.19,50.95 132.87,49.26 135.57,49.26 135.78,49.06 145.2,49.06 147.41,46.85 158.74,46.85 v5(158.96,47.07)
  GND5 w0.104: v6(158.96,47.56) v5(158.96,47.07) ; v5(111.06,50.3) v6(111.06,50.74)
  BOTTOM w0.122: v7(161.11,58) 159.82,56.72 159.82,48.43 v6(158.96,47.56) ; UH1.T2 110.5,56.22 110.41,56.14 110.41,53.95 111.12,53.24 111.12,52.74 111.09,52.72 111.09,50.77 v6(111.06,50.74) 111.06,50.43 111.68,49.8 RH248.2
PM_DRAM_PWRGD: length 56
  TOP w0.122: v2(139.5,48.08) RC4.1 139.9,47.5 140.06,47.66 140.06,48.45 140.24,48.63 140.8,48.63 141.05,48.38 UC1.1
  GND1 w0.104: v2(139.5,48.08) v3(139.94,48.08)
  IN1 w0.071: v4(124.59,49.95) 124.59,50.48 125.65,51.53 127.39,51.53 127.67,51.82 128.66,51.82 128.8,51.68 129.02,51.68 129.16,51.82 129.33,51.82 129.41,51.73 129.41,51.23 129.49,51.14 129.66,51.14 129.75,51.23 129.75,51.73 129.83,51.82 130,51.82 130.08,51.73 130.08,51.23 130.16,51.14 130.33,51.14 130.42,51.23 130.42,51.73 130.5,51.82 130.78,51.82 133.4,49.2 140.88,49.2 141,49.07 141,48.83 140.88,48.7 138.51,48.7 138.39,48.58 138.39,48.2 138.51,48.08 v3(139.94,48.08)
  IN4 w0.071: v5(124.31,50.34) 124.59,50.06 v4(124.59,49.95)
  GND5 w0.104: v6(124.59,50.91) 124.59,50.62 v5(124.31,50.34)
  BOTTOM w0.122: UH1.B12 117.75,60.76 117.98,60.52 v1(120.07,60.52) 120.3,60.29 123.22,60.29 123.49,60.02 123.49,59.79 123.07,59.37 123.07,57.44 123.61,56.91 123.72,56.91 124.53,56.1 124.53,55.6 124.05,55.12 123.22,55.12 122.37,54.27 122.37,52.48 122.62,52.24 124.39,52.24 124.53,52.1 124.53,51.89 124.42,51.79 122.63,51.79 122.51,51.66 122.51,51.49 122.63,51.37 124.42,51.37 124.53,51.27 124.53,50.98 v6(124.59,50.91)
PM_PWROK_R: length 10
  TOP w0.122: RH130.2 117.42,60.41 116.29,61.54 116.29,62.14 115.6,62.83 115.25,62.83 114.98,63.09 114.15,63.09 113.13,64.12 v1(112.64,64.12) 112.38,64.12 v2(112.25,64)
  GND1 w0.104: v3(112.25,64.4) v2(112.25,64)
  IN1 w0.071: v4(112.25,63.92) v3(112.25,64.4)
  IN4 w0.071: v5(112.73,64.05) 112.38,64.05 v4(112.25,63.92)
  GND5 w0.104: v5(112.73,64.05) 112.75,64.05 112.75,64.05 v6(112.28,64.05)
  BOTTOM w0.122: v6(112.28,64.05) 112.28,64.5 UH1.M22
PM_SLP_S3#: length 26.7
  TOP w0.122: R249.1 136.3,59.52 v2(135.82,59.52) 135.44,59.91 v1(135.44,59.93)
  GND1 w0.104: v2(135.82,59.52) v3(135.38,59.52)
  IN1 w0.071: v3(135.38,59.52) 135.38,59.16 134.73,58.51 v4(134.3,58.51)
  IN2 w0.094: v4(115.09,57.49) 115.83,58.23 115.83,58.75 116.64,59.56 118.18,59.56 118.42,59.8 120.64,59.8 120.89,59.56 122.59,59.56 123.27,60.25 125.6,60.25 126.13,59.72 128.19,59.72 129.32,58.59 133,58.59 133.31,58.89 133.92,58.89 v4(134.3,58.51)
  IN4 w0.071: v5(115.77,57.54) 115.15,57.54 v4(115.09,57.49)
  GND5 w0.104: v6(115.77,57.13) v5(115.77,57.54)
  BOTTOM w0.305: v6(115.77,57.13) 115.48,57.43 UH1.D4
PM_SLP_S4#: length 34.6
  TOP w0.076: U34.N1 139.42,62.2 138.9,62.72 138.77,62.72 138.42,63.07 138.42,63.08
  TOP w0.122: v2(137.76,64.11) 138.17,63.7 138.17,63.33 v1(138.25,63.25) 138.42,63.08
  GND1 w0.104: v3(137.22,64.2) 137.31,64.11 v2(137.76,64.11)
  IN1 w0.071: v3(137.22,64.2) 136.7,64.71 131.93,64.71 131.55,64.33 131.55,63.98 130.66,63.09 130.08,63.09 128.35,61.37 128.35,60.76 127.96,60.37 127.88,60.37 124.75,57.23 123.71,57.23 123.08,57.85 123.08,58.09 122.68,58.49 121.24,58.49 120.81,58.05 118.86,58.05 118.68,57.87 117.63,57.87 115.6,59.9 114.98,59.9 114.84,60.03 113.85,60.03 v4(113.37,59.55)
  IN4 w0.071: v4(113.37,59.55) 113.15,59.76 v5(112.92,59.76)
  GND5 w0.104: v6(113.14,60.14) 113.14,59.99 v5(112.92,59.76)
  BOTTOM w0.122: v6(113.14,60.14) 113.19,60.09 UH1.K10
PM_SLP_S5#: length 27.6
  TOP w0.122: R250.1 135.92,56.77 v2(135.78,56.62)
  GND1 w0.104: v3(135.78,57.21) v2(135.78,56.62)
  IN1 w0.071: v3(135.78,57.21) 134.99,57.21 v4(133.71,58.48)
  IN2 w0.094: v4(114.23,58) 114.23,57.62 114.76,57.09 115.34,57.09 117.48,59.23 118.24,59.23 118.62,59.61 120.56,59.61 120.94,59.23 122.78,59.23 123.53,59.98 125.06,59.98 125.52,59.52 128.11,59.52 129.29,58.34 133.57,58.34 v4(133.71,58.48)
  IN4 w0.071: v5(114.54,57.62) 114.23,57.93 v4(114.23,58)
  GND5 w0.104: v6(114.97,57.54) 114.89,57.62 v5(114.54,57.62)
  BOTTOM w0.305: UH1.F6 114.97,57.91 v6(114.97,57.54)
PM_SLP_SUS#: length 22.8
  TOP w0.122: v2(144.42,60.06) 144.42,59.72 144.73,59.41 144.73,59.3 U34.B7 ; v7(134.98,50.94) 134.63,51.3 134.63,51.42 v9(134.38,51.67) 133.61,52.44 133.61,52.9 133.15,53.35 R290.1 RH313.1 132.88,54.35 132.57,54.04 132.57,53.53 132.45,53.41 Q32.2
  GND1 w0.104: v3(143.98,60.01) 144.03,60.06 v2(144.42,60.06)
  IN1 w0.071: v7(134.98,50.94) 135.85,50.94 138.93,54.01 138.93,56.11 139.43,56.62 139.43,57.02 139.78,57.38 139.78,58.68 140.02,58.92 140.34,58.92 140.71,59.28 141.19,59.28 141.36,59.45 141.78,59.45 141.97,59.64 142.17,59.64 142.44,59.91 142.79,59.91 143.05,60.16 143.82,60.16 v3(143.98,60.01)
POK: length 106.3
  TOP w0.122: RH309.1 127.9,65.47 v2(127.72,65.65) 128.16,66.09 PR905.1 ; PR911.1 182.35,79.36 PR910.1 182.25,80.08 182.7,80.52 v1(182.7,81.23) 183.34,81.88 183.87,81.88 v7(184.21,81.53)
  GND1 w0.104: v2(127.72,65.65) 127.31,65.65 v3(127.24,65.72)
  IN1 w0.071: v4(142.65,69.18) 138.84,69.18 137.9,68.24 131.26,68.24 129.68,66.66 128.18,66.66 v3(127.24,65.72)
  IN1 w0.254: v7(185.97,57.28) 185.97,65.91 187.71,67.65 187.71,71.92 188.39,72.59 v7(188.81,72.59)
  IN2 w0.094: v4(142.65,69.18) 143.17,69.18 143.97,68.38 145.85,68.38 146.22,68 147.15,68 147.74,67.42 149.92,67.42 150.45,66.89 153.17,66.89 154.36,68.08 156.93,68.08 157.5,67.51 159.84,67.51 160.33,68.01 164.71,68.01 165.12,68.42 165.12,71 165.44,71.33 166.11,71.33 168.51,73.72 168.51,74.4 173.78,79.68 182.77,79.68 184.21,81.11 v7(184.21,81.53)
  BOTTOM w0.254: v7(188.81,72.59) 188.81,72.89 186.84,74.85 186.84,79.59 184.89,81.53 v7(184.21,81.53) ; v7(185.97,57.28) 186.14,57.11 189.21,57.11 PR516.1
PP: length 3.5
  TOP w0.122: U652.7 166.55,53.37 167.4,54.22 R975.1 168.59,54.22 v1(168.76,54.39)
PRESSURE_INT#: length 34.5
  TOP w0.076: 159.85,61.81 159.85,61.89 159.55,62.19 U636.D1
  TOP w0.122: 159.85,61.81 159.85,61.66 v2(159.89,61.62) ; v2(152.37,64.83) 152.41,64.8 T250.1
  GND1 w0.104: v2(152.37,64.83) 152.37,65.24 v3(152.41,65.28) ; v3(159.4,61.62) v2(159.89,61.62)
  IN1 w0.071: v4(135.9,69.51) 136.56,69.51 136.66,69.41 142.25,69.41 142.4,69.56 146.72,69.56 147.69,68.59 149.09,68.59 v3(152.41,65.28) 152.58,65.28 153.08,64.79 153.08,64.3 155.38,62 158.31,62 158.47,61.85 158.99,61.85 159.21,61.62 v3(159.4,61.62)
  IN4 w0.071: v5(135.39,69.51) v4(135.9,69.51)
  GND5 w0.104: v6(135.39,69.94) v5(135.39,69.51)
  BOTTOM w0.122: v6(135.39,69.94) 135.39,70 137.41,72.02 137.41,73.08 v1(137.34,73.14)
PS_ID: length 77.1
  TOP w0.076: v2(140.58,59.37) 140.81,59.6 U34.K6
  TOP w0.122: v7(196.73,82.12) 196.73,81.72 196.36,81.36 PR902.2 196.77,80.75 197.11,81.09 PR901.1 197.31,80.37 v1(197.75,79.93) ; PD901.1 186.67,81.8 v7(186.27,82.21)
  GND1 w0.104: v2(140.58,59.37) 140.61,59.37 v3(140.99,59.75)
  IN1 w0.071: v3(140.99,59.75) 141.04,59.8 141.57,59.8 141.76,59.99 142.01,59.99 142.53,60.52 144.74,60.52 145.02,60.79 145.02,61.89 145.21,62.08 145.45,62.08 145.82,61.71 147.28,61.71 149.28,63.72 v4(149.54,63.72)
  IN2 w0.094: v4(149.54,63.72) 149.91,63.72 150.31,63.31 155.72,63.31 156.04,63.63 157.32,63.63 157.88,64.19 158.61,64.19 158.94,63.86 161.99,63.86 162.83,64.7 163.61,64.7 164.19,64.13 165.73,64.13 166.64,65.03 166.64,67.72 167.22,68.3 167.22,70.5 168.26,71.54 170.35,71.54 173.35,74.54 180.25,74.54 180.52,74.82 180.52,75.3 185.68,80.45 185.68,81.62 v7(186.27,82.21) 190,82.21 190.27,81.94 196.55,81.94 v7(196.73,82.12)
PSID: length 5.6
  TOP w0.122: PL901.2 192.82,83.73 v7(193.06,83.49)
  BOTTOM w0.122: v7(193.06,83.49) 192.73,83.16 JDCIN1.1 189.88,83.16 v1(188.95,84.1)
PSID-1: length 18.6
  TOP w0.122: PQ901.2 189.12,83.05 v7(188.76,83.4) ; v1(197.76,78.51) 197.24,79.03 196.27,79.03 v7(195.74,79.57) 195.46,79.29 194.7,79.29 PR906.2 PR903.1
  IN1 w0.071: v7(193.5,84.01) 193.48,83.99 192.79,83.99 192.51,83.71 189.07,83.71 v7(188.76,83.4)
  BOTTOM w0.122: v7(195.74,79.57) 195.45,79.86 195.45,81.48 193.5,83.43 v7(193.5,84.01)
PSID-2: length 7.6
  TOP w0.122: PQ900.2 193.91,83.53 194.04,83.65 194.04,84.37 193.61,84.8 v1(192.35,84.8) 191.82,84.26 191.31,84.26 190.66,83.62 PR904.1 190.49,83.22 PQ901.1
PSID-3: length 2.8
  TOP w0.122: PR900.2 PR902.1 195.45,81.23 195.84,81.62 PQ900.3
PWM3: length 4.2
  BOTTOM w0.122: PR721.2 24.92,75.63 v1(24.92,74.13)
  BOTTOM w0.254: PR721.2 24.44,76.67 24.17,76.94 PU700.24
PWMG2: length 4
  TOP w0.122: PR716.2 18.68,78.85 v1(18.83,78.7)
  TOP w0.254: v7(20.07,80.68) 19.98,80.58 19.72,80.58 18.85,79.72 PR716.2
  BOTTOM w0.254: v7(20.07,80.68) 20.2,80.68 20.54,80.35 PU700.35
PWR_SRC_ON: length 4.1
  TOP w0.122: R536.1 163.85,84.32 C613.2 R535.2 164.9,83.23 164.55,82.88 Q70.3
PWRSHARE_EN#: length 11.2
  TOP w0.122: v2(205.54,55) 205.99,55.45 v1(206.08,55.45) 206.09,55.44 R807.1 ; UI1.1 v2(213.19,52.51)
  GND1 w0.104: v2(205.54,55) v3(205.54,54.57) ; v3(212.73,52.51) v2(213.19,52.51)
  IN1 w0.071: v3(212.73,52.51) 207.6,52.51 v3(205.54,54.57)
PWRSHARE_EN_EC#: length 118.3
  TOP w0.122: U34.E7 143.26,59.1 v2(143.07,58.92) ; R806.2 R807.2 206.73,54.08 206.73,55.37 207.11,55.76 v1(207.83,55.76) U656.4 210.2,55.76 v7(210.67,55.28)
  GND1 w0.104: v2(143.07,58.92) 142.68,58.92 v3(142.64,58.96)
  IN1 w0.071: v4(151.01,60.69) 150.07,59.75 149.08,59.75 148.91,59.59 148.4,59.59 147.78,58.97 146.87,58.97 146.77,59.06 146.22,59.06 146.07,59.21 145.6,59.21 145.53,59.14 145.1,59.14 144.8,59.45 143.13,59.45 v3(142.64,58.96)
  IN2 w0.094: v7(210.67,55.28) 210.67,56.07 210.14,56.6 210.14,61.71 215.73,67.3 215.73,69.25 210.57,74.42 210.57,74.94 209.29,76.22 201.76,76.22 199.47,78.51 198.04,78.51 196.47,80.08 190.59,80.08 187.07,76.56 187.07,75.52 182.42,70.88 181.11,70.88 180.32,70.09 179.66,70.09 176.29,66.72 176.29,62.54 174.67,60.92 170.9,60.92 170.67,60.69 166.63,60.69 165.96,61.36 164.29,61.36 163.06,60.13 156.83,60.13 155.52,61.44 155.15,61.44 155.14,61.44 153.73,61.44 152.02,59.73 150.87,59.73 150.65,59.94 150.65,60.34 v4(151.01,60.69)
PWRSHARE_OE#: length 111.1
  TOP w0.076: U34.E6 143.16,59.6 v2(143.03,59.73)
  TOP w0.122: v2(207.31,53.42) 208.19,52.54 v1(209.77,52.54) 210.17,52.93 UI1.8
  GND1 w0.104: v2(207.31,53.42) v3(207.31,53.86) ; v3(143.61,59.83) 143.14,59.83 v2(143.03,59.73)
  IN1 w0.071: v4(149.49,60.87) 148.04,60.87 147.72,60.55 146.83,60.55 146.66,60.38 145.85,60.38 145.54,60.07 144.46,60.07 144.1,59.72 143.72,59.72 v3(143.61,59.83) ; v4(208.64,56.12) 207.82,56.12 207.31,55.61 v3(207.31,53.86)
  IN2 w0.094: v4(149.49,60.87) 149.49,60.83 150.79,59.52 152.09,59.52 153.81,61.24 155.44,61.24 156.75,59.93 164.53,59.93 164.66,59.81 167.6,59.81 168.25,60.46 171.1,60.46 171.36,60.73 174.77,60.73 176.49,62.45 176.49,66.64 179.59,69.75 180.3,69.75 181.23,70.68 182.5,70.68 187.67,75.84 187.78,75.84 188.07,76.13 188.07,77.28 190.67,79.88 194.26,79.88 195.05,79.09 197.13,79.09 197.91,78.31 199.39,78.31 201.67,76.02 209.1,76.02 210.19,74.93 210.19,70.97 209.91,70.69 209.91,57.8 208.64,56.53 v4(208.64,56.12)
RBIAS_CPY: length 3.8
  BOTTOM w0.122: RH125.2 93.15,64.01 v1(94.39,64.01) UH1.BK20
RBIAS_SATA3: length 4.7
  TOP w0.122: RH48.1 104.91,54.95 105.18,55.22 105.18,55.69 104.91,55.96 v1(104.91,56.06) 104.96,56.11 104.96,56.43 v2(105.21,56.68)
  GND1 w0.104: v3(105.62,56.68) v2(105.21,56.68)
  IN1 w0.071: v4(106.15,56.68) v3(105.62,56.68)
  IN4 w0.071: v4(106.15,56.68) 105.69,56.68 v5(105.62,56.6)
  GND5 w0.104: v6(105.62,57.01) v5(105.62,56.6)
  BOTTOM w0.122: UH1.AH4 v6(105.62,57.01)
RESET#: length 6.9
  TOP w0.076: U636.C7 158.8,65.57 158.8,65.93 158.82,65.95 158.82,66.14
  TOP w0.122: 158.82,66.14 158.82,66.43 v2(158.92,66.54) ; R1089.1 154.31,66.22 R1090.1 v1(155.87,66.22) 157,66.22 v2(157.13,66.36)
  GND1 w0.104: v3(157.56,66.36) v2(157.13,66.36) ; v2(158.92,66.54) 158.92,66.46 v3(158.63,66.17)
  IN1 w0.071: v3(157.56,66.36) 157.75,66.17 v3(158.63,66.17)
RF_+V1.05S_VCCPP: length 2.7
  TOP w0.254: PR505.1 122.61,48.98 v1(122.85,48.74) 123.68,47.92 PU500.5
RFSW_IN: length 4
  BOTTOM w0.122: JANT2.2 161.13,24.75 v1(161.26,24.88) 161.26,25.59 CRF2.1
RFSW_IN_C: length 2.2
  BOTTOM w0.122: v1(158.87,25.95) 158.99,26.06 CRF2.2 160.14,26.33 URF1.5
RFSW_OUT1: length 7.9
  BOTTOM w0.122: v1(166.07,26.72) 165.12,25.77 JANT1.2 164.69,26.92 163.58,28.03 163.58,28.3 163.15,28.73 161.17,28.73 CRF1.2
RFSW_OUT1_C: length 2.6
  BOTTOM w0.122: URF1.1 159.79,28.28 159.87,28.37 CRF1.1 159.87,29.39 159.99,29.5 159.99,30.18 v1(160.27,30.45)
RFSW_OUT2: length 2.8
  BOTTOM w0.122: JANT3.2 152.21,24.24 v1(152.21,25.03) CRF3.2
RFSW_OUT2_C: length 8.7
  GND5 w0.104: v6(160.27,28.54) v6(159.51,28.54)
  BOTTOM w0.122: v6(160.27,28.54) 160.49,28.31 URF1.3 ; v6(159.51,28.54) 157.47,28.54 156.61,27.67 156.61,26.12 v1(156.02,25.53) 155.52,25.03 CRF3.1
RFSW_VCONT1: length 113.5
  IN4 w0.071: v7(155.82,23.34) 169.59,23.34 171.33,25.08 171.33,27.91 173.76,30.34 173.76,39.05 173.35,39.46 173.35,41.95 171.52,43.77 171.35,43.77 168.09,47.02 167.55,47.56 158.62,47.56 158.26,47.2 147.55,47.2 145.34,49.41 135.92,49.41 135.71,49.61 133.04,49.61 131.36,51.3 129.57,51.3 129.38,51.49 127.51,51.49 127.03,51 123.28,51 122.27,49.99 119.42,49.99 118.22,51.19 v5(110.17,51.19)
  GND5 w0.104: v5(110.17,51.19) 110.17,52.33 v6(110.12,52.38)
  BOTTOM w0.122: RRF1.2 157.23,27.94 156.86,27.58 156.86,25.46 155.82,24.42 v7(155.82,23.34) ; v6(110.12,52.38) 110.01,52.49 v1(110.01,53.33) 110.01,55.33 110.09,55.41 UH1.U1
RFSW_VCONT2: length 121.3
  IN4 w0.071: v7(161.87,23.81) 161.87,23.78 162.12,23.53 169.51,23.53 171.14,25.16 171.14,27.98 173.58,30.42 173.58,38.98 173.17,39.39 173.17,41.87 171.45,43.6 171.28,43.6 167.92,46.95 167.48,47.39 158.7,47.39 158.33,47.02 147.48,47.02 145.27,49.23 135.85,49.23 135.64,49.44 132.97,49.44 131.29,51.13 129.49,51.13 129.3,51.32 127.58,51.32 127.1,50.83 123.36,50.83 122.35,49.82 119.35,49.82 118.16,51.02 110.4,51.02 110.29,50.9 110.04,50.9 109.74,51.2 105.58,51.2 105.44,51.35 103.56,51.35 101.99,52.92 v5(101.42,52.92)
  GND5 w0.104: v6(101.85,52.92) v5(101.42,52.92)
  BOTTOM w0.122: v7(161.87,23.81) 161.87,25.08 163.33,26.55 163.33,28.19 163.05,28.48 162.17,28.48 RRF2.2 ; v6(101.85,52.92) 102.55,53.62 103.18,53.62 103.83,54.27 v1(104.54,54.27) 104.74,54.27 106.24,55.77 107.78,55.77 108.15,56.13 UH1.AA1
RI#: length 5.9
  TOP w0.122: v2(115.87,60.15) 115.96,60.15 116.86,59.24 116.86,58.64 117.18,58.32 117.18,58.18 117.64,57.72 RH145.1
  GND1 w0.104: v3(115.6,60.57) 115.6,60.41 v2(115.87,60.15)
  IN1 w0.071: v4(115.12,60.57) v3(115.6,60.57)
  IN4 w0.071: v4(115.12,60.57) 115.49,60.57 v5(115.61,60.45)
  GND5 w0.104: v5(115.61,60.45) 115.24,60.45 v6(115.2,60.41)
  BOTTOM w0.122: UH1.F12 114.95,60.66 v6(115.2,60.41)
ROTATION_LOCK_SW#: length 176
  TOP w0.122: v7(21.97,25.81) 21.43,25.27 20.87,25.27 20.8,25.35 19.67,25.35 19.38,25.06 R957.2 C1125.1 ; v1(122.83,60.41) RH324.1 123.48,60.85 v2(123.4,60.85)
  GND1 w0.104: v3(123.81,61.12) 123.53,60.85 v2(123.4,60.85)
  IN1 w0.071: v3(123.81,61.12) 124.12,61.43 v4(124.29,61.43) ; v4(71.07,21.54) 72.39,21.54 73.71,22.87 103.03,22.87 104.68,24.51 108.3,24.51 113.06,29.27 113.06,31.26 114.42,32.63 114.42,34.66 113.16,35.92 113.16,43.08 111.72,44.53 107.87,44.53 107.09,45.3 107.09,47.38 105.47,49.01 103.78,49.01 v4(101.54,51.24)
  IN2 w0.094: v4(124.29,61.43) 124,61.14 118.49,61.14 117.58,60.24 v4(116.95,60.24) ; v4(71.07,21.54) 70.61,21.08 63.65,21.08 62.23,22.49 62.23,25.62 59.99,27.86 51.01,27.86 48.08,30.8 43.95,30.8 39.5,26.34 34.88,26.34 34.25,25.71 32.17,25.71 31.86,26.02 22.18,26.02 v7(21.97,25.81)
  IN3 w0.094: v4(101.54,51.24) 102.48,52.18 105.23,52.18 106.4,53.35 106.4,56.36 106.59,56.56 106.59,57.66 107.4,58.46 108.15,58.46 109.14,59.45 109.14,59.92 109.53,60.31 111.11,60.31 111.56,59.86 112.91,59.86 113.24,60.19 116.9,60.19 v4(116.95,60.24)
  IN4 w0.071: v4(116.95,60.24) 116.95,60.74 116.12,61.57 114.96,61.57 v5(113.99,62.55)
  GND5 w0.104: v6(113.99,62.08) v5(113.99,62.55)
  BOTTOM w0.122: UH1.H15 v6(113.99,62.08)
ROTATION_LOCK_SW#_C: length 8
  TOP w0.122: v7(21.34,20.91) 22.5,22.07 22.5,24.85 22.13,25.22 v1(21.98,25.22) 21.64,24.88 R957.1
  BOTTOM w0.122: v7(21.34,20.91) 21.6,20.66 JIOL1.31
RUN_ON_CPU1.5VS3: length 7.8
  BOTTOM w0.381: CC139.1 RC105.1 RC101.2 ; CC139.1 v9(76.26,50.14) 74.79,50.14 74.17,50.76 QC3.4 ; CC139.1 QC4.3
RUN_ON_CPU1.5VS3#: length 97.6
  TOP w0.122: v2(92.77,54.29) 92.76,54.29 90.81,52.35 88.9,52.35 83.21,46.66 80.16,46.66 79.97,46.47 v7(79.94,46.47) v1(78.92,46.47) 61.13,46.47 60.17,47.43 v7(60.03,47.43) ; v2(141.76,50.84) 141.88,50.95 QC1.2
  GND1 w0.104: v2(141.76,50.84) v3(141.76,50.41) ; v3(92.89,53.86) 92.89,54.17 v2(92.77,54.29)
  IN1 w0.071: v3(92.89,53.86) 92.89,53.68 93.67,52.9 95.98,52.9 96.36,53.29 101.81,53.29 102.15,52.95 102.84,52.95 103.15,52.64 105.87,52.64 106.82,51.68 111.03,51.68 111.4,51.31 113.71,51.31 113.93,51.52 124.85,51.52 125.6,52.27 125.84,52.27 126.3,52.73 131.15,52.73 133.65,50.23 141.59,50.23 v3(141.76,50.41)
  BOTTOM w0.122: Q38.2 61.66,49.78 60.03,48.15 v7(60.03,47.43) 60.1,47.36 Q37.2 ; RC102.2 79.69,46.22 v7(79.94,46.47) 79.68,46.73 QC4.6 QC4.5
S3_1.35V: length 6.5
  TOP w0.254: PU300.7 28.98,22.37 v7(28.84,22.52) 28.84,22.62 28.28,23.18 PR308.2
  BOTTOM w0.122: v7(28.84,22.52) 30.03,22.52 v1(30.13,22.62)
  BOTTOM w0.254: PR323.2 28.3,24.04 28.84,23.51 v7(28.84,22.52) ; v1(30.13,22.62) 29.51,23.24 PC1910.1
S5_1.35V: length 3.6
  TOP w0.254: PU300.8 29.05,21.97 v7(28.85,21.77)
  BOTTOM w0.122: v7(28.85,21.77) 29.14,21.48 v1(29.47,21.48)
  BOTTOM w0.254: v7(28.85,21.77) 28.72,21.77 PR306.2 PC313.1
SA_PGOOD: length 39.6
  TOP w0.122: R931.2 145.73,69.35 v1(146.16,69.79) 146.16,70.83 v7(145.73,71.26) ; v7(117.3,82.51) 116.8,82 PR611.1
  IN2 w0.094: v4(125.36,80.86) 125.56,80.66 128.58,80.66 129,80.24 129.94,80.24 130.87,79.31 131.58,79.31 131.68,79.21 134.75,79.21 138.33,75.63 142.64,75.63 145.73,72.55 v7(145.73,71.26)
  IN4 w0.071: v4(125.36,80.86) 124.62,81.6 120.71,81.6 119.84,82.46 117.36,82.46 v7(117.3,82.51)
SATA3_COMP: length 14.4
  TOP w0.254: v7(104.68,55.55) 104.02,54.89 RH43.1
  IN3 w0.254: v7(104.68,55.55) 104.68,56.14 107.28,58.74 108.04,58.74 108.77,59.47 108.77,59.96 108.16,60.57 v4(107.25,60.57)
  IN4 w0.254: v5(106.84,60.16) v4(107.25,60.57)
  GND5 w0.254: v6(106.43,60.16) v5(106.84,60.16)
  BOTTOM w0.127: v1(102.32,54.17) 102.99,54.17 103.7,54.88 104.3,54.88 104.68,55.26 v7(104.68,55.55)
  BOTTOM w0.254: UH1.AF10 v6(106.43,60.16) UH1.AF12
SATA_COMP: length 3.4
  TOP w0.254: RH41.1 108.97,59.81 v2(109.05,59.73)
  GND1 w0.254: v2(109.05,59.73) 109.05,59.77 108.76,60.06 v3(108.74,60.06)
  IN1 w0.254: v3(108.74,60.06) 108.87,60.19 v4(108.87,60.57)
  IN4 w0.254: v5(108.39,60.59) 108.8,60.59 108.85,60.54 v4(108.87,60.57)
  GND5 w0.254: v6(108.36,60.16) 108.39,60.19 v5(108.39,60.59)
  BOTTOM w0.254: UH1.AB12 v6(108.36,60.16) UH1.AB10
