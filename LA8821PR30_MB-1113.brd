# Allegro board LA8821PR30_MB-1113.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCSST: length 3
  TOP w0.254: CH78.1 v2(110.46,62.93)
  GND1 w0.254: v2(110.46,62.93) v3(110.46,62.5)
  IN1 w0.254: v3(110.46,62.5) 110.07,62.5 v4(109.89,62.67)
  IN4 w0.254: v5(110.39,62.67) v4(109.89,62.67)
  GND5 w0.254: v6(110.39,63.08) v5(110.39,62.67)
  BOTTOM w0.254: UH1.U17 v6(110.39,63.08)
+VCCSUS1: length 3.1
  TOP w0.254: CH54.1 v2(110.27,60.57)
  GND1 w0.254: v2(110.27,60.57) v3(109.84,60.57)
  IN1 w0.254: v4(109.3,60.97) 109.7,60.57 v3(109.84,60.57)
  IN4 w0.254: v4(109.3,60.97) 109.71,60.97 v5(109.79,61.05)
  GND5 w0.254: v5(109.79,61.05) 109.79,61.2 v6(109.58,61.4)
  BOTTOM w0.254: v6(109.58,61.4) 109.81,61.18 UH1.V13
+VCCSUSHDA: length 6
  TOP w0.122: CH85.1 108.43,69.65 v1(108.01,69.23)
  TOP w0.254: CH85.1 109.44,69.65 v2(109.66,69.43) 109.71,69.38 111.03,69.38 RH244.2
  GND1 w0.254: v2(109.66,69.43) v3(109.66,69.84)
  IN1 w0.254: v3(109.66,69.84) v4(109.66,69.35)
  IN4 w0.254: v5(109.96,68.6) 109.96,68.6 109.73,68.83 109.73,69.28 v4(109.66,69.35)
  GND5 w0.254: v5(109.96,68.6) 109.96,68.6 109.73,68.83 v6(109.73,68.95)
  BOTTOM w0.254: UH1.V31 v6(109.73,68.95)
GND: length 1455.9
  TOP w0.076: v2(142.71,62.82) 142.71,62.24 142.67,62.21 142.67,61.71 142.56,61.6 U34.G2 142.3,61.6 142.17,61.74 142.17,62.41 v2(142.2,62.44) ; v2(161.89,64.13) 161.83,64.07 160.94,64.07 160.69,64.32 U636.F5 160.55,64.19 160.8,63.94 160.8,63.72 160.94,63.57 161.65,63.57 161.78,63.7 v2(161.92,63.7) ; v2(159.84,66.59) 159.8,66.55 159.8,65.53 160.01,65.32 U636.E7 160.09,65.32 160.3,65.52 160.3,66.12 v2(160.33,66.15)
  TOP w0.122: U637.10 153.09,48.59 153.27,48.42 v2(153.66,48.42) 153.89,48.64 U637.11 ; v2(150.76,54.98) 150.76,52.4 150.93,52.23 U637.7 ; U638.4 v2(139.03,75.41) ; C1188.2 149.46,30.26 149.92,30.72 149.92,30.9 C1187.2
  TOP w0.127: U638.13 142.64,79.47 142.88,79.72 144.61,79.72 144.89,79.44 144.89,76.8 v7(144.81,76.72) ; 144.79,76.06 U638.10 ; 144.79,76.06 v7(144.81,76.09) 144.99,75.91 144.99,75.04 143.52,73.57 142.88,73.57 142.64,73.82 U638.8 ; 144.79,76.06 144.14,75.41 U638.9 ; U638.11 144.81,76.71 v7(144.81,76.72) ; v7(144.81,76.72) 144.17,77.36 U638.12
  TOP w0.203: v7(168.46,26.38) 169.3,27.22 JKB1.30 ; v2(157.66,65.46) 157.91,65.46 U636.A7 ; v2(158.05,61.87) 158.11,61.87 158.55,62.31 U636.B1 ; PU300.1 32.17,24.2 v7(32.29,24.32) ; PU300.3 PU300.21
  TOP w0.254: v10(42.81,36.01) 42.97,35.85 v10(43.64,35.85) 43.95,35.85 UD12.D1 ; v2(67.62,77.66) 67.65,77.64 67.65,77.58 67.75,77.48 PC1239.2 ; v10(71.12,25) 70.72,25.39 UD8.L1 ; v10(44.57,30.08) 44.18,30.47 UD12.L1 ; v2(112.18,60.59) 112.58,60.98 CH83.2 ; v10(55.62,38.1) 55.22,37.7 UD10.B1 ; v10(55.62,38.1) 56.02,37.7 UD10.B2 ; v10(55.62,38.1) 55.24,38.48 UD10.A1 ; v10(82.17,33.02) 82.57,32.62 UD6.B2 ; v10(82.17,33.02) 81.79,33.4 UD6.A1 ; v10(82.17,33.02) 81.77,32.62 UD6.B1 ; PU300.14 31.77,19.81 31.76,19.8 31.76,19.11 v7(31.58,18.94) ; UD12.B1 44.18,37.7 v10(44.57,38.1) ; UD4.B8 98.42,32.63 v10(98.05,33) ; UD2.J1 103.48,27.38 v10(103.48,27.38) ; UD16.B8 27.68,37.69 v10(27.31,38.05) ; UD8.D1 70.39,31 v10(70.16,30.77) v10(69.55,30.77) ; UD10.D9 62.29,36.08 62.31,36.11 62.31,36.13 v7(62.34,36.16) ; UD10.D9 UD10.C9 ; UD10.D9 UD10.D8 ; v10(28.9,28.43) 28.48,28.85 UD16.N9 ; UD14.L9 39.53,30.48 v10(39.93,30.08) ; v10(40.51,30.89) 40.51,31.09 UD14.J9 ; v2(58.55,82.31) 58.1,81.85 RC34.2 ; C1118.2 151.57,59.78 v2(151.44,59.65) ; UD14.A1 33.14,38.48 v10(33.52,38.1) ; v10(62.61,30.89) 62.61,31.09 UD10.J9 ; UD4.B7 97.65,32.6 v10(98.05,33) ; v10(109.1,33) 109.47,33.36 UD2.A8 ; v10(109.1,33) 108.7,32.6 UD2.B7 ; v10(109.1,33) 109.47,32.63 UD2.B8 ; RH34.1 124.78,65 RH159.2 ; v10(77.54,23.35) 77.12,23.77 UD8.N9 ; UD4.N9 99.22,23.77 v10(99.64,23.35) ; v2(105.34,53.17) 105.34,53.23 104.91,53.66 RH48.2 ; v10(22.44,31.66) 22.44,31.74 22.09,32.08 22.09,32.09 UD16.J1 ; v2(110.28,59.97) 110.66,59.59 CH48.2 ; v10(104.26,33.02) 103.88,33.4 UD2.A1 ; v10(104.26,33.02) 103.87,32.62 UD2.B1 ; v10(104.26,33.02) 104.67,32.62 UD2.B2 ; v10(38.36,38.08) 37.96,37.68 UD14.B7 ; v10(38.36,38.08) 38.73,37.71 UD14.B8 ; v10(38.36,38.08) 38.73,38.44 UD14.A8 ; RC144.2 v2(58.99,73.75) ; UD8.J1 70.34,27.38 v10(70.33,27.38) ; v10(93.21,33.02) 92.83,33.4 UD4.A1 ; v10(93.21,33.02) 93.62,32.62 UD4.B2 ; v10(93.21,33.02) 92.82,32.62 UD4.B1 ; v10(54.83,29.28) 55.22,28.88 UD10.N1 ; v10(78.11,25.81) 78.11,26.01 UD8.J9 ; v10(60.48,38.08) 60.82,38.42 UD10.A8 ; v10(60.48,38.08) 60.82,37.74 UD10.B8 ; v10(60.48,38.08) 60.09,37.68 UD10.B7 ; v10(44.57,38.1) 44.19,38.48 UD12.A1 ; v10(44.57,38.1) 44.98,37.7 UD12.B2 ; UD4.J1 92.43,27.38 v10(92.43,27.38) ; UD14.B2 33.93,37.7 v10(33.52,38.1) ; RH46.2 105.8,53.39 106.01,53.17 v2(106.23,53.17) ; v10(93.21,25) 92.82,25.39 UD4.L1 ; UD12.N1 v10(43.78,29.28) ; UD2.L1 103.87,25.39 v10(104.26,25) ; UD10.J1 54.84,32.46 v10(54.84,32.46) ; UD6.L1 81.77,25.39 v10(82.17,25) ; v7(93.55,62.81) 93.51,62.77 RC138.2 ; v10(51.56,30.89) 51.56,31.09 UD12.J9 ; UD6.L9 UD5.L1 v10(88.57,25) ; v10(32.74,32.46) 32.74,32.46 UD14.J1 ; UD8.B7 75.56,32.6 v10(75.95,33) ; UD14.N9 39.53,28.85 v10(39.95,28.43) ; UD14.N1 33.13,28.88 v10(32.73,29.28) ; v10(111.25,25.81) 111.25,26.01 UD2.J9 ; U34.N13 139.42,55.9 139.22,55.7 139.22,55.54 v2(138.83,55.14) ; UD10.D1 55,35.85 v10(54.67,35.85) 54.14,35.85 v10(54.09,35.8) ; UD12.A8 49.78,38.44 v10(49.41,38.08) ; v2(112.13,61.57) 112.13,61.57 111.69,61.13 CH84.2 ; v10(99.62,25) 99.22,25.4 UD4.L9 ; CH75.2 108.46,62.7 v2(108.08,62.32) ; v10(70.32,24.2) 70.72,23.8 UD8.N1 ; UD16.N1 v10(21.68,29.28) ; UD10.L1 55.22,30.47 v10(55.62,30.08) ; UD2.N1 v10(103.47,24.2) ; UD6.B8 87.37,32.63 v10(87,33) ; v10(102.73,30.72) 102.78,30.77 v10(103.31,30.77) 103.64,30.77 UD2.D1 ; v10(22.48,38.1) 22.88,37.7 UD16.B2 ; v10(22.48,38.1) 22.1,38.48 UD16.A1 ; v10(22.48,38.1) 22.08,37.7 UD16.B1 ; U636.H3 162.16,63.32 v7(162.48,63.64) ; UD6.N9 88.17,23.77 v10(88.59,23.35) ; v10(29.47,30.89) 29.47,31.09 UD16.J9 ; UD4.N1 92.82,23.8 v10(92.42,24.2) ; v10(49.41,38.08) 49.78,37.71 UD12.B8 ; v10(49.41,38.08) 49.01,37.68 UD12.B7 ; v10(43.79,32.46) 43.79,32.46 UD12.J1 ; UD16.D1 21.85,35.85 v10(21.52,35.85) 20.99,35.85 v10(20.94,35.8) ; v10(62.05,28.43) 61.62,28.85 UD10.N9 ; v10(98.05,33) 98.42,33.36 UD4.A8 ; UD8.B8 76.32,32.63 v10(75.95,33) ; UD10.F2 56.01,34.49 56.01,34.51 v10(55.63,34.89) ; v10(87,33) 86.61,32.6 UD6.B7 ; v10(87,33) 87.37,33.36 UD6.A8 ; UD16.A8 27.68,38.42 v10(27.31,38.05) ; RC77.2 49.96,51.47 50.42,51.92 50.42,51.93 50.83,52.34 CC69.2 ; v10(33.52,38.1) 33.13,37.7 UD14.B1 ; v10(28.88,30.08) UD15.L1 UD16.L9 ; v10(27.31,38.05) 26.94,37.68 UD16.B7 ; v10(81.38,27.38) 81.38,27.38 UD6.J1 ; v10(77.52,25) 77.12,25.4 UD8.L9 ; v10(75.95,33) 76.32,33.36 UD8.A8 ; U636.H2 161.97,62.82 v2(161.97,62.81) ; v10(71.12,33.02) 70.74,33.4 UD8.A1 ; v10(71.12,33.02) 70.72,32.62 UD8.B1 ; v10(71.12,33.02) 71.52,32.62 UD8.B2 ; v10(50.98,30.08) UD11.L1 UD12.L9 ; v10(80.63,30.72) 80.68,30.77 v10(81.21,30.77) 81.54,30.77 UD6.D1 ; v10(91.45,30.93) 91.54,30.93 91.7,30.77 v10(92.29,30.77) 92.31,30.8 92.61,30.8 UD4.D1 ; UD2.N9 110.27,23.77 v10(110.69,23.35) ; UD14.D1 32.9,35.85 v10(32.57,35.85) 32.04,35.85 v10(31.99,35.8) ; v7(113.6,36.72) 114.25,37.37 CD117.2 CD118.2 115.28,37.36 RD25.2 ; v10(110.67,25) UD1.L1 UD2.L9 ; UD14.L1 33.13,30.47 v10(33.52,30.08) ; v10(51,28.43) 50.58,28.85 UD12.N9 ; v2(113.04,61.57) 113.04,61.57 113.47,61.14 CH82.2 ; UD10.L9 61.62,30.48 v10(62.03,30.08) ; UD4.J9 100.2,26.01 v10(100.2,25.81) ; UD6.N1 v10(81.37,24.2) ; UD16.L1 22.08,30.47 v10(22.48,30.08) ; UD6.J9 89.16,26.01 v10(89.16,25.81) ; C1188.2 C1189.2 ; v2(141.19,57.29) 141.42,57.52 U34.J10 U34.J9 U34.J8
  TOP w0.305: v2(76.64,29.75) 76.64,29.74 76.32,29.41 UD8.F8 ; UD14.F8 38.73,34.49 39.05,34.82 v2(39.05,34.83) ; UD12.D8 UD12.D9 50.99,36.08 v10(51.11,36.2) 51.11,36.36 50.59,36.88 UD12.C9 ; PC1304.2 v2(74.12,67.3) ; UD4.F2 93.56,29.4 v2(93.22,29.74) ; PC1309.2 69.47,64.59 PC1301.2 70.45,65.35 v2(70.8,65.7) ; UD2.F8 109.47,29.41 109.79,29.74 v2(109.79,29.75) ; v2(77.04,70.52) 76.97,70.45 PC1297.2 ; v2(28,34.83) 28,34.82 27.68,34.49 UD16.F8 ; v2(72.32,66.59) 72.5,66.59 72.69,66.4 PC1306.2 ; CC223.2 74.92,60.71 v2(74.1,61.53) ; CC221.2 75.29,66.27 PC1307.2 v2(74.68,66.79) ; v2(112.25,50.84) 112.36,50.84 112.81,51.29 RH272.2 ; PC1308.2 72.17,64.26 v2(72.17,64.6) ; UD2.D8 UD2.D9 110.68,31 v10(110.8,31.12) 110.8,31.28 110.28,31.8 UD2.C9 ; PC1316.2 73.2,70.51 72.91,70.22 v2(72.91,69.96) ; v7(75.65,71.31) 75.75,71.31 76.29,70.77 CC226.2 ; v7(56.63,65.54) 55.82,64.73 PC1269.2 ; UD6.C9 88.18,31.8 88.7,31.28 v10(88.7,31.12) 88.58,31 UD6.D9 UD6.D8 ; UD14.C9 39.54,36.88 40.06,36.36 v10(40.06,36.2) 39.94,36.08 UD14.D9 UD14.D8 ; v2(87.69,29.75) 87.69,29.74 87.37,29.41 UD6.F8 ; UD14.F2 33.91,34.48 v2(33.56,34.84) ; v2(59.54,77.05) 59.49,77.11 RC143.2 ; v2(22.54,34.79) 22.86,34.48 UD16.F2 ; UD12.F2 44.98,34.49 v2(44.62,34.84) ; CC228.2 71.18,77.23 v7(70.97,77.43) ; UD8.D8 UD8.D9 77.63,31 77.76,31.13 v10(77.76,31.13) 77.65,31.23 77.65,31.28 77.13,31.8 UD8.C9 ; RH140.2 113.34,76.74 v2(113.34,77.46) ; v2(82.19,29.7) 82.49,29.4 UD6.F2 ; UD2.F2 104.6,29.4 v2(104.25,29.75) ; UD16.D8 UD16.D9 28.89,36.08 v10(29.01,36.2) 29.01,36.36 28.49,36.88 UD16.C9 ; UD12.F8 49.78,34.49 50.1,34.82 v2(50.1,34.83) ; PC1305.2 v2(73.79,66.05) ; v2(98.74,29.75) 98.74,29.74 98.42,29.41 UD4.F8 ; PC1322.2 v2(76.79,67.81) ; v7(72.65,76.28) 72.2,76.73 CC227.2 ; UD8.F2 71.5,29.4 v2(71.13,29.76) ; UD4.C9 99.23,31.8 99.75,31.28 v10(99.75,31.28) 99.75,31.12 99.63,31 UD4.D9 UD4.D8 ; v2(61.15,34.83) 61.15,34.82 60.82,34.49 UD10.F8 ; v2(109.07,60.92) 109.55,61.4 CH71.2 ; PC1318.2 v2(76.81,64.66) ; v2(72.02,66.89) 71.99,66.87 71.86,66.87 PC1272.2 ; v2(123.76,63.61) 123.91,63.77 RH34.1 ; PC1303.2 v2(73.36,68.95)
  TOP w0.381: v7(51.3,86.58) 51.3,85.64 U635.3 ; 158.66,56.48 v2(158.68,56.48) 159.18,55.97 U652.18 160.56,55.97 161.07,55.46 v7(161.07,55.18) ; v2(103,52.5) PR403.2 PC404.2 ; Q305.1 166.41,84.69 v7(166.94,84.16) ; U652.8 164.87,54.02 v7(164.5,54.39) 164.78,54.67 U652.9 ; UD18.4 71.32,51.95 CD127.2 71.29,52.6 UD18.3 ; PC1268.2 60.23,66.08 v2(59.62,65.47) ; RH291.2 114.43,72.48 v2(114.23,72.28) ; C352.2 120.81,52.64 v2(120.77,52.6) ; v7(175.75,60.77) UV1.15 ; PR510.1 PC505.2 127.93,50.67 v2(128.33,51.07) ; v2(149.62,64.75) 149.66,64.79 Q35.4 ; RH44.2 114.74,56.6 v2(115.25,56.1) ; v7(196.36,79.57) 196.36,79.93 196.12,80.18 195.36,80.18 195.08,79.9 PR906.1 ; RH314.1 v2(121.52,73.35) ; PR502.1 129.19,48.48 129.5,48.17 v7(129.75,48.17) ; v2(116.52,71.34) CH103.2 ; Q305.4 v7(168.7,83.39) ; PU702.2 v2(125.99,28.09) ; v2(57.49,75.93) 57.73,76.17 RC89.2 ; U656.1 v2(208.67,57.71) ; RH182.1 v2(113.13,53.02) ; UC1.3 v7(141.05,45.76) ; v2(219.16,72.61) DV1.3 ; v2(119.59,72.25) RH315.1 ; v2(150.96,67.11) Q35.1 ; v2(136.58,52.49) 136.36,52.71 R924.1 C1116.1 ; v7(164.46,56.07) 164.46,56.05 164.53,55.97 U652.11 ; v2(149.14,61.18) RH299.2 ; CH78.2 109.55,62.58 v2(109.18,62.95) ; U652.25 v7(161.04,51.42) ; UV1.8 v7(172.43,56.87)
  TOP w0.508: v7(121.89,28.17) CD129.2 CD133.2 CD132.2 ; PR40.2 152.47,34.79 v7(152.09,34.41) ; CD127.2 70.77,52.08 v2(70.77,51.65) ; v7(98.41,19.39) 98.17,19.63 CD3.2 ; v7(91.19,44.26) 91.07,44.38 RD32.2 ; CH28.2 v2(105.98,63.16) ; R941.1 v7(140.61,71.07) ; v7(74.33,80.68) 74.33,80.73 74.51,80.92 CC229.2 ; v7(22.97,23.79) 23.45,23.3 24.19,23.3 24.8,22.69 C1124.2 ; PR918.2 v7(124.01,25.03) ; CH3.2 119.19,64.74 v2(119.15,64.69) ; v7(129.85,30.06) PC30.1 129.4,29.27 129.1,29.57 PC1916.2 ; C715.2 178.64,24.51 v7(177.98,24.51) ; CH72.2 v2(106.98,62.57) ; C1170.2 177.81,52.29 178.14,52.62 v7(178.14,52.59) ; Q333.3 v7(169.02,48.08) ; C1100.1 v7(12.4,19.01) ; v7(139,23.69) C1155.2 ; RC129.1 v2(74.1,61.53) ; Q32.3 131.71,54.71 131.38,54.38 v2(131.38,54.09) ; U652.4 165.69,51.45 167.03,51.45 167.3,51.72 C1139.2 ; CLRP1.1 123.17,56.4 CH4.1 123.63,57.47 v7(123.98,57.82) ; v7(131.45,76.24) 131.44,76.25 RH183.1 131.68,76.97 132.01,77.3 RH171.2 ; v7(43.31,43.19) 40.98,43.19 40.65,42.86 CD64.2 ; v2(79.12,67.7) 79.08,67.74 CC222.2 ; Q4.3 109.57,39.35 109.91,39.69 v7(110.01,39.69) ; v7(31.81,59.78) 32.27,59.78 PC735.2 32.37,59.14 v7(31.81,59.14) ; v7(69.12,53.99) 69.2,54.06 RD41.1 ; PC1235.2 v2(63.12,75.73) ; v2(109.55,65.91) 108.93,65.91 CH62.2 ; CH74.2 106.9,71.12 v2(106.9,71.67) ; R290.2 132.6,52.48 132.6,52.49 v7(132.52,52.49) ; 106.9,63.75 107.72,63.75 CH25.2 ; 106.9,63.75 106.86,63.75 v2(106.86,63.18) ; 106.9,63.75 CH26.2 ; C279.2 C278.2 147.7,51.53 C283.2 147.04,51.42 147.04,51.82 v7(146.92,51.93) ; PC911.2 122.34,27.75 122.51,27.93 v7(122.51,28.03) ; C1125.2 16.05,24.88 C1101.1 16.03,23.91 v7(16.1,23.84) ; CC232.2 v2(75.75,59.14) ; v2(110.09,66.28) 109.82,66.55 109.82,66.86 CH52.2 ; C1151.2 158.11,78.67 158.11,77.85 ; C1168.2 178.9,53.78 178.35,53.23 v2(177.98,53.23) 177.33,53.23 C1169.2 ; Q311.3 174.67,31.08 v7(174.54,31.2) ; v2(112.55,72.88) 112.55,72.26 CH68.2 ; v7(78.7,19.63) 78.7,20.25 RD8.2 ; v2(97.43,67.92) 97.4,67.89 CH44.2 ; RH123.1 v2(111.34,74.75) ; CC218.2 59.81,60.54 59.44,60.91 v7(59.44,61.61) ; v7(59.42,63.1) 59.37,63.15 PC1312.2 ; v7(111.67,79.93) 112.12,79.93 112.65,80.46 CH24.2 ; v7(142.68,52.06) 143.29,52.67 L44.1 ; 141.25,65.21 R607.1 ; 141.25,65.21 C654.2 ; 141.25,65.21 141.28,65.21 v7(141.28,65.87) ; v7(162.68,67.17) 163.06,67.55 C1205.2 ; PC125.2 200.03,56.31 v7(199.99,56.27) ; CD5.2 87.86,20.26 v7(87.86,19.66) ; CH118.1 106.99,55.44 v7(106.89,55.33) ; v7(127.36,26.86) 126.93,26.43 DE2.1 ; v2(112.81,65.97) 113.31,65.97 RH80.2 ; PC1240.2 v2(67.44,75.7) ; C1167.2 170.09,50.98 v7(170.47,50.61) ; CD30.2 51.98,41.8 v2(51.33,41.15) ; PC905.2 v7(121.34,30.31) ; v7(31.81,61.43) 32.34,61.43 PC734.2 32.29,60.79 v7(31.81,60.79) ; R945.1 v7(173.47,27.97) ; PC1310.2 60.26,63.06 v7(60,62.8) ; v7(111.94,18.5) 111.96,18.52 CD114.2 ; PD905.1 v7(131.55,22.59) ; v2(169.26,44.28) 169.29,44.31 169.3,44.31 169.85,44.86 Q34.3 ; C1199.2 175.55,77.74 175.12,77.32 v7(175.12,77.3) ; CH81.2 v2(102.93,64.96) ; QC1.3 141.01,50.98 v2(141.54,51.5) ; v7(89.83,19.65) 89.79,19.69 RD6.2 ; v2(105.76,67.36) 105.76,66.74 CH59.2 ; YH2.4 116.86,78.68 v7(116.86,78.68) ; v2(99.79,70.5) 99.82,70.46 CH41.2 ; C656.2 49.4,85.78 v2(49.37,85.81) ; v2(106.9,69.6) 106.9,70.16 CH77.2 ; v7(52.79,51.75) 52.2,52.34 R1035.2 CC69.2 ; PC25.2 v7(129.8,30.87) ; C1157.2 v7(142.45,26.25) ; 98.38,44.55 96.76,42.93 RH338.1 ; 158.11,77.85 158.11,77.81 157.44,77.81 v7(156.9,77.28) ; 158.11,77.85 R545.2 ; C1146.1 12.78,20.79 v7(12.33,20.33) 12.76,19.9 C1098.1 ; CH79.2 104.22,60.9 v2(105.06,60.9) ; v7(93.55,62.81) 93.74,62.81 94.01,63.08 RH79.2 94.25,63.07 RH77.2 ; PC714.2 v2(19.23,85.94) ; v7(177.53,46.29) 177.35,46.11 C712.2 177.65,44.79 R730.2 C709.2 ; v2(110.96,70.3) 110.96,70.92 CH64.2 ; Q5.3 131.07,50.61 v7(131.07,50) ; PC409.2 167.38,43.09 v7(167.25,43.22) ; PC1914.2 v2(127.03,32.32) ; C1200.2 169.74,80.96 v7(169.96,81.18) ; CH85.2 108.99,68.7 v2(108.36,68.7) ; CH56.2 113.82,71.24 v2(113.82,71.75) ; Q71.3 v7(160.57,84.4) ; CH21.2 122.89,80.23 v7(123.32,79.79) ; CD90.2 23.48,41.26 v7(23.71,41.26) ; PC737.2 30,79.92 30.68,79.25 v7(30.68,79.17) ; C1154.2 133.31,21.5 132.82,21.02 v7(132.35,21.02) ; C1156.2 v7(138.82,21.22) ; v2(155.67,47.03) v2(156.69,47.03) 156.92,46.8 v2(157.79,46.8) v2(158.68,46.8) ; R928.2 61.48,25.29 v7(61.35,25.16) ; CH116.2 132.17,63.28 v2(132.13,63.24) ; v7(161.28,78.68) 161.28,79.58 C612.2 ; RD20.2 15.24,42.65 v7(15.7,43.12) ; PC1273.2 v2(59.45,68.75) ; CH49.2 93.73,69.93 v7(94.41,69.25) ; v7(43.94,43.21) 43.94,41.99 CD87.2 ; PD902.1 195.89,78.09 v7(196.27,78.47) ; CD59.2 57.33,41.52 v2(57.43,41.62) ; CD58.2 30.97,42.25 v7(30.28,42.94) ; v2(113.34,77.46) 113,77.46 CH23.2 ; CH47.2 v2(108.64,65.27) ; RH163.2 v2(114.76,69.3) ; RH306.2 123.86,76.95 v2(123.88,76.92) ; CH70.2 106.99,61.88 CH65.2 v2(107.63,61.28) ; C284.2 137.45,61.32 v2(137.95,61.82) ; PR509.1 PR505.2 v7(121.98,50.58) ; v2(99.66,67.57) 99.69,67.53 RH78.2 ; v7(181.67,70.07) 181.24,70.5 C617.1 ; RD14.2 42.58,26.28 v2(42.61,26.31) ; CH46.2 101.08,61.3 CH42.2 v2(100.9,60.49) ; C716.2 179.39,33.93 v7(178.95,33.49) ; RH45.2 121.15,55.43 v2(121.24,55.33) ; v7(215.2,63.84) 214.57,63.84 214.14,64.27 C962.2 ; PC904.2 v7(123.12,30.24) ; PC715.2 19.54,73.44 v7(19.26,73.72) ; PR726.1 v7(26.75,86.58) ; C277.2 C276.2 136.02,63.95 135.71,63.64 v7(135.71,63.18) 135.78,63.11 R980.2 ; C1204.2 159.44,67.83 v7(159.16,68.11) 159.09,68.03 CH1202.2 ; C1122.2 228,22.02 v7(227.96,22.06) ; v2(136.58,52.49) 137.02,52.05 C280.1 C281.1 ; CC230.2 76.28,80.92 v7(76.66,80.53) ; CC225.2 86.1,73.3 v2(85.99,73.19) ; v7(177.65,51.65) 177.17,51.17 C722.2 ; v7(182.4,55.97) 182.94,56.5 PC215.2 ; v2(104.53,56.4) RH83.2 ; PC1228.2 65.74,77.84 v2(65.74,77.84) ; v2(68.46,75.73) 68.46,75.73 PC1236.2 ; CC231.2 v2(75.75,57.87) ; v7(174.4,48.96) 174.56,48.81 C1171.2 ; CH67.2 108.8,70.99 v2(108.8,71.56) ; v2(105.21,59.68) 105.81,59.68 CH45.2 ; RH151.1 v2(119.34,68.03) ; v2(113.04,63.61) 113.4,63.25 RH53.2 ; C710.2 v7(178.11,26.38) ; CH50.2 112.17,65.15 v2(112.17,65.74) ; v2(103.99,72.36) 103.95,72.33 CH43.2 ; CH38.2 v2(104.07,66) ; C1102.1 v7(10.42,20.41) ; PC1266.2 v2(104.93,64.25) ; C1161.2 174.74,62.99 v7(174.78,62.95) ; RD4.2 100.04,19.99 v7(100.04,19.39) ; CD2.2 71.42,20.07 v7(71.61,20.07) ; CH89.2 v2(98.86,70.5) ; RH300.1 211.39,73.32 v7(211.39,72.28) ; CH35.2 100.63,56.72 v2(100.82,56.53) ; PC909.2 176.49,80.48 175.88,81.09 v7(175.88,81.75) ; CH55.2 v2(103.22,68.48) ; R540.2 166.4,76.03 v7(166.43,76.01) 166.91,76.49 Q336.3 ; v7(213.88,62.75) 213.57,63.06 C963.2 ; v7(27.59,41.52) 27.24,41.87 CD91.2 ; CD29.2 77.75,20.25 v7(77.75,19.65) ; v2(109.73,59.07) CH54.2 ; v7(81.9,51.4) 81.11,52.19 81.09,52.19 81.05,52.23 CD128.2 ; v2(103.87,59.81) 104.49,59.81 RH82.2 ; C968.2 151.44,57.16 v2(151.95,57.67) ; PC1238.2 v2(68.08,77.94) ; v7(80.19,39.99) 79.97,39.76 CD62.2 ; CH39.2 v2(100.03,66) ; PC1233.2 v2(63.2,78.35) ; v7(178.62,47.97) 178.87,48.22 R1027.2 179.02,48.8 Q330.3 ; YH2.2 114.94,77.6 114.38,78.16 v2(114.22,78.16) ; C1140.2 v2(166.89,57.04) ; RH295.2 132.15,66 131.77,65.62 CH66.2 131.3,66.05 v2(130.86,66.5) ; v7(165.04,67.31) 165.04,66.71 R1108.1 ; CD42.2 104.01,19.05 v7(103.99,19.06) ; PC1234.2 v2(64.01,75.73) ; v7(216.31,55.08) 216.31,54.88 216.02,54.58 R809.2 ; v2(113.05,58.93) 112.9,59.08 CH51.2 ; C713.2 180.22,51.17 v7(180.27,51.22) ; CD139.2 14.77,26.83 v2(14.33,27.27) 14.33,27.95 15.11,28.73 CD136.2 ; CH80.2 v2(103.82,64.99) ; C1137.2 155.41,67.14 v7(155.61,66.94) 155.75,67.08 CH1203.2 ; v7(86.85,40.32) 87.13,40.32 CD4.2 ; v7(16.16,41.62) 16.17,41.63 CD115.2 CD116.2 ; v7(179.9,71.55) Q42.3 ; v2(138.15,81.28) C969.2 C970.2 ; v7(165.11,60.93) C979.2 C977.2 ; v2(153.84,68.15) 153.91,68.08 C1152.2 ; R1100.1 v2(114.59,50.53) ; v2(113.31,69.45) 113.31,70.03 CH63.2 ; PD904.1 v2(125.53,21.53) ; C1141.2 158.66,56.48 ; Q334.3 v2(144.78,70.29) ; v2(105.2,58.73) 105.36,58.89 CH69.2 ; RD2.2 114.48,24.12 v7(114.51,24.09) ; v7(33.61,40.86) 34.41,41.65 CD57.2 ; v2(58.2,68.08) 57.97,67.85 PC1285.2 ; v7(179.76,61.23) 179.27,60.74 CV13.2 ; v7(31.81,62.7) 32.42,62.7 PC736.2 32.22,63.33 32.21,63.33 v7(31.79,63.33) ; PC1231.2 65.66,75.73 v2(65.67,75.73) ; v2(114.48,64.48) RH81.2 114.71,65.05 115.4,65.75 CH117.2 ; PC1311.2 v2(57.01,66.98) ; QC5.3 v2(92.32,65.49) ; Q321.3 v7(141.35,69.96) ; v2(100.23,63.94) 100.86,63.94 CH40.2 ; v7(158.11,71.26) 158.11,71.97 157.63,72.45 157.63,72.95 C1207.2 ; C708.2 179.92,38.15 179.92,38.65 v2(180.27,39) ; 170.49,67.07 v7(171.46,67.07) ; CH60.2 v2(107.12,65.37) ; C1099.1 v7(14.03,23.05) ; PR47.1 v7(122.23,30.29) ; PR606.2 v7(102.86,81.42) ; v7(142.68,82.08) 142.63,82.03 C974.2 ; v2(69.35,75.73) 69.35,75.73 PC1237.2 ; PR404.2 107.96,50.97 v2(107.86,50.86) ; v7(112.83,18.5) 112.85,18.52 CD113.2 ; PC1232.2 v2(65.61,79.06) ; RD10.2 66.43,31.06 v7(66.46,31.03) ; PC1265.2 v2(101.57,67.34) ; C1117.2 v7(144.84,65.87) ; v2(192.52,75.15) 192.52,74.04 ; R1099.1 v2(155.25,72.56) ; v2(118.9,62.19) 119.74,62.19 CH2.2 ; CLRP2.2 117.56,66.36 v2(117.28,66.64) ; v2(50.84,42.32) 50.81,42.28 RD12.2 ; CH53.2 112.8,66.93 v2(112.8,67.57) ; PC1317.2 v2(75.19,69.28) ; PC1313.2 58.3,63.89 v7(57.23,62.83) ; CH73.2 98.38,53.26 97.7,52.58 v7(97.7,52.51) ; PC1229.2 v7(68.92,80.56) ; 70.3,63.51 70.3,62.91 v7(70.44,62.78) ; v7(111.06,18.5) 111.07,18.52 RD19.2 ; PC1300.2 v2(101.91,63.72) ; v7(125.15,28.03) PR937.1 ; v2(93.48,64.6) 93.86,64.99 RH76.2 ; PC1320.2 v2(100.01,60.52) ; v7(139.25,66.71) 139.28,66.69 C293.2 ; v7(14.79,40.45) 14.37,40.03 CD140.2 CD142.2 ; CH99.2 119.8,78.7 v7(119.9,78.8) 120.37,79.27 RH84.2 ; v2(147.89,50.43) 147.71,50.25 R225.1 ; v7(56.83,19.2) 56.79,19.16 PC311.2 ; JKB1.32 v7(170.77,23.53) ; v7(121.86,29.06) CD135.2 ; PC1321.2 v2(100.02,65.05) ; CH61.2 v2(108.01,65.34) ; CH76.2 103.22,69.4 v2(103.22,70.01) ; v7(139.32,52.06) C285.2 ; PR959.1 v2(123.96,30.65) ; v2(118.29,34.51) CD123.2 ; CD37.2 91.56,39.81 v7(91.56,40.52) ; C961.1 v2(207.22,54.44) ; JKB1.31 v7(144.62,23.15) ; C1123.2 25.9,20.92 26.16,20.66 v7(26.16,20.26) ; PC1230.2 v2(69.88,79.11) ; CH36.2 v2(110.67,73.52) ; v7(142.3,21.6) DE1.1 ; CC65.2 v7(144.2,45.94) ; v2(97.59,73.52) CH87.2
  GND1 w0.254: v3(112.4,67.48) 112.71,67.48 v2(112.8,67.57) ; v3(114.95,64.47) 114.95,64.48 v2(114.48,64.48) ; v3(109.07,63.4) 109.07,63.06 v2(109.18,62.95) ; v2(151.44,59.65) v3(151.85,59.65) ; v3(71.53,66.56) 71.87,66.89 v2(72.02,66.89) ; v2(108.8,71.56) 108.8,71.15 v3(108.8,71.15) ; v3(72.78,66.46) 72.45,66.46 v2(72.32,66.59) ; v3(86.04,72.5) 85.99,72.56 v2(85.99,73.19) ; v3(102.58,69.94) 103.16,69.94 v2(103.22,70.01) ; v2(112.25,50.84) v3(112.25,50.43) ; v3(180.75,39) v2(180.27,39)
  GND1 w0.305: v2(73.36,68.95) 73.36,69.38 v3(73.21,69.53) ; v3(65.11,64.3) v2(65.56,64.3) ; v2(70.8,65.7) v3(70.44,65.34) ; v3(66.05,65.52) v2(66.05,65.11) ; v2(73.79,66.05) 73.79,65.87 v3(73.59,65.67) ; v2(76.79,67.81) v3(76.36,67.81) ; v2(72.17,64.6) v3(72.17,64.2) ; v2(76.81,64.66) v3(76.81,65.06) ; v2(58.99,73.75) v3(58.55,73.75) ; v2(74.68,66.79) v3(74.68,66.38) ; v2(77.04,70.52) v3(77.04,70.09) ; v3(124.16,63.87) 124.01,63.87 v2(123.76,63.61) ; v2(74.12,67.3) v3(74.12,67.7)
  GND1 w0.381: v2(208.67,57.71) 208.47,57.9 v3(208.24,57.9) ; v2(120.77,52.6) v3(120.77,53.35) ; v3(128.63,50.76) v2(128.33,51.07)
  GND1 w0.508: v2(64.01,75.73) v3(64.01,75.32) ; v2(119.34,68.03) v3(119.34,67.61) ; v2(107.86,50.86) 107.47,50.48 v3(107.37,50.48) ; v2(63.2,78.35) v3(63.61,78.35) ; v2(67.44,75.7) v3(67.44,75.27) ; v3(112.83,77.64) 113.01,77.46 v2(113.34,77.46) ; v3(131.9,54.71) 131.9,54.61 v2(131.38,54.09) ; v2(141.54,51.5) v3(141.13,51.5) ; v2(147.89,50.43) v3(147.89,51.07) ; v3(137.29,51.55) 137.29,51.78 v2(136.58,52.49) ; v3(104.53,72.22) 104.45,72.3 104.05,72.3 v2(103.99,72.36) ; v3(132.39,42.89) v2(131.93,42.89) ; v2(63.12,75.73) 63.12,75.33 v3(63.23,75.22) ; v2(121.24,55.33) 121.77,55.87 v3(121.77,55.94) ; v3(65.67,75.32) v2(65.67,75.73) ; v2(125.53,21.53) v3(125.94,21.53) ; v2(131.93,40.98) v3(131.93,41.55) ; v2(117.28,66.64) 117.43,66.79 v3(117.43,67.12) ; v2(177.98,53.23) v3(177.98,53.63) ; v2(131.93,39.08) v3(131.93,39.54) ; v2(169.26,44.28) 169.26,43.97 v3(169.04,43.75) ; v2(68.08,77.94) v3(68.49,77.94) ; v2(79.12,67.7) v3(78.39,67.7) ; v2(69.35,75.73) 69.45,75.73 v3(69.78,75.4) ; v2(75.19,69.28) v3(75.19,69.81) ; v2(68.46,75.73) v3(68.46,75.32) ; 167.82,57.77 v3(167.82,58.41) ; v2(14.33,27.27) v3(13.9,27.27) ; v3(155.4,72.07) 155.4,72.4 v2(155.25,72.56) ; v2(65.74,77.84) v3(66.17,77.84) ; v2(57.43,41.62) v3(57.43,41.09)
  IN1 w0.254: v3(55.38,65.04) 55,65.04 v4(54.9,65.14) ; v4(153.04,59.93) 153.04,59.91 152.79,59.65 v3(151.85,59.65) ; v4(74.35,62.5) 74.05,62.8 v5(73.92,62.8) ; v4(108.27,71.79) 108.09,71.79 v3(107.81,71.51) ; v5(56.04,66.46) 56.17,66.46 56.5,66.79 v4(56.52,66.79) ; v4(56.75,66.15) 56.4,66.15 v5(56.22,65.98) ; v4(113.14,67.57) 113.05,67.48 v3(112.4,67.48) ; v3(105.39,70.71) 105.26,70.71 104.95,71.02 v4(104.95,71.02) ; v4(124.01,63.08) 124.01,63.72 v3(124.16,63.87) ; v5(52.23,68.16) 51.7,68.16 v4(51.65,68.11) ; v4(79.03,62.73) 78.8,62.95 v5(78.8,63.18) ; v4(56.85,57.52) v3(56.85,57.04) ; v4(55.4,61.35) 55.73,61.68 55.73,61.71 55.73,61.71 55.73,61.73 v5(55.73,61.73) ; v4(51.37,65.95) 51.44,65.87 v5(51.85,65.87) ; v4(71.28,60.67) 71.66,61.05 v3(71.66,61.33) ; v5(62.87,62.98) 62.9,62.98 63.28,62.6 v4(63.28,62.52) ; v3(86.04,72.5) 86.34,72.5 v4(86.67,72.17) ; v4(59.16,62.22) 59.52,62.22 v5(59.65,62.09) ; 97.47,60.26 97.47,60.46 v3(97.77,60.77) ; 97.47,60.26 97.45,60.27 v3(96.91,60.27) ; 97.47,60.26 v4(97.48,60.25) ; v5(74.63,38.39) 74.71,38.32 75.06,38.32 75.09,38.29 v4(75.11,38.32) ; v5(69.7,60.39) 70.31,60.39 v4(70.34,60.36) ; v5(68.54,56.3) 69.04,56.3 v4(69.07,56.32) ; v5(76.38,62.98) v4(76.38,62.5) ; v3(117.83,73.66) 117.9,73.74 118.26,73.74 118.26,73.74 v4(118.33,73.74) ; v4(72.5,59.58) v3(72.5,59.09) ; v5(75.42,41.08) 75.42,40.63 v4(75.45,40.6) ; v3(115.55,65.62) 115.55,65.62 115.4,65.47 115.4,65.06 v4(115.42,65.04) 115.4,65.01 115.4,64.92 114.95,64.48 v3(114.95,64.47) ; v3(52.89,67.02) 52.41,67.02 52.36,66.97 v4(52.33,66.97) ; v4(58.33,64.53) 58.3,64.53 v5(57.97,64.2) ; v5(72.3,62.09) v4(72.3,61.61) ; v3(68.08,62.7) 68.08,63.06 68.18,63.16 v4(68.18,63.18) ; v4(73.01,60.9) 73.01,60.64 v5(73.24,60.41) ; v4(76.31,61.73) 76.36,61.73 v3(76.69,62.06) ; v3(55.05,67.32) 55.33,67.6 v4(55.48,67.6) ; v4(53.19,67.93) 53.19,67.83 53.27,67.75 v3(53.27,67.37) ; v4(97.57,68.69) 97.54,68.69 v3(97.21,69.02) ; v3(101.4,55.62) v4(101.91,55.62) ; v3(69.12,62.47) 69.12,62.34 v4(69.43,62.04) ; v3(96.91,74.64) 97.39,74.64 v4(97.42,74.66) ; v4(75.9,63.11) 75.8,63 v5(75.8,62.62) ; v4(54.62,67.6) 54.62,67.63 54.59,67.6 54.57,67.63 54.54,67.6 54.41,67.6 v5(54.19,67.37) ; v4(97.44,65.27) 97.44,65.32 v3(97.12,65.64) ; v4(98.58,73.65) 98.56,73.65 v3(98.23,73.32) ; v3(60.64,58.84) 60.61,58.86 60.43,58.86 60.15,59.14 v4(59.95,59.14) ; v4(95.66,69.3) 95.89,69.08 v3(96.1,69.08) ; v4(52.97,58.33) v3(52.97,57.85) ; v5(69.76,34.25) 70.01,34.25 v4(70.21,34.46) ; v3(56.65,61.86) 57.11,61.86 v4(57.13,61.84) ; v4(97.87,64.91) 97.9,64.91 v3(98.25,64.55) ; v4(99.75,73.06) 100.06,72.76 v3(100.16,72.76) ; v4(57.82,62.9) 57.87,62.9 v5(58.2,62.57) ; v3(60.71,58.15) v4(60.71,57.67) ; v4(65.06,62.57) 65.51,62.12 v3(65.51,62.01) ; v5(76.54,58.74) 76.54,58.59 v4(76.82,58.31) ; v5(73.72,40.07) v4(73.72,39.59) ; v3(113.98,65.9) 113.69,65.9 113.49,65.7 v4(113.48,65.7) ; v5(77.76,63.23) 78.09,63.23 v4(78.24,63.08) ; v4(99.12,76.75) v3(99.47,77.1) ; v4(102.01,69.94) v3(102.58,69.94) ; v3(64.85,38.27) v4(64.85,37.78) ; v3(58.05,63.69) v4(58.55,63.69) ; v3(101.05,58.99) 101.05,59.42 v4(101.13,59.49) ; v4(56.85,58.74) v3(56.85,58.25) ; v3(73.49,60.74) v4(73.49,61.25) ; v3(115.42,66.56) v4(114.91,66.56) ; v5(60.71,62.83) 60.71,62.4 v4(60.66,62.34) ; v4(109.1,62.73) 109.1,63.37 v3(109.07,63.4) ; v4(109.07,70.52) 109.07,70.87 108.8,71.14 v3(108.8,71.15) ; v4(57.18,64.76) 56.93,65.01 v5(56.75,65.01) ; v5(58.33,62.17) 58.63,61.86 v4(58.71,61.86) ; v3(53.75,60.08) v4(53.75,59.6) ; v4(52.92,60.06) v3(52.92,59.58) ; v5(76.21,60.64) 76.21,61.07 v4(76.28,61.15) ; v4(97.75,58.43) 97.8,58.43 98.05,58.69 v3(98.05,59.14) ; v3(112.25,50.43) v4(112.25,49.95) ; v4(94.77,62.6) 94.78,62.6 95.08,62.3 v3(95.18,62.3) ; v3(62.14,63.31) 62.24,63.41 v4(62.62,63.41) ; v5(59.75,60.24) v4(59.75,60.72) ; v4(181.11,38.29) 181.13,38.32 181.13,38.56 180.75,38.94 v3(180.75,39) ; v4(77.91,60.85) 78.21,60.54 v3(78.32,60.54) ; v5(62.47,40.42) 62.47,40.83 62.39,40.91 v4(62.38,40.91) ; v3(63.48,61.99) v4(63.86,62.37) ; v3(57.74,61.38) 57.77,61.38 58,61.61 v4(58,61.81) ; v5(78.82,66.38) v4(79.31,66.38) ; v3(54.64,57.77) v4(54.64,58.25)
  IN1 w0.305: v3(74.12,67.7) 74.12,68.09 v4(73.9,68.31) ; v4(76.28,70.65) 76.49,70.65 77.04,70.09 v3(77.04,70.09) ; v3(73.59,65.67) 73.31,65.95 v4(72.93,65.95) ; v4(65.59,64.3) v3(65.11,64.3) ; v3(71.53,66.56) 70.9,66.56 v4(70.87,66.54) ; v4(58.45,73.22) 58.55,73.32 v3(58.55,73.75) ; v3(74.68,66.38) 75.11,66.38 v4(75.22,66.48) ; v4(70.39,65.98) 70.44,65.93 v3(70.44,65.34) ; v4(76.97,67.48) 76.69,67.48 76.36,67.81 v3(76.36,67.81) ; v3(72.17,64.2) 72.17,64.17 v4(71.64,63.64) ; v3(73.21,69.53) v4(73.59,69.15) ; v4(66.05,65.04) v3(66.05,65.52) ; v4(77.5,65.27) 77.3,65.06 v3(76.81,65.06) ; v4(73.24,66.71) 73.24,66.69 73.01,66.46 v3(72.78,66.46)
  IN1 w0.381: v3(75.19,69.81) 74.76,70.24 v4(74.76,70.52) ; v4(208.16,58.38) 208.16,57.98 v3(208.24,57.9) ; v4(120.17,53.48) 120.3,53.35 v3(120.77,53.35) ; v3(128.63,50.76) v4(128.63,50.08)
  IN1 w0.508: v3(66.17,77.84) 66.17,78.35 66.33,78.5 v4(66.33,78.52) ; v4(115.27,77.99) 114.87,77.99 v3(114.69,78.17) ; v4(122.26,55.94) v3(121.77,55.94) ; v4(176.08,70.32) v3(176.08,70.83) ; v3(13.9,27.27) 13.72,27.27 v4(13.22,27.77) ; v3(141.13,51.5) 141.13,51.88 v4(141,52.01) ; v3(68.46,75.32) v4(68.46,76.14) ; v3(78.39,67.7) 77.63,67.7 v4(77.58,67.65) ; v3(119.34,67.61) 119,67.61 118.7,67.3 118.7,67.3 v4(118.7,67.29) ; v4(136.43,50.76) 137.22,51.55 v3(137.29,51.55) ; v3(69.78,75.4) v4(69.22,75.96) ; v3(173.16,70.76) v4(173.16,70.26) ; v3(104.53,72.22) 105.01,72.22 v4(105.04,72.2) ; v3(177.98,53.63) v4(177.43,54.19) ; v3(112.83,77.64) 112.83,78.42 v4(112.88,78.47) ; v4(156.32,71.26) 156.32,71.49 155.73,72.07 v3(155.4,72.07) ; v3(125.94,21.53) v4(126.42,21.53) ; v3(131.9,54.71) 131.9,54.46 v4(131.4,53.96) ; v3(63.61,78.35) v4(64.14,78.35) ; v3(131.93,41.55) 132.05,41.44 v4(132.52,41.44) ; v4(57.03,40.6) 57.43,41 v3(57.43,41.09) ; v3(65.67,75.32) 65.46,75.53 v4(65.46,76.03) ; v3(169.04,43.75) v4(169.04,43.27) ; v3(132.39,42.89) v4(132.39,42.38) ; v3(91.75,65.95) v4(90.96,65.95) ; v3(64.01,75.32) v4(64.01,76.14) ; v3(131.93,39.54) v4(131.38,39.54) ; v3(117.43,67.12) 117.93,67.12 v4(118.07,67.26) ; v4(67.44,76.16) v3(67.44,75.27) ; v3(147.89,51.07) v4(148.37,51.07) ; v3(107.37,50.48) v4(107.37,49.9) ; v3(167.82,58.41) v4(167.44,58.03) ; v4(68.49,78.45) v3(68.49,77.94) ; v3(63.23,75.22) v4(63.23,74.71) ; v3(118.7,34.51) v4(118.7,34)
  IN4 w0.254: v5(62.47,40.42) 62.47,40.83 62.39,40.91 v4(62.38,40.91) ; v4(72.3,61.61) v5(72.3,62.09) ; v4(76.38,62.5) v5(76.38,62.98) ; v4(103.39,74.84) 103.39,74.76 103.79,74.36 v5(103.89,74.36) ; v5(58.2,62.57) 57.87,62.9 v4(57.82,62.9) ; v5(78.9,63.64) 78.87,63.64 78.9,63.61 v5(78.9,63.64) ; v5(78.9,63.64) 79.23,63.97 v4(79.23,64) ; v5(106.43,68.52) v4(106.43,69) ; v5(55.14,71.52) v4(55.14,71.02) ; v4(54.62,67.6) 54.41,67.6 v5(54.19,67.37) ; v4(75.9,63.11) 75.8,63 v5(75.8,62.62) ; v5(110.48,75.36) 110.48,75.6 v4(110.75,75.87) ; v4(65.06,62.57) v5(65.41,62.93) ; v5(76.21,60.64) 76.21,61.07 v4(76.28,61.15) ; v5(107.04,66.85) 106.79,66.85 106.6,66.65 v4(106.59,66.65) ; v4(115.42,65.04) 115.4,65.06 115.4,65.19 v5(115.09,65.49) ; v4(70.34,60.36) 70.31,60.39 v5(69.7,60.39) ; v5(100.67,59.71) 100.88,59.49 101.12,59.49 v4(101.13,59.49) ; v5(64.04,74.76) v4(64.52,74.76) ; v4(79.03,62.73) 78.8,62.95 v5(78.8,63.18) ; v4(78.24,63.08) 78.09,63.23 v5(77.76,63.23) ; v5(100.62,68.29) 101.15,68.29 101.52,67.92 101.52,67.91 v4(101.56,67.87) ; v4(74.35,62.5) 74.23,62.5 v5(73.92,62.8) ; v4(57.13,61.84) 57.16,61.86 57.16,62.27 57.13,62.29 v5(57.13,62.32) ; v5(103.41,71.64) 103.7,71.93 v4(103.7,72.13) ; v4(99.75,75.04) 99.73,75.02 99.73,74.84 100.03,74.54 v5(100.03,74.54) ; v5(97.87,74.99) 97.52,74.64 97.44,74.64 v4(97.42,74.66) ; v5(71.99,75.68) 71.99,76.19 v4(71.99,76.19) ; v5(53.8,59.12) 53.8,59.55 v4(53.75,59.6) ; v5(102.18,70.43) 102.18,70.11 v4(102.01,69.94) ; v4(77.91,60.85) 77.99,60.85 v5(78.32,60.52) ; v4(97.57,68.69) 97.37,68.69 v5(97.14,68.47) ; v4(104.44,71.65) 104.44,72.21 v5(104.47,72.24) ; v5(71.61,61.15) 71.28,60.82 v4(71.28,60.67) ; v4(97.87,64.91) 97.87,64.88 97.95,64.96 97.95,64.99 97.96,65 v5(98.37,65) ; v4(65.36,79.92) 64.99,79.92 v5(64.86,79.79) ; v4(100.28,70.16) 100.28,69.78 v5(100.17,69.67) ; v5(57.37,69.96) v4(57.37,69.48) ; v4(63.28,62.52) 63.28,62.6 62.9,62.98 v5(62.87,62.98) ; v4(104.28,60.65) 104.28,60.4 v5(104.09,60.21) ; v4(51.65,68.11) 51.7,68.16 v5(52.23,68.16) ; v4(105.06,74.82) 105.09,74.84 v5(105.59,74.84) ; v5(107.91,74.44) 107.91,74.57 108.19,74.85 v4(108.19,74.86) ; v5(68.46,79.82) v4(67.98,79.82) ; v4(58.33,64.53) 58.3,64.53 v5(57.97,64.2) ; v4(108.75,74.82) 108.75,75.25 v5(108.87,75.37) ; v4(75.45,40.6) 75.42,40.63 v5(75.42,41.08) ; v4(72.5,59.58) v5(72.85,59.93) ; v4(69.07,56.32) 68.56,56.32 v5(68.54,56.3) ; v4(114.91,66.56) 114.94,66.58 v5(115.44,66.58) ; v4(59.95,59.14) 59.95,59.4 v5(59.72,59.63) ; v4(101.91,55.62) 101.72,55.62 101.43,55.92 v5(101.43,56.53) ; v4(60.66,62.34) 60.71,62.4 v5(60.71,62.83) ; v4(56.75,66.15) 56.4,66.15 v5(56.22,65.98) ; v4(104.91,75.83) 104.88,75.83 104.91,75.81 v4(104.91,75.83) ; v4(104.91,75.83) v5(105.44,75.83) ; v4(76.82,58.31) 76.82,58.46 v5(76.54,58.74) ; v5(73.29,75.5) 73.29,75.58 v7(73.67,75.96) ; v5(101.09,71.68) 101.02,71.68 100.72,71.39 100.72,71.39 v4(100.69,71.35) ; v5(63.25,78.07) 63.86,78.07 v4(64.14,78.35) ; v4(53.19,67.93) 53.12,67.86 v5(53.12,67.45) ; v4(58.6,69.51) 58.61,69.51 58.96,69.15 v5(59.09,69.15) ; v4(116.57,63.58) 116.28,63.29 v5(116.28,63.2) ; v5(108.66,63.2) 108.66,63.17 v4(109.1,62.73) ; v5(106.71,75.86) v4(106.23,75.86) ; v4(102.62,74.82) 102.62,74.79 v5(102.98,74.44) ; v5(56.43,71.53) v4(56.43,71.05) ; v4(103.04,70.68) 103.04,70.68 103.04,70.55 103.35,70.23 v5(103.35,70.23) ; v4(75.11,38.32) 74.71,38.32 v5(74.63,38.39) ; v4(102.85,68.41) 102.92,68.48 v5(103.37,68.48) ; v4(71.99,73.49) 71.99,73.77 72.17,73.95 v5(72.17,73.98) ; v5(105.54,70.27) v4(106.03,70.27) ; v4(60.71,57.67) 60.71,58.21 v5(60.76,58.25) ; v5(103.79,66.03) v4(103.79,65.54) ; v4(47.96,79.16) 48.27,78.85 v5(48.27,78.78) ; v4(98.65,75.87) 98.65,75.83 v5(98.28,75.47) ; v5(96.21,69.29) 95.67,69.29 v4(95.66,69.3) ; v5(98.71,58.33) 98.97,58.33 v4(99.17,58.53) ; v4(98.58,73.65) 98.58,73.83 v5(98.33,74.08) ; v4(94.83,72.91) 94.85,72.94 v5(95.73,72.94) ; v5(66.81,79.79) v4(66.81,80.28) ; v4(52.5,70.36) v5(52.5,69.87) ; v5(99.96,73.6) 99.94,73.6 99.75,73.42 v4(99.75,73.06) ; v4(53.02,70.7) 53.02,70.75 52.9,70.86 v5(52.9,71.17) ; v4(59.75,60.72) v5(59.75,60.24) ; v4(118.33,73.74) 117.9,73.74 v5(117.83,73.67) ; v5(65.89,79.87) v4(65.89,80.35) ; v5(56.04,66.46) 56.17,66.46 56.5,66.79 v4(56.52,66.79) ; v5(106.15,71.11) 106.15,71.03 106.47,70.72 v4(106.47,70.71) ; v4(105.77,69) 105.99,68.78 v5(105.99,68.5) ; v5(113.76,67.02) 113.69,67.02 v4(113.14,67.57) ; v4(97.75,58.43) 97.77,58.43 v5(98.13,58.79) ; v4(109.31,74.82) 109.29,74.81 v5(109.29,74.02) ; v5(56.75,65.01) 56.93,65.01 v4(57.18,64.76) ; v4(69.43,62.04) 69.63,61.84 v5(69.63,61.58) ; v5(62.85,77.03) v4(62.85,77.66) ; v5(106.52,70.19) 106.52,70.19 106.75,69.96 v4(106.96,69.96) ; v4(54.16,76.03) 54.13,76.01 v5(53.68,76.01) ; v5(55.28,77.26) 55.28,77.66 55.23,77.71 v4(55.23,77.76) ; v5(58.06,72.24) 58.06,72.26 58.4,72.6 v4(58.4,72.62) ; v4(101.58,71.82) 101.51,71.82 101.18,72.15 v5(101.18,72.16) ; v4(97.48,60.25) 97.07,60.25 v5(96.97,60.35) ; v4(55.48,67.6) 55.28,67.6 v5(55.05,67.37) ; v5(109.45,67.65) 109.45,67.66 109.19,67.92 v4(109.05,67.92) ; v4(72.96,69.96) 73.29,69.63 v5(73.29,69.61) ; v5(57.36,58.59) 57,58.59 v4(56.85,58.74) ; v4(52.92,60.06) v5(53.3,60.44) ; v5(67.57,74.79) v4(67.06,74.79) ; v4(103.97,74.84) 104.01,74.88 v5(104.46,74.88) ; v5(101.57,72.3) 102.04,72.3 v4(102.06,72.33) ; v4(63.86,62.37) 63.84,62.34 63.84,62.32 v5(63.51,61.99) ; v5(65.79,74.77) v4(65.29,74.77) ; v5(108.84,71.79) v4(108.27,71.79) ; v4(103.06,72.42) 102.94,72.3 v5(102.57,72.3) ; v5(108.47,50.89) 108.41,50.89 108.01,50.48 v4(108.01,50.41) ; v4(76.44,69.02) 76.97,69.56 v5(76.99,69.56) ; v5(57.08,71.53) v4(57.08,71.05) ; v4(52.33,66.97) 52.74,66.97 v5(52.81,66.89) ; v5(59.65,62.09) 59.52,62.22 v4(59.16,62.22) ; v4(105.14,67.55) 105.02,67.68 v5(104.63,67.68) ; v5(51.85,65.87) 51.44,65.87 v4(51.37,65.95) ; v4(56.85,57.52) 56.88,57.52 57.18,57.82 v5(57.28,57.82) ; v5(58.01,69.94) v4(58.01,69.46) ; v5(111.46,68.95) 111.46,69.41 v4(111.41,69.46) ; v5(54.76,69.95) v4(54.76,69.46) ; v5(116.32,66.88) 115.85,66.88 v4(115.82,66.91) ; v5(103.77,75.86) v4(104.25,75.86) ; v4(106.62,63.86) 106.62,63.86 106.24,64.24 v5(106.14,64.24) ; v4(58.71,61.86) 58.63,61.86 v5(58.33,62.17) ; v4(73.49,61.25) v5(73.97,61.25) ; v5(106.79,74.44) 106.79,74.43 106.53,74.43 v4(106.15,74.82) ; v5(101,73.57) v4(101,74.1) ; v4(70.21,34.46) 70.01,34.25 v5(69.76,34.25) ; v5(57.53,61.57) 57.78,61.81 v4(58,61.81) ; v5(97.41,66.45) 97.41,65.3 v4(97.44,65.27) ; v4(48.88,79.57) 48.85,79.57 v5(48.5,79.21) ; v4(105.02,71.61) 105.4,71.23 105.4,71.18 v5(105.42,71.16) ; v4(79.31,66.38) v5(78.82,66.38) ; v4(73.72,39.59) v5(73.72,40.07) ; v5(54.64,58.74) 54.62,58.74 54.64,58.71 v4(54.64,58.25) ; v4(104.95,71.02) 104.49,71.02 v5(104.47,71.05) ; v5(68.54,63.54) v4(68.18,63.18) ; v4(56.06,64.99) 55.53,64.99 v5(55.46,65.06) ; v5(73.24,60.41) 73.01,60.64 v4(73.01,60.9) ; v5(106.08,71.77) v4(105.59,71.77) ; v4(59.39,70.45) 60.22,70.45 v5(60.25,70.48) ; v4(55.4,61.35) 55.4,61.4 55.73,61.73 v5(55.73,61.73) ; v4(110.23,74.81) 110.16,74.81 109.84,74.49 v5(109.84,74.44) ; v5(56.02,69.92) v4(56.02,69.43) ; v4(99.18,75.01) 99.18,74.99 98.77,74.58 v5(98.77,74.58) ; v4(58.55,63.69) v5(58.07,63.69) ; v5(69.35,74.79) v4(69.86,74.79) ; v5(106.15,66.87) 106.15,66.92 106.31,67.08 v4(106.31,67.38) ; v4(113.48,65.7) 113.78,65.99 v5(113.96,65.99) ; v4(94.77,62.6) 94.77,62.46 v5(95.17,62.05) ; v4(100.36,75.02) 100.41,75.02 v5(100.74,75.35) ; v4(214.87,74.59) 214.94,74.59 v5(215.3,74.94) ; v5(71.51,73.59) 71.04,73.59 v4(71.03,73.57) ; v5(115.73,50.58) 115.27,50.58 v4(115.25,50.56) ; v5(54.62,65.54) 54.62,65.42 v4(54.9,65.14) ; v5(76.28,70.17) v4(76.28,70.65) ; v5(102.19,75.86) v4(101.58,75.86) ; v4(59.36,71.41) 59.44,71.41 59.48,71.36 59.44,71.36 59.84,70.96 v5(59.84,70.95) ; v4(62.62,63.41) v5(63.13,63.41) ; v5(52.46,75.02) v4(52.46,75.53) ; v4(70.67,74.75) v5(71.15,74.75) ; v5(55.79,71.53) v4(55.79,71.04)
  IN4 w0.279: v5(103.16,76.33) v4(103.64,76.33) ; v5(99.91,76.33) v4(99.91,76.87) ; v4(82.46,75.97) 82.48,75.95 v5(82.48,75.48) ; v5(104.78,76.33) v4(105.26,76.33) ; v5(106.41,76.33) v4(105.92,76.33) ; v5(102.37,76.33) v4(101.89,76.33)
  IN4 w0.305: v5(58.94,73.22) v4(58.45,73.22) ; v5(76.79,64.63) 77.48,65.32 77.48,65.29 v4(77.5,65.27) ; v5(59.57,64.12) v4(59.04,64.12) ; v5(70.72,78.37) v4(70.72,78.85) ; v5(76.84,70.85) 76.49,71.21 v4(76.33,71.21) ; v5(75.11,73.57) v4(75.78,73.57) ; v5(59.98,73.62) v4(59.49,73.62) ; v5(54.77,73.85) v4(55.13,73.49) ; v5(75.9,72.43) 75.9,72.86 v4(76.21,73.16) ; v5(66.68,74.03) v4(66.68,73.52) ; v4(58.17,60.79) 58.22,60.85 v5(58.22,61.3) ; v5(64.9,74.03) 64.88,74 v4(64.88,73.52) ; v4(68.48,73.55) 68.48,74 v5(68.46,74.03) ; v4(72.96,64.73) 72.8,64.58 v5(72.47,64.58) ; v5(72.37,71.44) 72.37,72.2 v4(72.42,72.25) 72.8,72.25 v5(72.91,72.35) ; v5(72.07,62.94) 72.07,63.36 72.6,63.89 v4(72.6,63.87) ; v5(63.02,65.37) 62.67,65.01 v4(62.67,64.99) ; v5(76.3,67.14) 76.28,67.14 75.85,66.71 v4(75.75,66.71) ; v5(74.61,65.8) 74.61,65.34 v4(74.66,65.29) ; v5(58.71,66) 58.1,66 v4(57.72,65.62) ; v5(74.73,66.48) v4(75.22,66.48) ; v5(74.2,74.82) v4(74.68,74.82) ; v5(62.16,74.38) v4(61.68,74.38) ; v4(57.91,73.37) 57.42,73.37 v5(57.41,73.39) ; v5(71.41,71.11) v4(71.41,70.62) ; v5(69.25,66.13) 69.02,65.9 v4(68.74,65.9) ; v4(76.97,67.48) 76.82,67.48 76.44,67.86 76.44,68.26 v5(76.46,68.29) ; v5(72.55,68.8) 72.17,69.18 v4(72.22,69.18) ; v4(70.24,73.55) 70.24,73.7 v5(70.54,74) ; v5(70.39,65.49) v4(70.39,65.98) ; v5(74.68,69.63) 74.68,70.45 v4(74.76,70.52) ; v5(73.11,73.57) v6(73.59,73.57) ; v5(70.39,66.54) v4(70.87,66.54) ; v5(69.45,63.94) v4(69.45,63.46) ; v5(72.55,65.39) v4(73.03,65.39) ; v5(69.78,64.66) v4(70.26,64.66) 70.39,64.78 v5(71,64.78) ; v5(66.22,65.57) 66.22,65.19 66.07,65.04 v4(66.05,65.04) ; v5(73.72,72.35) 73.74,72.35 74,72.1 v4(74.2,72.1) ; v5(74.4,68.26) 73.92,68.26 73.9,68.29 v4(73.9,68.31) ; v4(71.64,63.64) 71.33,63.94 v5(71.2,63.94) ; v5(61.35,74.03) v4(61.35,73.52) ; v5(75.5,68.92) v6(75.14,69.28) ; v5(63.12,74.03) v4(63.12,73.52) ; v5(61.45,64.1) v4(61.83,64.48) ; v5(66.68,64.3) v4(65.59,64.3) ; v5(73.39,66.84) v4(73.87,66.84) ; v5(72.93,67.73) v4(72.45,67.73) ; v5(73.95,68.8) v4(73.59,69.15) ; v5(58.35,73.95) v4(57.84,73.95) ; v5(71.89,69.63) v4(71.53,69.99)
  IN4 w0.508: v4(178.34,35.7) 178.77,36.13 v5(178.77,36.16) ; v4(131.38,39.54) v5(131.38,40.09) ; v4(18.65,41.11) v5(17.94,41.11) ; v4(132.39,42.38) v5(131.88,42.38) ; v5(47.81,47.46) 47.81,47.61 48.13,47.94 48.17,47.94 v4(48.19,47.96) ; v4(180.3,77.36) 180.37,77.43 v5(181.01,77.43) ; v4(132.52,41.44) v5(132.01,41.44) ; v4(176.21,71.46) 176.59,71.84 v5(176.59,72.1)
  GND5 w0.076: 115.07,73.42 115.16,73.33 115.16,73.22 115.42,72.95 v6(115.88,72.95)
  GND5 w0.254: v6(106.84,75.47) 106.84,75.73 v5(106.71,75.86) ; v6(101.57,72.71) v5(101.57,72.3) ; v6(72.98,69.96) 72.98,69.91 v5(73.29,69.61) ; v5(104.47,72.24) 104.58,72.14 v6(104.58,71.85) ; v6(100.58,73.57) v5(101,73.57) ; v6(57.74,71.93) 57.75,71.93 v5(58.06,72.24) ; v6(103.48,74.44) 103.56,74.36 v5(103.89,74.36) ; v6(76.28,69.58) v5(76.28,70.17) ; v6(108.87,50.81) 108.8,50.89 v5(108.47,50.89) ; v6(99.61,74.44) 99.93,74.44 v5(100.03,74.54) ; v5(109.45,67.65) 109.73,67.93 v6(109.73,68.1) ; v5(101.43,56.53) 101.43,56.86 v6(101.55,56.98) ; v6(72.49,62.94) v5(72.07,62.94) ; v5(113.76,67.02) 113.56,67.23 v6(113.56,67.41) ; v6(77.25,69.23) 77.25,69.3 v5(76.99,69.56) ; v5(58.01,69.94) 57.71,69.65 v6(57.7,69.65) ; v6(56.43,71.94) v5(56.43,71.53) ; v6(71.99,75.25) v5(71.99,75.68) ; v6(96.13,72.95) 95.74,72.95 v5(95.73,72.94) ; v6(103.13,70.63) 103.13,70.46 v5(103.35,70.23) ; v6(109.28,71.85) 108.9,71.85 v5(108.84,71.79) ; 56.02,69.92 v5(56.02,69.92) ; v5(102.19,75.86) 101.96,75.63 v6(101.96,75.47) ; v6(53.68,76.44) v5(53.68,76.01) ; v6(98.31,58.33) v5(98.71,58.33) ; v5(116.28,63.2) v6(115.87,63.2) ; v6(55.72,69.64) 55.73,69.64 ; v6(52.9,70.77) v5(52.9,71.17) ; v6(97.41,66.04) v5(97.41,66.45) ; v5(101.18,72.16) 101.18,72.15 ; v6(103.13,68.12) 103.37,68.36 v5(103.37,68.48) ; v5(58.22,61.3) 58.22,60.95 v6(57.86,60.58) ; v6(96.98,68.89) 97.14,68.73 v5(97.14,68.47) ; v6(57.07,69.67) 57.07,69.67 v5(57.37,69.96) ; v6(62.85,77.43) v5(62.85,77.03) ; v6(71.56,74.75) v5(71.15,74.75) ; v5(55.73,61.73) 55.42,61.42 v6(55.42,61.19) ; v6(104.45,67.27) 104.63,67.45 v5(104.63,67.68) ; v5(99.96,73.6) v6(99.54,73.6) ; 97.73,75.46 v6(97.85,75.46) 97.87,75.44 v5(97.87,74.99) ; v6(109.07,63.08) 108.79,63.08 v5(108.66,63.2) ; v6(68.46,79.41) v5(68.46,79.82) ; v5(115.44,66.58) 115.44,66.05 v6(115.45,66.04) ; v6(98.03,59.21) 98.13,59.11 v5(98.13,58.79) 98.1,58.79 ; v6(100.34,75.47) 100.63,75.47 v5(100.74,75.35) ; v6(106.43,63.93) 106.43,63.95 v5(106.14,64.24) ; v5(106.08,71.77) 105.77,71.46 v6(105.77,71.45) ; v5(109.84,74.44) v6(110.25,74.44) ; v5(103.77,75.86) 103.59,75.68 v6(103.59,75.47) ; v6(59.84,71.36) v5(59.84,70.95) ; v5(105.54,70.27) 105.77,70.5 v6(105.77,70.63) ; 106.43,70.64 v6(106.43,70.63) ; v5(96.21,69.29) 96.21,69.61 v6(96.12,69.7) ; v5(116.32,66.88) 116.71,66.49 116.72,66.49 v6(116.72,66.45) ; v6(102.51,72.71) 102.51,72.37 v5(102.57,72.3) ; v5(105.99,68.5) 105.99,68.72 v6(105.77,68.94) ; v6(105.21,75.47) 105.21,75.6 v5(105.44,75.83) ; v6(59.81,70.48) v5(60.25,70.48) ; v6(105.41,74.44) 105.59,74.62 v5(105.59,74.84) ; v5(111.91,66.18) 111.83,66.1 v6(111.83,65.56) ; v5(103.41,71.64) 103.6,71.64 v6(103.79,71.45) ; v6(100.62,71.76) 100.69,71.68 v5(101.09,71.68) ; v6(116.01,50.89) 115.73,50.61 v5(115.73,50.58) ; v6(48.72,78.65) 48.39,78.65 v5(48.27,78.78) ; v5(104.47,71.05) 104.45,71.07 v6(104.45,71.46) ; v6(106.43,67.27) 106.15,66.99 v5(106.15,66.87) ; v6(66.81,80.2) v5(66.81,79.79) ; v5(69.35,74.79) v6(69.35,75.2) ; v5(106.52,70.19) 106.43,70.1 v6(106.43,69.79) ; v5(102.98,74.44) v6(102.53,74.44) ; v5(102.18,70.43) 102.4,70.64 v6(102.64,70.64) ; v5(100.62,68.29) 100.65,68.32 v6(101.03,68.32) ; v6(98.01,68.86) 98.01,68.86 98.23,68.64 v5(98.41,68.64) ; v6(48.25,79.62) 48.5,79.37 v5(48.5,79.21) ; v6(104.02,60.61) 104.02,60.28 v5(104.09,60.21) ; v5(73.29,75.5) v6(73.29,75.1) ; v5(107.04,66.85) 107.09,66.8 v6(107.09,66.42) ; v6(55.14,71.94) v5(55.14,71.52) ; v5(108.87,75.37) 108.78,75.47 v6(108.46,75.47) ; v6(57.08,71.94) v5(57.08,71.53) ; v5(105.42,71.16) 105.4,71.16 v6(105.11,71.45) ; v6(104.46,74.44) v5(104.46,74.88) ; v6(72.45,74.28) 72.45,74.26 v5(72.17,73.98) ; v6(97.94,65) v5(98.37,65) ; v6(98.02,73.69) 98.02,73.77 v5(98.33,74.08) ; 54.46,69.67 v6(54.46,69.66) ; v6(106.43,68.94) v5(106.43,68.52) ; v6(72.62,72.71) 72.91,72.42 v5(72.91,72.35) ; v5(106.79,74.44) v6(106.37,74.44) ; v6(108.32,74.44) v5(107.91,74.44) ; v6(98.3,74.58) v5(98.77,74.58) ; 99.12,76.64 v5(99.5,76.26) ; v6(65.79,75.2) v5(65.79,74.77) ; v6(111.05,68.95) v5(111.46,68.95) ; v6(100.64,59.3) 100.67,59.32 v5(100.67,59.71) ; v5(106.15,71.11) 106.15,70.91 ; v6(66.25,64.4) 66.35,64.3 v5(66.68,64.3) ; v6(100.17,70.25) v5(100.17,69.67) ; v6(55.8,64.83) 55.58,65.06 v5(55.46,65.06) ; v6(110.09,75.22) 110.34,75.22 v5(110.48,75.36) ; v6(65.79,79.46) 65.79,79.77 v5(65.89,79.87) ; v6(55.79,71.94) v5(55.79,71.53) ; v5(54.76,69.95) 54.76,69.97 ; v6(52.05,75.02) v5(52.46,75.02) ; v6(64.04,75.19) v5(64.04,74.76) ; v6(62.85,78.07) v5(63.25,78.07) ; v6(67.57,75.2) v5(67.57,74.79) ; v5(52.5,69.87) v6(52.09,69.87) ; v5(98.28,75.47) v6(98.71,75.47) ; v6(97.55,60.35) v5(96.97,60.35) ; 101.51,71.82 v6(101.65,71.82) ; v6(71.93,73.59) v5(71.51,73.59) ; v6(64.86,80.2) v5(64.86,79.79) ; v6(103.79,66.43) v5(103.79,66.03) ; v5(55.28,77.26) v6(54.85,77.26) ; v6(109.29,74.44) v5(109.29,74.02)
  GND5 w0.279: v6(105.21,76.33) v5(104.78,76.33) ; v6(82.53,75.97) 82.48,75.92 v5(82.48,75.48) ; v6(103.59,76.33) v5(103.16,76.33) ; v6(100.34,76.33) v5(99.91,76.33) ; v6(101.96,76.33) v5(102.37,76.33) ; v5(106.41,76.33) 106.41,76.75 v6(106.43,76.77)
  GND5 w0.305: v6(70.8,66.54) v5(70.39,66.54) ; v6(73.08,66.54) v5(73.39,66.84) ; v5(57.41,73.39) 57.31,73.49 v6(57,73.49) ; v6(58.94,73.62) v5(58.94,73.22) ; v6(61.78,64.43) v5(61.45,64.1) ; v6(70.24,73.62) 70.24,73.7 v5(70.54,74) ; v6(70.7,65.06) 70.97,64.78 v5(71,64.78) ; v5(72.37,71.44) 72.62,71.68 v6(72.62,71.82) ; v6(76.31,67.88) 76.46,68.03 v5(76.46,68.29) ; v5(54.77,73.85) 55.05,73.57 v6(55.07,73.57) ; v6(72.93,67.32) v5(72.93,67.73) ; v6(63.12,73.62) v5(63.12,74.03) ; v5(68.46,74.03) 68.48,74 v6(68.48,73.62) ; v6(74.33,66.48) v5(74.73,66.48) ; v6(76.84,71.26) v5(76.84,70.85) ; v6(68.87,65.85) 69.15,66.13 v5(69.25,66.13) ; v5(64.9,74.03) 64.88,74 v6(64.88,73.62) ; v5(72.55,65.39) 72.4,65.54 v6(72.4,65.8) ; v6(59.11,66) v5(58.71,66) ; v6(71.58,69.99) 71.58,69.94 v5(71.89,69.63) ; v6(59.94,64.49) v5(59.57,64.12) ; v6(70.72,77.89) v5(70.72,78.37) ; v5(71.2,63.94) 71.38,63.94 v6(71.61,63.72) ; v6(73.99,68.26) v5(74.4,68.26) ; v6(76.94,65.04) 76.94,64.78 v5(76.79,64.63) ; v6(69.78,65.09) v5(69.78,64.66) ; v6(66.68,73.62) v5(66.68,74.03) ; v6(71.41,70.7) v5(71.41,71.11) ; v6(74.2,74.41) v5(74.2,74.82) ; v6(58.35,74.36) v5(58.35,73.95) ; v5(73.72,72.35) 73.99,72.62 v6(73.99,72.71) ; v6(73.59,73.57) v5(73.11,73.57) ; v5(74.68,69.63) 74.35,69.96 v6(74.35,70.02) ; v6(76.3,66.73) v5(76.3,67.14) ; v6(61.35,73.62) v5(61.35,74.03) ; v5(63.02,65.37) v6(62.72,65.06) ; v6(69.76,64.25) v5(69.45,63.94) ; v6(75.11,73.15) v5(75.11,73.57) ; v6(72.24,69.1) v5(72.55,68.8) ; v6(66.22,65.16) v5(66.22,65.57) ; v6(75.14,69.28) v5(75.5,68.92) ; v6(74.2,65.8) v5(74.61,65.8) ; v6(61.75,74.38) v5(62.16,74.38) ; v6(75.9,72.83) v5(75.9,72.43) ; v6(70.7,65.8) v5(70.39,65.49) ; v5(73.95,68.8) v6(73.64,69.1) ; v6(59.57,73.62) v5(59.98,73.62) ; v6(72.47,64.99) v5(72.47,64.58)
  GND5 w0.381: v6(113.56,66.4) 113.96,65.99 v5(113.96,65.99)
  GND5 w0.508: v6(178.77,35.75) v5(178.77,36.16) ; v6(48.19,47.97) 47.81,47.59 v5(47.81,47.46)
  BOTTOM w0.127: v9(174.58,75.13) 173.76,75.95 v7(173.29,75.95) ; v6(81.07,71.68) 81.05,71.7 81.05,72.05 80.68,72.42 UCPU1.R4
  BOTTOM w0.203: v7(185.17,78.68) 185.24,78.75 JLVDS2.1 ; JMDP1.8 v6(219.39,72.2) ; UCPU1.AY36 65.01,60.85 65.56,61.41 v6(65.56,61.42)
  BOTTOM w0.254: UD13.N1 39.53,28.85 v10(39.95,28.43) ; UD16.B8 UD15.B2 ; UD16.B8 v6(28.08,38.08) ; UD16.B8 27.68,37.69 v10(27.31,38.05) ; UCPU1.AL13 76.63,65.35 v6(76.94,65.04) ; UCPU1.AC10 77.59,68.89 v6(77.25,69.23) ; JIOL1.10 v7(16.1,23.84) 16.39,23.84 16.6,24.05 JIOL1.12 ; v6(48.72,78.65) 48.72,78.64 48.27,78.19 RC52.2 ; v6(53.95,70.15) 53.9,70.2 UCPU1.Y58 ; UH1.P4 v6(111.31,57.01) UH1.P2 ; 71.65,32.73 71.52,32.6 71.52,32.62 v10(71.12,33.02) 71.5,33.4 UD7.A8 ; 71.65,32.73 UD7.B8 ; 71.65,32.73 72.19,32.73 UD7.B7 ; UD12.B8 49.78,37.71 v10(49.41,38.08) ; UD12.B8 v6(50.18,38.08) ; UD12.B8 UD11.B2 ; v10(21.52,35.85) 21.85,35.85 UD15.D9 22.48,36.48 ; UCPU1.BD56 55.1,58.81 v6(54.79,59.12) 54.79,60.29 54.68,60.4 ; UH1.BH6 v6(97.42,57.87) ; v6(52.04,67.03) UCPU1.AG61 ; UCPU1.F29 67.78,77.25 v6(67.47,77.56) ; UH1.K50 v6(112.93,75.88) UH1.K48 ; v10(71.12,25) 70.72,25.39 UD7.L9 ; UD5.B8 82.7,32.73 ; UD5.B8 82.69,32.73 82.7,32.73 ; UD5.B8 82.57,32.62 v10(82.17,33.02) 82.55,33.4 UD5.A8 ; 82.7,32.73 83.24,32.73 UD5.B7 ; v10(32.74,32.46) 33.12,32.08 UD13.J9 ; UD15.D8 22.48,36.48 ; 22.48,36.48 UD15.C9 ; UCPU1.BA32 67.24,60.16 67.56,60.48 UCPU1.AY30 67.63,60.49 67.86,60.26 v6(67.86,60.18) ; UCPU1.BD32 v6(67.03,58.14) ; UD11.B1 50.58,37.68 v6(50.18,38.08) ; UH1.AB48 v6(108.46,75.47) ; v6(80.21,60.56) 80.37,60.72 UCPU1.AY4 ; UH1.V7 v6(109.81,58.89) UH1.V9 ; UH1.BA36 v6(99.72,70.79) ; UCPU1.T56 54.76,72.24 54.48,71.96 54.48,71.96 v6(54.48,71.95) ; UD11.A8 44.95,38.48 v10(44.57,38.1) 44.98,37.7 UD11.B8 ; UD3.L1 v10(99.62,25) ; UH1.AV50 v6(101.96,76.33) ; UH1.D34 v6(115.45,69.29) ; UD6.B8 87.37,32.63 v10(87,33) ; UD6.B8 UD5.B2 ; UD6.B8 v6(87.77,33) ; UD9.A8 56,38.48 v10(55.62,38.1) 56.02,37.7 56.02,37.68 56.15,37.81 ; UH1.BA9 v6(100.16,59.76) UH1.BA11 ; UCPU1.AA55 55.42,69.97 v6(55.12,69.67) ; UD1.A8 104.64,33.4 v10(104.26,33.02) 104.67,32.62 UD1.B8 ; UCPU1.AT14 76,62.77 UCPU1.AR13 76.35,63.1 v7(76.72,63.46) ; UCPU1.AM13 76.63,64.34 v7(76.33,64.05) ; UCPU1.E35 65.69,77.87 v6(66,78.17) ; 54.68,60.4 54.91,60.4 UCPU1.AY55 55.42,60.91 v6(55.42,61.19) UCPU1.AV55 ; 54.68,60.4 54.3,60.4 v6(54.29,60.39) 54.05,60.39 UCPU1.AY58 ; UCPU1.AJ45 60.48,66.14 v6(60.85,66.52) ; v6(61.17,58.13) 61.11,58.19 UCPU1.BD44 ; UH1.N31 111.83,68.4 v6(111.82,68.39) 111.82,67.91 UH1.N29 ; v6(75.39,61.02) 75.6,60.82 UCPU1.AY14 76.09,61.15 UCPU1.AW13 ; UH1.N39 v6(111.74,72.28) UH1.N41 ; UCPU1.AN47 59.57,64.12 v6(59.94,64.49) 60.19,64.49 UCPU1.AM45 ; v6(55.8,64.83) UCPU1.AN54 55.8,64.01 UCPU1.AP55 ; v6(79.93,58.65) 80.14,58.86 80.14,59.12 UCPU1.BC5 ; v6(72.9,58.12) 72.9,58.16 72.89,58.16 72.89,58.48 72.96,58.55 UCPU1.BD19 ; 161.27,78.68 161.16,78.68 160.75,79.1 JLVDS1.12 ; 161.27,78.68 161.27,79.66 JLVDS1.11 ; 161.27,78.68 v7(161.28,78.68) ; UH1.BK10 v6(96.55,60.35) ; 56.15,37.81 56.7,37.81 UD9.B7 ; 56.15,37.81 UD9.B8 ; v10(75.95,33) 76.32,32.63 76.32,32.6 ; UCPU1.AJ7 v6(79.18,66.79) UCPU1.AG7 ; UD2.B8 109.47,32.63 v10(109.1,33) ; UD2.B8 UD1.B2 ; UD2.B8 v6(109.87,33) ; UCPU1.BG9 v6(78.33,56.72) ; UH1.G43 v6(114.42,73.2) UH1.G41 ; UCPU1.T55 55.42,72.22 55.14,71.94 v6(55.14,71.94) ; JLVDS1.1 v7(166.25,78.68) ; UH1.AH2 v6(105.62,56.02) ; UCPU1.BB53 56.42,59.44 v6(56.69,59.72) 56.69,59.74 57.04,60.09 UCPU1.BA51 ; UCPU1.AF1 82.27,68.07 v6(82.48,67.86) ; UCPU1.T50 58.02,72.21 57.77,71.96 57.77,71.95 57.74,71.93 v6(57.74,71.93) ; UH1.BE13 v6(98.44,60.73) ; v7(57.81,64.82) 57.81,64.3 UCPU1.AN50 57.75,64.01 UCPU1.AP51 ; UH1.AW11 v6(101.12,59.73) UH1.AW9 ; UD7.C9 71.12,31.4 ; 71.12,31.4 71.12,31.4 UD7.D9 70.49,30.77 v10(70.16,30.77) ; 71.12,31.4 71.52,31 UD7.D8 ; 104.24,31.37 UD1.D9 103.64,30.77 v10(103.31,30.77) ; 104.24,31.37 104.29,31.37 UD1.D8 ; 104.24,31.37 103.87,31.75 UD1.C9 ; JIOL1.30 v7(21.1,25.72) ; UH1.J16 v6(113.56,62.53) UH1.J18 ; UH1.D10 UH1.B10 v6(116.31,59.54) ; UD13.D8 33.93,36.08 33.53,36.48 ; UH1.BE23 v6(97.94,65) ; UH1.AJ7 v6(105.39,58.46) ; UH1.AK2 v6(104.81,56.98) UH1.AK4 ; UD5.J1 89.16,26.01 v10(89.16,25.81) ; UH1.AV48 v6(101.96,75.47) ; v6(72.39,61.41) UCPU1.AV21 71.62,61.09 UCPU1.AV22 ; UH1.L39 v6(112.69,72.21) 112.69,72.7 UH1.L41 ; UCPU1.AW61 v6(52.04,61.1) ; UD7.L1 v10(77.52,25) ; UD5.N1 88.17,23.77 v10(88.59,23.35) ; v6(63.52,61.12) UCPU1.AV40 ; UD13.J1 40.51,31.09 v10(40.51,30.89) ; UH1.BE41 v6(98.44,73.14) ; 60.83,37.68 UD9.B2 ; 60.83,37.68 v6(61.23,38.08) ; 60.83,37.68 60.83,37.74 v10(60.48,38.08) ; v6(61.23,38.08) 61.63,37.68 UD9.B1 ; v6(61.23,38.08) UD9.A1 ; v6(52.88,72.89) 53.14,73.14 UCPU1.P59 ; v6(80.44,63.07) 80.45,63.06 80.45,63.06 80.68,62.83 UCPU1.AT4 ; v7(60,62.8) 60.36,62.45 UCPU1.AT45 ; UH1.J27 v6(113.56,66.4) UH1.J25 ; UH1.BK38 v6(96.12,71.32) ; UD11.B8 45.1,37.81 ; UD11.B8 45.1,37.81 45.1,37.81 ; 45.1,37.81 45.65,37.81 UD11.B7 ; JLVDS1.4 v7(164.75,78.65) ; UH1.J21 v6(113.56,64.52) UH1.J23 ; v10(104.26,25) 103.87,25.39 UD1.L9 ; UH1.BK42 v6(96.13,72.95) ; v10(103.48,27.38) 103.86,27 UD1.J9 ; UCPU1.AU11 77.71,61.8 v6(77.92,61.8) ; v7(61.02,69.53) 60.63,69.15 UCPU1.AC46 ; UCPU1.D29 68.17,78.49 v6(68.54,78.85) ; UH1.AL7 v6(104.02,58.89) ; v7(19.39,23.81) 19.1,24.1 JIOL1.22 ; UH1.P48 111.15,75.47 v6(110.85,75.17) ; UH1.BH10 97.41,59.95 97.41,60.22 97.55,60.36 v6(97.55,60.35) ; UD15.J1 29.47,31.09 v10(29.47,30.89) ; UH1.BA41 v6(100.58,72.72) ; UCPU1.A37 v6(64.86,80.2) ; UD9.D1 62.29,36.08 62.31,36.11 62.31,36.13 v7(62.34,36.16) ; UH1.AE7 v6(106.91,58.89) UH1.AE9 ; UH1.BH38 v6(97,71.32) ; UCPU1.E61 52.59,77.74 v6(52.92,78.07) ; UH1.N7 v6(111.74,58.89) UH1.N9 ; UH1.BK14 v6(96.55,61.98) ; UCPU1.J49 v6(57.84,75.96) ; UD7.A1 v6(76.72,33) ; v6(76.72,33) 77.12,32.6 UD7.B1 ; v6(76.72,33) 76.32,32.6 ; v6(82.86,69.84) 82.65,70.04 UCPU1.AA1 ; UH1.AP48 v6(103.59,75.47) ; UD15.B8 23,37.81 23.01,37.81 ; UD15.B8 22.88,37.7 v10(22.48,38.1) 22.86,38.48 UD15.A8 ; UD15.B8 23.01,37.81 ; 44.63,36.43 44.52,36.43 UD11.D9 43.95,35.85 v10(43.64,35.85) ; 44.63,36.43 UD11.D8 ; 44.63,36.43 UD11.C9 ; UH1.BH14 v6(97.41,61.98) ; UH1.AP43 v6(103.47,73.57) ; 33.53,36.48 33.53,36.48 UD13.D9 32.9,35.85 v10(32.57,35.85) ; 33.53,36.48 UD13.C9 ; JIOL1.11 16.6,20.83 v7(16.57,20.87) ; v10(22.48,30.08) 22.08,30.47 UD15.L9 ; UH1.AP2 v6(103.18,56.98) UH1.AP4 ; v6(80.25,70.6) UCPU1.Y4 ; UH1.BA7 v6(99.65,58.46) ; v6(62.85,77.43) 63.1,77.18 UCPU1.F40 ; UCPU1.BA11 77.67,60.09 v6(77.92,60.35) 78.33,60.76 UCPU1.AY9 ; v10(38.36,38.08) 38.73,37.71 38.73,37.68 ; UH1.AF48 v6(106.84,75.47) ; UCPU1.AU28 68.54,62.1 v6(68.22,61.78) ; UCPU1.AY19 72.65,60.74 v6(72.36,60.46) 72.02,60.11 UCPU1.BA21 ; UCPU1.AK1 v6(82.1,65.67) ; UCPU1.AW43 61.5,61.22 v6(61.08,60.81) 60.77,60.5 UCPU1.AY45 ; UCPU1.G61 52.28,76.97 v6(52.1,77.15) ; UH1.BK26 v6(96.55,66.04) ; 98.42,32.6 98.42,32.63 v10(98.05,33) ; 98.42,32.6 UD3.B2 ; 98.42,32.6 v6(98.82,33) ; UH1.G13 v6(114.42,60.63) UH1.G11 ; UH1.BC36 v6(98.9,70.79) ; UCPU1.AA51 57.37,69.97 v6(57.07,69.67) ; UCPU1.AA50 58.02,69.97 v6(57.7,69.65) ; 38.73,37.68 v6(39.13,38.08) ; 38.73,37.68 UD13.B2 ; v6(39.13,38.08) 39.53,37.68 UD13.B1 ; v6(39.13,38.08) UD13.A1 ; v10(70.32,24.2) 70.72,23.8 UD7.N9 ; UH1.AV4 v6(101.55,56.98) UH1.AV2 ; UH1.BC13 v6(99.31,61.65) ; UCPU1.AR41 62.61,63.43 v6(62.73,63.55) 63.12,63.94 UCPU1.AN40 ; UCPU1.BA1 v6(82.61,60.16) ; UH1.B26 v6(116.72,66.45) ; UD11.L9 44.18,30.47 v10(44.57,30.08) ; UH1.L23 v6(112.69,64.52) UH1.L21 ; C1138.2 132.46,79.19 v7(132.04,79.62) ; UH1.BA31 v6(100.58,68.86) ; UH1.AW36 v6(100.58,70.79) ; UH1.L43 v6(112.71,73.98) UH1.L45 ; UH1.AB4 v6(108.06,57.01) UH1.AB2 ; UCPU1.AG10 77.88,67.09 v7(77.63,66.84) ; UH1.AJ9 v6(104.98,59.75) ; UCPU1.BC61 v6(52.09,59.22) ; UCPU1.A40 62.91,79.81 63.2,80.1 v6(63.2,80.15) ; v7(59.44,61.61) 59.25,61.8 UCPU1.AV48 ; 156.52,80.86 v7(157.41,80.86) ; UD13.L1 v10(39.93,30.08) ; UD3.B1 99.22,32.6 v6(98.82,33) ; v7(57.79,77.84) 57.79,77.94 57.74,77.99 UCPU1.D50 ; UCPU1.C29 68.19,79.14 v6(68.46,79.41) ; UH1.V11 v6(109.81,60.59) ; UD1.N9 v10(103.47,24.2) ; UCPU1.AE8 78.63,68.32 v6(79,67.96) ; UCPU1.AH58 53.9,66.56 54.2,66.86 v6(54.33,66.86) ; UH1.D26 v6(115.45,66.04) ; UCPU1.BD16 v6(74.94,59.04) ; 55.68,36.43 55.57,36.43 UD9.D9 54.9,36.08 v10(54.67,35.85) ; 55.68,36.43 UD9.C9 ; 55.68,36.43 56.02,36.08 UD9.D8 ; UD5.C9 82.17,31.4 ; 82.17,31.4 UD5.D8 ; 82.17,31.4 UD5.D9 81.54,30.77 v10(81.21,30.77) ; UH1.AR8 v6(102.57,59.32) ; UH1.AR6 v6(102.57,58.43) ; UCPU1.D46 v6(59.72,77.94) ; UH1.P50 v6(111.71,76.33) ; UH1.L25 v6(112.69,65.48) ; JIOL1.9 16.1,19.15 v7(16.26,18.99) ; UH1.BA43 v6(100.58,73.57) ; UH1.BH48 v6(97.85,75.46) ; UH1.BB50 v6(100.34,76.33) ; v6(78.15,64.95) 78.15,65.13 77.93,65.35 UCPU1.AL10 ; UD9.N9 55.22,28.88 v10(54.83,29.28) ; v10(51,28.43) 50.58,28.85 UD11.N1 ; v6(28.08,38.08) 28.48,37.68 UD15.B1 ; v6(28.08,38.08) UD15.A1 ; UCPU1.AM4 v6(80.21,64.67) ; UD9.F8 56.03,34.49 v10(55.63,34.89) ; UD13.L9 33.13,30.47 v10(33.52,30.08) ; UCPU1.AB48 v6(58.68,69.15) ; 93.22,31.4 93.62,31 UD3.D8 ; 93.22,31.4 93.22,31.4 UD3.D9 92.59,30.77 v10(92.29,30.77) ; 93.22,31.4 UD3.C9 ; UD15.B7 23.55,37.81 23.01,37.81 ; UCPU1.D54 55.28,78.37 v7(55.23,78.42) ; UH1.J7 v6(113.67,58) ; UH1.D30 v6(115.45,67.67) ; UCPU1.H53 v6(55.84,76.21) ; UCPU1.M58 54.28,74.47 54.31,74.43 v6(54.31,74.47) ; v6(67.67,78.3) 67.67,77.97 67.78,77.86 UCPU1.E29 ; UCPU1.BD36 v6(65.06,58.14) ; v7(47.56,81.8) 47.76,81.8 48.09,82.13 RC86.2 ; v6(60.02,73.11) 59.84,72.94 UCPU1.R46 59.81,72.7 UCPU1.T47 ; v6(55.72,69.64) 56.07,69.98 UCPU1.AA53 ; UH1.AC7 v6(107.88,58.89) UH1.AC9 ; UH1.L13 v6(112.69,61.57) ; UD9.J1 62.61,31.09 v10(62.61,30.89) ; UD9.L9 55.23,30.47 v10(55.62,30.08) ; UH1.L11 v6(112.69,60.66) ; UCPU1.AU1 v6(82.1,61.71) ; v6(54.46,69.66) 54.77,69.97 UCPU1.AA56 ; v6(109.87,33) UD1.A1 ; v6(109.87,33) 110.27,32.6 UD1.B1 ; UD1.N1 110.27,23.77 v10(110.69,23.35) ; UCPU1.D40 62.99,78.47 v6(63.3,78.78) ; UCPU1.BA48 v6(59.26,59.85) ; v6(61.98,78.02) 61.69,78.3 UCPU1.D43 ; UCPU1.T52 56.72,72.23 56.46,71.97 56.46,71.96 v6(56.43,71.94) ; UD5.L1 v10(88.57,25) ; UH1.G27 v6(114.42,66.4) UH1.G25 ; UH1.R37 v6(111.05,71.46) ; UD13.N9 33.13,28.88 v10(32.73,29.28) ; UCPU1.L30 v6(67.57,75.2) ; UH1.K4 v6(112.93,56.99) UH1.K2 ; v7(162.03,72.61) 162.03,73.02 R1034.1 161.4,72.99 v7(161.4,72.61) ; UH1.G21 v6(114.42,64.49) UH1.G23 ; UD1.B8 104.79,32.73 104.79,32.73 ; UD1.B8 104.79,32.73 ; UCPU1.L61 v6(52.05,75.02) ; v6(57.08,71.94) 57.37,72.24 UCPU1.T51 ; UH1.J39 v6(113.56,71.27) ; v6(97.01,73.76) 97.01,73.75 97.02,73.76 UH1.BH44 ; v7(64.37,63) 64.5,62.88 64.85,62.88 UCPU1.AT36 ; UH1.BB4 v6(99.52,57.43) ; v6(97.42,63.6) 97.42,63.2 UH1.BH18 ; UH1.B46 v6(115.88,74.57) UH1.D46 ; D82.7 216.61,57.04 v7(216.77,56.88) ; v10(99.75,31.28) 99.48,31 UD3.D1 ; UCPU1.BG24 v6(70.43,56.72) ; UCPU1.BG21 v6(72.41,56.72) ; UCPU1.BG17 v6(74.38,56.72) ; UH1.B34 v6(116.31,70.1) ; UH1.G31 114.41,68.87 v6(114.41,69.35) 114.42,69.37 UH1.G34 ; 177.74,80.72 JLVDS2.16 ; UH1.BE36 v6(98.02,70.79) ; UCPU1.AN1 v6(82.55,64.12) ; UH1.AK48 v6(105.21,75.47) ; UH1.L16 v6(112.69,62.57) UH1.L18 ; v7(119.9,78.8) 120.11,79.01 CH107.2 ; v6(62.57,79.49) 62.57,79.49 UCPU1.C40 ; 76.32,32.6 UD7.B2 ; UCPU1.AR48 v7(59.42,63.1) ; UCPU1.A45 v6(60.69,79.79) ; v6(69.54,58.96) 69.38,58.96 UCPU1.BD27 ; UH1.AP11 v6(103.05,60.62) ; v6(59.09,77.25) 58.82,76.98 UCPU1.G48 ; UH1.AP7 v6(103.05,58.89) ; v10(99.64,23.35) 99.22,23.77 UD3.N1 ; v6(52.05,73.63) UCPU1.N61 ; UD11.L1 v10(50.98,30.08) ; UH1.G7 114.42,58.79 UH1.G9 v6(114.42,59.65) ; v10(77.54,23.35) 77.12,23.77 UD7.N1 ; v6(87.77,33) 88.17,32.6 UD5.B1 ; v6(87.77,33) UD5.A1 ; UD9.L1 v10(62.03,30.08) ; UD11.J1 51.56,31.09 v10(51.56,30.89) ; UH1.B18 v6(115.87,63.2) UH1.D18 ; UH1.BB2 v6(99.52,56.56) ; UCPU1.AL61 v6(52.04,65.05) ; UH1.U49 v6(110.5,75.9) ; UH1.BE11 v6(98.44,59.76) ; v6(72.98,69.96) 73.3,69.64 UCPU1.AB18 ; v6(65.92,78.78) 65.63,78.49 UCPU1.D35 ; UCPU1.AY41 v6(62.3,60.19) ; v6(56.62,80.07) 56.34,79.79 UCPU1.A53 ; UD3.L9 92.82,25.39 v10(93.21,25) ; UCPU1.BG49 v6(58.57,56.72) ; UCPU1.W46 v6(59.84,71.36) ; v6(50.18,38.08) UD11.A1 ; UH1.J13 v6(113.56,61.58) ; UH1.L9 v6(112.71,58.89) UH1.L7 ; UCPU1.AA8 78.55,69.88 78.21,70.22 v6(78.21,70.37) 78.21,70.6 78.49,70.87 UCPU1.W8 ; UH1.BC25 v6(99.31,65.41) ; 104.79,32.73 105.34,32.73 UD1.B7 ; UD9.N1 61.63,28.85 v10(62.05,28.43) ; UCPU1.BC13 76.33,59.18 UCPU1.BD12 77.12,58.38 v6(77.12,58.18) ; UD15.L1 v10(28.88,30.08) ; v6(116.01,50.89) 116.03,50.91 CH102.1 ; UCPU1.BD48 59.13,58.6 59.43,58.91 v6(59.48,58.91) ; v6(56.75,76.75) 57.07,76.75 UCPU1.G51 ; UH1.AK50 v6(105.21,76.33) ; UH1.BC11 99.31,60.58 99.29,60.6 v6(99.29,60.58) ; 93.74,32.73 93.62,32.6 93.62,32.62 v10(93.21,33.02) 93.59,33.4 UD3.A8 ; 93.74,32.73 UD3.B8 ; 93.74,32.73 94.29,32.73 UD3.B7 ; UH1.BE16 v6(98.44,61.66) ; UCPU1.AG47 UCPU1.AF47 ; UH1.T7 110.77,58.89 v6(110.78,58.89) 110.77,58.89 UH1.T9 UH1.T11 ; JIOL1.21 v7(19.1,20.89) ; v6(82.56,72.1) 82.56,72.12 82.48,72.05 82.13,72.05 UCPU1.T1 ; UD7.J9 70.71,27 v10(70.33,27.38) ; v6(98.82,33) UD3.A1 ; UCPU1.AL47 59.43,65.45 v6(59.08,65.1) 58.74,64.77 UCPU1.AM48 ; UH1.BC16 v6(99.31,62.59) ; UCPU1.AN36 64.77,64.08 v7(64.45,64.4) ; v6(80.99,66.96) UCPU1.AH4 ; v10(100.2,25.81) 100.2,26.01 UD3.J1 ; UH1.BK18 v6(96.55,62.79) ; UH1.AT45 v6(102.53,74.44) ; UH1.V4 v6(109.68,57.01) UH1.V2 ; v6(48.25,79.62) 48.25,79.6 48.26,79.61 48.26,79.08 RC54.2 ; UCPU1.D26 69.76,78.49 v6(69.4,78.85) ; v10(81.38,27.38) 81.76,27 UD5.J9 ; UCPU1.BG53 v6(56.6,56.72) ; UH1.G16 v6(114.89,62.1) ; UH1.BB48 v6(100.34,75.47) ; UH1.N11 v6(111.74,60.62) 111.83,60.71 UH1.N13 ; UCPU1.BD8 79.05,58.43 v6(79.05,58.13) ; v6(55.79,71.94) 55.79,71.95 55.79,71.96 55.81,71.97 56.07,72.23 UCPU1.T53 ; UCPU1.A33 v6(66.81,80.2) ; UCPU1.V61 v6(52.89,71.68) ; UCPU1.F35 65.69,77.18 v6(66,77.48) ; v10(92.42,24.2) 92.82,23.8 UD3.N9 ; UH1.BC41 v6(99.74,72.72) ; UCPU1.AJ13 76.58,66.45 v6(76.3,66.73) 75.93,67.1 UCPU1.AG14 ; UH1.BE43 v6(98.02,73.69) ; UCPU1.AU32 66.87,62.11 v6(66.62,62.36) ; UH1.BK22 v6(96.1,64.82) ; UCPU1.K21 v6(71.99,75.25) ; UCPU1.AP10 v6(77.85,64.39) ; v10(22.44,31.66) 22.44,31.75 22.09,32.09 UD15.J9 ; UH1.L31 112.69,68.38 v6(112.68,68.36) ; JIOL1.13 v7(17.1,18.99) ; UD13.B7 34.73,37.62 v10(35.08,37.26) ; v6(69.35,75.2) 69.35,74.75 UCPU1.L26 ; v7(17.56,23.84) 17.6,23.88 JIOL1.16 ; UH1.N25 v6(111.83,65.56) ; UD9.J9 55.22,32.08 v10(54.84,32.46) ; UCPU1.BG41 62.52,57.12 62.77,56.87 v6(62.77,56.84) ; UCPU1.F55 v6(54.85,77.26) ; v6(53.76,73.62) 53.9,73.48 UCPU1.P58 ; UH1.T13 v6(110.77,61.46) ; UD11.N9 v10(43.78,29.28) ; UH1.AP9 v6(103.05,59.75) ; v6(109.71,75.04) 109.71,75.44 UH1.V48 ; UH1.V50 v6(110.09,76.33) ; v6(60.21,56.83) 60.54,57.16 UCPU1.BG45 ; UH1.AF2 v6(106.84,56.56) ; UH1.AF50 v6(106.43,76.77) ; UH1.D14 v6(115.87,61.57) UH1.B14 ; UCPU1.L38 64.01,75.17 v6(64.04,75.19) ; UH1.B42 v6(115.88,72.95) UH1.D42 ; v6(52.09,69.87) 52.33,69.87 UCPU1.AB61 ; UD15.N9 v10(21.68,29.28) ; UH1.AW7 v6(101.12,57.98) ; v6(62.85,78.07) 63.08,77.84 63.26,77.84 UCPU1.E40 ; v10(78.11,25.81) 78.11,26.01 UD7.J1 ; UCPU1.BG13 v6(76.36,56.72) ; v6(56.89,58.96) 56.89,58.85 UCPU1.BD52 ; UH1.AY10 v6(100.64,59.3) ; UH1.AT9 v6(102.09,59.73) ; UH1.BH46 v6(96.96,74.57) UH1.BK46 95.78,74.57 v7(95.77,74.59) ; UH1.BD15 v6(98.87,62.11) ; UH1.AL9 v6(104.02,59.75) ; UCPU1.BD40 v6(63.08,58.14) ; UH1.AW45 v6(101.53,74.44) ; UH1.AP50 v6(103.59,76.33) ; UCPU1.AR7 79.16,63.35 79.17,63.36 v6(79.2,63.36) 79.2,63.38 79.15,63.44 UCPU1.AP7 ; UH1.BF48 v6(98.71,75.47) ; UCPU1.K51 57.02,75.88 v6(56.88,75.88) ; v6(57.86,60.58) 58.1,60.82 UCPU1.AY49 ; UCPU1.AV17 v6(74.36,61.4) ; UCPU1.Y59 52.94,70.73 52.94,70.74 v6(52.9,70.77) ; UH1.AF4 v6(106.43,57.01) ; JLVDS1.20 156.75,80.63 ; v6(65.79,79.46) 65.5,79.17 UCPU1.C35 ; 178.24,80.8 JLVDS2.15 ; RH316.1 109.25,51.19 v6(108.87,50.81) ; UH1.BF50 v6(98.71,76.33) ; JIOL1.36 22.6,24.16 v7(22.97,23.79) ; UH1.BA39 v6(99.76,71.76) ; v6(112.69,67.36) UH1.L29 ; UH1.J36 113.56,70.33 v6(113.57,70.32) ; v6(76.28,69.58) 76.58,69.88 UCPU1.AA13 ; UH1.AA7 v6(108.84,58.89) UH1.AA9 ; UD1.J1 111.25,26.01 v10(111.25,25.81) ; UH1.B38 v6(116.31,70.92) ; UCPU1.BD23 v6(70.99,58.14) ; UD13.A8 33.9,38.48 v10(33.52,38.1) 33.93,37.7 UD13.B8 ; UCPU1.AC6 v6(79.97,68.89) ; UCPU1.AA52 56.72,69.96 v6(56.41,69.65) ; UCPU1.AT58 v6(54.35,62.52) ; UH1.BE9 v6(98.03,59.21) ; UCPU1.AT52 56.8,62.69 56.94,62.83 v7(57.23,62.83) UCPU1.AU51 ; UCPU1.AU7 v6(79.21,61.45) 79.21,61.33 UCPU1.AW7 ; UH1.AW39 v6(100.62,71.76) ; UCPU1.BG37 v6(64.5,56.72) ; UH1.AW41 v6(101.57,72.71) ; UH1.N21 v6(111.83,64.49) UH1.N23 ; UH1.J45 v6(113.67,74.97) ; v6(98.31,58.33) 98.6,58.62 UH1.BE7 ; UD11.J9 44.17,32.08 v10(43.79,32.46) ; v7(163,80.73) 163.25,80.48 JLVDS1.7 v7(163.25,78.65) ; UH1.G18 v6(114.88,63.07) ; UCPU1.AD4 v6(81.1,68.62) ; UD15.N1 28.48,28.85 v10(28.9,28.43) ; UH1.G36 114.42,70.31 v6(114.41,70.29) ; UCPU1.Y47 v6(59.81,70.48) ; v10(82.17,25) 81.77,25.39 UD5.L9 ; UH1.G39 v6(114.42,71.3) ; UD3.J9 92.81,27 v10(92.43,27.38) ; UCPU1.AR21 72.07,63.36 v6(72.49,62.94) 72.74,62.7 UCPU1.AT19 ; UH1.J31 113.56,69.32 v6(113.55,69.33) 113.55,69.81 UH1.J34 ; UH1.J11 v6(113.56,60.6) ; UCPU1.AR61 v6(52.04,63.07) ; UH1.BH22 v6(96.98,64.82) ; UCPU1.L34 v6(65.79,75.2) ; UH1.L36 112.71,70.78 v6(112.71,70.27) 112.69,70.26 UH1.L34 ; UH1.J9 113.72,59.4 v6(113.57,59.55) ; UH1.BH42 v6(96.98,72.95) ; UCPU1.BA26 v6(69.97,60.04) ; UH1.D38 v6(115.45,70.92) ; UH1.AT7 v6(102.09,58.91) ; UCPU1.BA17 v6(74.37,60.09) ; UH1.AP45 v6(103.48,74.44) ; UH1.B22 v6(115.89,64.82) UH1.D22 ; PU600.1 111.36,80.26 111.67,79.96 v7(111.67,79.93) ; UH1.B30 v6(116.31,67.67) ; v6(65.56,61.42) UCPU1.AV34 ; 175.74,80.7 JLVDS2.20 ; UCPU1.AM58 53.95,64.54 53.95,64.71 54.26,65.03 54.33,65.03 v6(54.35,65.05) ; UH1.J41 v6(113.56,72.21) ; UH1.F48 114.32,75.47 v6(114.13,75.27) ; UD5.N9 v10(81.37,24.2) ; UCPU1.BG28 v6(68.45,56.72) ; UH1.F50 v6(114.56,76.82) ; UH1.J29 v6(113.56,67.41) ; UH1.G29 v6(114.42,67.42) ; UD1.L1 v10(110.67,25) ; UH1.BF15 v6(98.01,62.09) ; UH1.BA34 v6(100.17,70.25) ; UH1.AT11 v6(101.66,60.18)
  BOTTOM w0.279: UH1.AG11 v6(105.95,60.6) ; UH1.BA11 100.17,60.2 UH1.BA13 UH1.BA16 UH1.BA18 UH1.BA21 UH1.BA23 v6(100.17,65.41) ; UH1.R31 v6(111.05,68.95) ; UH1.AC43 v6(108.29,73.57) ; UH1.N43 v6(112.16,73.57) ; v6(113.16,74.43) 113.16,74.43 113.16,74.45 113.14,74.44 UH1.L45 ; UH1.Y35 v6(109.07,70.63) ; UH1.BA29 v6(100.17,68.32) ; UH1.AG37 v6(105.77,71.45) ; UH1.V17 v6(109.73,63.08) ; UH1.AR19 v6(102.47,63.92) ; UH1.AP25 v6(103.13,66.44) ; UH1.AE33 v6(107.09,69.79) UH1.AE35 ; UH1.AP33 v6(103.13,69.78) ; UH1.BH34 v6(96.97,69.7) ; UH1.AB37 v6(108.41,71.46) ; UH1.AK35 v6(104.45,70.61) ; UH1.AP21 v6(103.13,64.75) ; UH1.AA41 v6(109.28,72.71) ; v6(102.64,70.64) 102.47,70.47 UH1.AR35 ; UH1.AL41 v6(104.46,72.71) ; UH1.BH32 v6(96.98,68.89) ; UH1.BC18 v6(99.31,63.52) ; UH1.AP31 v6(103.13,68.95) ; UH1.AK17 v6(104.45,63.08) ; UH1.AE45 v6(107.33,74.44) ; UH1.AF8 v6(106.43,59.32) ; UH1.AU37 v6(101.39,71.04) ; UH1.AG9 v6(105.95,59.77) ; UH1.AM15 v6(103.79,62.23) ; UH1.V43 v6(109.81,74) ; UH1.AM37 v6(103.79,71.45) ; UH1.AL43 v6(104.45,73.57) ; v6(96.98,68.07) UH1.BH30 ; v6(110.09,75.22) 110.34,75.48 110.48,75.48 UH1.T48 ; UH1.Y15 v6(109.07,61.42) ; v6(110.23,72.7) 110.23,72.71 UH1.V41 ; UH1.V33 v6(109.73,69.78) ; UH1.AR37 v6(102.47,71.46) ; UH1.AB50 v6(108.06,76.74) ; UH1.AC41 v6(108.29,72.71) ; UH1.AJ43 v6(105.45,73.57) ; UH1.AF31 v6(106.43,68.94) ; v6(96.12,69.7) 96.12,69.7 96.13,69.7 96.14,69.71 96.16,69.7 UH1.BK34 ; UH1.AE11 v6(106.91,59.75) ; v6(101.56,73.57) UH1.AW43 ; UH1.AJ33 v6(105.11,69.78) ; UH1.AK10 v6(104.5,59.34) ; UH1.AJ19 v6(105.11,63.93) ; UH1.Y37 v6(109.07,71.45) ; v6(105.5,71.85) 105.5,71.84 105.51,71.85 UH1.AG39 ; UH1.AR31 v6(102.47,68.94) ; UH1.AW13 v6(101.12,60.64) ; v6(107.88,58.01) UH1.AC7 ; v6(108.18,63.1) 108.41,62.86 UH1.AB17 ; UH1.AP35 v6(103.13,70.63) ; UH1.Y33 v6(109.07,69.78) ; UH1.BE27 v6(98.44,66.51) ; v6(99.31,65.41) UH1.BC23 ; UH1.AP17 v6(103.13,63.08) ; UH1.V15 v6(109.73,62.24) ; UH1.AJ35 v6(105.11,70.63) ; UH1.AM31 v6(103.79,68.94) ; UCPU1.J55 v6(54.87,75.96) ; UH1.BA25 v6(100.17,66.51) ; UH1.AW23 v6(101.03,65.42) ; UH1.AP23 v6(103.13,65.59) ; UH1.BF24 v6(98.01,65.93) ; UH1.AL39 v6(104.02,72.26) ; UH1.AB25 UH1.AC25 v6(107.75,65.59) ; UH1.AW29 v6(101.03,68.32) ; UH1.T41 v6(111.23,72.71) ; UH1.AC45 v6(108.32,74.44) ; UH1.AW25 v6(101.03,66.41) ; UH1.AG43 v6(106.36,73.57) ; v6(58.25,80.2) 58.3,80.15 UCPU1.A49 ; UH1.BC21 v6(99.31,64.48) ; UH1.AU17 v6(101.81,63.07) ; UH1.AJ37 v6(105.11,71.45) ; UH1.BE25 v6(98.44,65.52) ; UH1.AF19 v6(106.43,63.93) ; UH1.BC31 v6(98.9,68.86) ; UH1.BE29 v6(97.94,67.89) ; UH1.BE21 UH1.BE23 ; UH1.AC33 v6(107.75,69.79) ; UH1.AE15 v6(107.09,61.42) ; UH1.AR17 v6(102.47,63.08) ; UH1.AL11 v6(104.02,60.61) ; UH1.AG33 v6(105.77,69.79) ; UH1.AG41 v6(106.39,72.71) ; UH1.AM25 v6(103.79,66.43) ; UH1.BH26 v6(97.41,66.04) ; UH1.V45 v6(110.25,74.44) ; UH1.AR21 v6(102.47,64.77) ; UCPU1.H58 v6(53.68,76.44) ; UH1.AA39 v6(109.28,71.85) ; UH1.BD24 v6(98.87,65.94) ; UH1.Y17 v6(109.07,63.08) ; UH1.AF33 v6(106.43,69.79) ; UH1.AE43 v6(107.32,73.57) ; UH1.AK37 v6(104.45,71.46) ; UH1.BE31 v6(98.01,68.86) ; UH1.AG19 v6(105.77,63.93) ; UH1.BH28 v6(97.41,67.67) ; UH1.AT41 v6(102.51,72.71) ; UH1.T45 v6(111.21,74.44) ; UH1.T43 v6(111.22,73.57) ; UH1.AT39 102.06,71.82 v6(101.65,71.82) ; UH1.AL45 v6(104.46,74.44) ; UH1.L27 v6(112.69,67.36) ; v6(102.89,71.42) 102.9,71.42 103.13,71.19 UH1.AP37 ; UH1.AP29 v6(103.13,68.12) ; UH1.AJ45 v6(105.41,74.44) ; UH1.AG17 v6(105.77,63.08) ; UH1.BC34 v6(99.31,70.25) ; UH1.AE25 v6(107.09,66.42) ; UH1.V27 v6(109.73,67.27) ; UH1.AK12 v6(104.5,60.2) ; UH1.AE13 v6(106.91,60.64) ; UH1.AC17 v6(107.75,63.08) ; UH1.AG45 v6(106.37,74.44) ; UH1.R17 v6(111.05,62.24) ; UH1.AG7 v6(105.95,58.89) ; UH1.AP41 v6(103.5,72.71) ; UH1.V29 v6(109.73,68.1) ; UH1.AJ11 v6(104.98,60.6) ; UH1.AG31 v6(105.77,68.94) ; UH1.AK19 v6(104.45,63.93) ; UH1.BC27 v6(99.31,67.38) ; UH1.AW27 v6(101.03,67.37) ; UH1.U31 v6(110.39,68.95) ; UH1.AH12 v6(105.47,60.19) ; UH1.V35 v6(109.73,70.63) ; UH1.AA11 v6(108.84,59.75) ; UH1.AT43 v6(102.51,73.57) ; UH1.AB35 v6(108.41,70.62) ; UH1.AF37 v6(106.43,71.45) ; UH1.AA43 v6(109.28,73.57) ; UH1.AF35 v6(106.43,70.63) ; UH1.BE34 v6(98.44,70.25) ; UH1.AC11 v6(107.88,59.78) ; UH1.AA45 v6(109.29,74.44) ; UH1.AK23 v6(104.45,65.59) ; UH1.AM19 v6(103.79,63.92) ; UH1.AJ41 v6(105.42,72.71) ; UH1.N45 v6(112.18,74.44) ; UH1.AE17 v6(107.09,63.08) ; UH1.AB33 v6(108.41,69.79) ; UH1.AJ39 v6(104.58,71.85) ; UH1.AH10 v6(105.47,59.31) ; UH1.BE18 v6(98.44,62.59) ; v6(106.91,58.01) UH1.AE7 ; UH1.BC29 v6(98.88,67.89) ; UH1.AE41 v6(107.32,72.71) ; UH1.T11 UH1.T13 ; UH1.BA27 v6(99.75,66.93) ; UH1.AG35 v6(105.77,70.63) ; UCPU1.J1 v6(82.53,75.97) ; UH1.N34 v6(111.83,70.28) ; UH1.R21 v6(111.05,63.93)
  BOTTOM w0.305: v6(61.75,74.38) 61.39,74.75 UCPU1.L43 ; v6(71.56,74.75) UCPU1.L22 ; v6(75.14,69.28) 75.53,68.89 UCPU1.AC14 ; UCPU1.P16 v6(75.11,73.15) ; UCPU1.A28 68.76,80.4 v7(68.92,80.56) ; JMDP1.14 v6(219.4,70.4) ; v7(72.27,68.29) 71.93,67.95 UCPU1.AF21 ; v6(57,73.49) 57,73.5 56.72,73.78 UCPU1.N52 ; UCPU1.BE58 54.07,57.92 v6(54.29,57.7) ; v6(79.46,73.77) 79.86,74.17 UCPU1.M6 ; UCPU1.N1 82.15,74.04 82.54,74.04 v6(82.71,74.21) ; v7(78.98,75.91) 78.98,75.87 78.51,75.4 UCPU1.K8 ; UD5.F8 82.49,29.4 v6(82.2,29.69) ; v7(76.51,79.39) 76.11,79.79 UCPU1.A13 ; v6(76.52,29.79) 76.52,29.79 76.32,29.59 UD7.F2 ; UH1.AM29 v6(103.79,68.11) ; v7(67.98,66.59) 67.57,66.18 UCPU1.AJ30 ; v7(77.1,75.76) 77.07,75.76 77.53,76.21 UCPU1.H10 ; UCPU1.E25 70.37,78.11 70.59,77.89 v6(70.72,77.89) ; UD15.D1 28.89,36.08 v10(29.01,36.2) ; 77.78,73.75 77.27,74.27 UCPU1.M11 ; v6(98.3,74.58) 98.61,74.27 UH1.BE45 ; UH1.AK27 v6(104.45,67.27) ; UCPU1.AM42 62.42,64.77 v6(62.72,65.06) ; UCPU1.AN25 69.92,64.08 v6(69.76,64.25) ; v7(77.05,77.08) 76.68,77.44 UCPU1.F13 ; v6(99.54,73.6) 99.28,73.6 UH1.BC43 ; UCPU1.AM20 72.69,64.77 v6(72.47,64.99) ; UCPU1.W21 71.63,70.48 v6(71.41,70.7) ; v6(64.88,73.62) 64.88,74.04 UCPU1.N36 ; v6(74.2,74.41) 73.85,74.06 UCPU1.N17 ; UCPU1.BG57 v6(54.53,56.78) ; UCPU1.AM22 70.99,64.77 v6(70.7,65.06) ; UH1.F4 v6(114.56,56.99) UH1.F2 ; UCPU1.AM34 65.66,64.77 v7(65.34,65.09) ; UD1.F8 104.6,29.4 v6(104.26,29.75) ; UCPU1.C58 54.38,79.04 v6(54.53,79.18) UCPU1.A57 ; UD13.D1 39.94,36.08 v10(40.06,36.2) ; UCPU1.L48 58.68,74.69 v6(58.35,74.36) ; UCPU1.AL40 63.14,65.45 63.48,65.8 v7(63.56,65.8) ; UCPU1.AD20 72.62,68.73 v6(72.24,69.1) ; UD3.F2 98.42,29.59 98.62,29.79 v6(98.62,29.79) ; UCPU1.AJ38 64.01,66.14 63.61,66.54 v7(63.53,66.54) ; v6(115.88,58.32) UH1.B6 ; v6(80.17,56.93) 80.17,57.28 UCPU1.BG5 80.06,57.4 UCPU1.BE5 ; v6(70.7,65.8) 70.35,65.45 UCPU1.AL25 ; UCPU1.N25 v6(70.24,73.62) ; UH1.AF27 v6(106.43,67.27) ; v6(66.22,65.16) 66.51,65.45 UCPU1.AL33 ; v6(38.93,34.87) 38.93,34.87 38.73,34.67 UD13.F2 ; v7(74.53,79.36) 74.53,79.44 74.18,79.79 UCPU1.A17 ; v7(70.09,80.48) 70.06,80.45 70.03,80.45 70.06,80.43 UCPU1.A25 ; UCPU1.AL28 68.45,65.45 68.13,65.77 v7(68.03,65.77) ; UCPU1.R20 v6(72.62,72.71) ; v6(22.55,34.79) 22.86,34.48 UD15.F8 ; UD5.D1 88.58,31 v10(88.7,31.12) ; UCPU1.N21 72.23,74.06 v6(72.45,74.28) ; UCPU1.D59 53.7,78.39 UCPU1.D58 v6(53.87,77.74) ; v10(77.76,31.13) 77.76,31.15 77.6,31 UD7.D1 ; v6(66.25,64.4) 66.57,64.08 UCPU1.AN33 ; UD15.F2 27.68,34.67 27.88,34.87 v6(27.88,34.87) ; UCPU1.AF17 v6(73.99,68.26) ; UCPU1.E3 81.32,77.75 v6(80.98,78.09) ; UD13.F8 33.91,34.48 v6(33.56,34.84) ; UCPU1.BE4 80.7,58.18 v6(80.46,58.42) 80.5,58.46 81.25,58.46 UCPU1.BD3 ; UCPU1.N40 v6(63.12,73.62) ; UCPU1.N43 v6(61.35,73.62) ; UCPU1.AR17 v6(74.35,63.35) ; UCPU1.BD59 53.49,58.57 53.65,58.41 v6(53.73,58.41) 53.76,58.41 UCPU1.BC57 ; v6(76.31,67.88) 76.61,68.18 UCPU1.AE13 ; v6(77.88,77.97) 77.5,78.35 UCPU1.D10 ; UCPU1.AL17 73.85,65.45 v6(74.2,65.8) ; v6(72.4,65.8) 72.05,65.45 UCPU1.AL21 ; UCPU1.AJ48 58.98,66.14 v6(59.11,66) ; v6(44.63,34.83) 44.98,34.49 UD11.F8 ; UCPU1.G6 79.44,76.86 v6(79.08,77.23) ; UH1.AF29 v6(106.43,68.11) ; v6(80.09,78.14) 80.42,78.47 UCPU1.D4 ; UCPU1.E1 v6(82.46,78) ; v6(93.22,29.74) 93.56,29.4 UD3.F8 ; UCPU1.AM26 69.46,64.77 v6(69.78,65.09) ; v7(75.34,76.21) 75.59,76.46 UCPU1.H14 ; v7(63.56,64.4) 63.63,64.4 64,64.77 UCPU1.AM38 ; UH1.BK30 v6(96.98,68.07) ; UCPU1.D22 v7(71.57,78.88) ; UCPU1.AJ16 74.67,66.14 v6(74.33,66.48) ; UCPU1.P9 78.5,73.44 v7(78.19,73.75) ; v6(49.98,34.87) 49.98,34.87 49.78,34.67 UD11.F2 ; UCPU1.A9 v6(78.37,80.1) ; v6(61.78,64.43) 61.43,64.08 UCPU1.AN43 ; v6(71.13,29.76) 71.5,29.4 UD7.F8 ; UCPU1.F15 v7(75.08,77.81) ; UCPU1.R17 v6(73.99,72.71) ; UCPU1.P18 73.3,73.28 v6(73.59,73.57) ; UCPU1.AN28 68.38,64.08 v7(68.03,64.43) 67.9,64.43 67.57,64.76 UCPU1.AM30 ; UH1.BC39 v6(98.89,71.76) ; UH1.BF2 v6(97.87,56.56) ; v6(68.87,65.85) 69.15,66.14 UCPU1.AJ26 ; UCPU1.AB21 71.93,69.64 v6(71.58,69.99) ; UCPU1.N33 v6(66.68,73.62) ; v7(64.47,65.8) 64.82,65.45 UCPU1.AL36 ; UCPU1.D14 v7(75.53,78.88) ; UCPU1.A21 72.17,79.79 72.57,79.39 v7(72.57,79.36) ; UH1.BC45 v6(99.61,74.44) ; v6(80.17,74.82) 80.43,74.55 UCPU1.M4 ; UCPU1.W15 75.31,70.99 75.62,71.31 v7(75.65,71.31) ; UH1.AK25 v6(104.45,66.43) ; v6(80.22,76.21) 80.54,76.53 UCPU1.H4 ; v7(73.67,75.96) 74.05,76.35 UCPU1.H17 ; UCPU1.AJ22 71.13,66.21 v6(70.8,66.54) ; v7(80.73,80.2) 80.3,79.77 UCPU1.A5 ; v6(79.15,77.94) 79.48,78.27 UCPU1.D6 ; UCPU1.U8 78.55,71.67 v7(78.21,71.34) ; UCPU1.N51 v7(57.37,74.45) ; UCPU1.V20 v6(72.62,71.82) ; UCPU1.F19 73.4,77.52 v7(73.67,77.25) ; v6(74.35,70.02) 74.35,69.91 74.67,69.59 UCPU1.AB16 ; v6(58.94,73.62) 58.68,73.88 UCPU1.N48 ; UH1.BE39 v6(97.94,71.76) ; UCPU1.AJ34 65.8,66.14 v7(66.17,66.51) ; v6(61.03,34.87) 61.02,34.87 60.83,34.67 UD9.F2 ; v10(51.11,36.2) 50.99,36.08 UD11.D1 ; UCPU1.AJ42 62.14,66.14 v7(61.81,65.8) 61.46,65.45 UCPU1.AL43 ; UCPU1.N28 68.48,74.04 v6(68.48,73.62) ; UD1.D1 110.68,31 v10(110.8,31.12) ; UD5.F2 87.37,29.59 87.57,29.79 v6(87.57,29.79) ; UH1.D6 v6(115.45,57.87) ; UCPU1.D18 v7(73.55,78.88) ; UCPU1.P21 v6(71.93,73.59) ; UCPU1.L20 72.94,74.75 v6(73.29,75.1) ; UCPU1.C3 82.05,79.74 v7(82.04,79.74) ; v6(73.08,66.54) 72.9,66.36 UCPU1.AJ20 ; UCPU1.AN21 71.97,64.08 v6(71.61,63.72) ; UCPU1.AG18 73.3,66.95 v6(72.93,67.32) ; UH1.AF25 v6(106.43,66.43) ; UCPU1.AD17 73.99,68.75 v6(73.64,69.1) ; UCPU1.W13 76.61,70.86 76.61,71.03 v6(76.84,71.26) 76.84,71.5 UCPU1.U13 ; v6(73.08,70.98) 73.08,70.7 73.3,70.48 UCPU1.W18 ; UCPU1.P14 v6(75.9,72.83) ; UH1.AG29 v6(105.77,68.11) ; UCPU1.H21 72.14,76.47 72.45,76.47 v7(72.65,76.28) ; UCPU1.M15 v7(75.31,75.04) ; UH1.BF4 v6(97.87,57.43) ; UCPU1.N47 v6(59.57,73.62) ; UCPU1.N56 v6(55.07,73.57) ; v6(109.67,29.79) 109.67,29.79 109.47,29.59 UD1.F2 ; UH1.BK32 v6(96.13,68.89) ; UCPU1.AK52 v7(56.63,65.54) ; UH1.BA45 v6(100.57,74.44)
  BOTTOM w0.356: v7(77.1,75.76) 77.21,75.65 UCPU1.K11 ; JTP1.4 140.25,26.73 140.57,26.4 v7(140.57,26.3) ; 77.78,73.75 v7(78.19,73.75)
  BOTTOM w0.381: v7(128.23,79.31) 128.01,79.1 UC2.3 ; PQ204.4 199.65,56.62 v7(199.99,56.27) ; v6(119.54,63.99) 119.84,63.68 CH5.2 ; JSATA1.27 174.95,55.62 174.35,56.22 v7(174.35,56.35) 174.12,56.12 174.12,55.66 174.96,54.82 JSATA1.29 ; v7(75.31,75.04) 74.96,75.04 74.68,74.76 UCPU1.L16 ; v7(215.32,67.78) DV2.3 ; QC4.1 v6(78.34,47.44)
  BOTTOM w0.432: PQ204.1 v7(198.3,55.32)
  BOTTOM w0.508: JBL1.6 v7(169.75,25.44) ; 178.57,38.98 178.57,38.44 178.86,38.15 JWLAN1.27 ; 178.57,38.98 v7(178.54,39) ; 178.57,38.98 178.6,38.95 JWLAN1.29 ; v7(159.42,32.37) 159.42,32.37 159.42,31.87 v9(158.66,31.1) ; RD9.2 52.2,41.97 v6(51.72,41.49) ; JRTC1.3 24.25,48.64 v7(23.5,49.39) ; v7(174.78,62.95) 174.78,62.97 175.43,63.62 JSATA1.15 ; v7(200.08,53.81) PC205.2 ; v7(6.67,26.67) 5.9,27.44 JFAN1.5 ; v7(168.92,52.89) 168.86,52.82 JSATA1.34 ; JSATA1.35 177.97,52.42 v7(178.14,52.59) ; RV10.2 v6(211.58,74.85) ; CH22.2 123.63,78.81 123.63,79.49 v7(123.32,79.79) ; v7(158.69,22.87) 159.05,23.23 JANT2.1 ; JANT3.3 150.88,22.24 v7(150.17,22.95) ; v7(152.69,22.86) 153.3,22.24 JANT3.1 ; CD120.2 16.9,36.8 CD124.2 ; CD120.2 16.83,38.37 v7(15.98,38.37) ; CD120.2 CD119.2 ; v7(6.69,25.73) 7.17,25.24 JFAN1.1 ; JSATA1.40 170.28,50.42 v7(170.47,50.61) ; JSATA1.26 v6(165.85,56.02) ; v7(156.27,22.85) 156.65,23.23 JANT2.3 ; JSATA1.43 174.8,49.22 174.53,48.96 v7(174.4,48.96) ; U48.4 127.03,84.42 126.65,84.8 v7(126.65,85.26) ; PC745.2 30.31,84.14 v7(30.31,84.29) ; v7(32.33,26.12) 31.22,26.12 RD13.2 ; v7(102.89,19.39) 102.89,19.99 RD1.2 ; v7(177.35,65.75) 176.97,65.75 176.69,66.03 JSATA1.9 ; JRTC1.4 v7(18.88,50.58) ; SW2.4 152.01,82.84 v7(152.31,82.84) ; C1059.2 168.36,33.45 168.36,34.15 v7(167.98,34.53) ; v7(120.58,47.97) 119.84,48.7 PC508.2 ; v7(84.19,60.29) 84.89,59.58 84.89,58.38 85.54,57.73 CC174.2 CC175.2 ; v7(164.23,24.79) 163.69,24.25 JANT1.3 ; v7(167.2,24.79) 166.66,24.25 JANT1.1 ; PC907.2 v7(131.25,18.4) ; v6(181.43,77.43) D50.2 ; v7(23.5,21.42) 24.26,21.42 24.8,21.96 JIOL1.37 ; v7(197.54,76.75) 196.22,76.75 195.77,76.29 JDCIN1.6 197.45,75.96 v7(197.52,76.03) ; v7(77.75,19.65) 77.75,20.25 CD29.2 ; JWLAN1.21 v6(178.77,35.75) ; CC68.2 131.14,78.82 v7(131.17,78.86) ; JSATA1.50 169.52,46.42 v7(169.96,45.99) ; JSATA1.4 168.65,68.03 v7(169.48,67.2) ; v7(152.09,34.41) 151.65,33.97 PC29.2 ; JTP1.7 v7(135.6,26.35) ; v6(177.1,72.07) JSATA1.53 ; H21.1 v6(204.67,77.24) ; v7(174.35,58.03) 174.51,58.03 JSATA1.21 ; v7(71.61,20.07) 71.14,19.6 CD8.2 ; C1160.2 167.92,36.34 v7(167.95,36.38) ; v7(94.93,48.81) PC403.2 ; RD29.2 90.88,44.57 v7(91.19,44.26) ; v7(173.29,75.95) 173.29,75.96 172.83,76.42 C1198.2 ; JWLAN1.43 179.02,44.55 177.53,46.04 v7(177.53,46.29) ; CD34.2 103.99,20 v7(103.99,19.06) ; RD26.2 v6(18.61,41.11) ; 24.54,44.74 25.53,44.74 ; C1110.2 216.38,49.34 v7(216.71,49.66) ; v7(177.65,51.65) 177.63,51.62 JSATA1.37 ; v7(181.19,30.98) 181.19,30.54 180.79,30.15 JWLAN1.15 ; C265.2 v7(223.51,27.32) ; v7(82.19,19.63) 82.19,20.25 RD5.2 ; v7(171.79,35.62) 172.46,35.62 PC410.2 172.87,35.18 172.69,35 v7(171.58,35) ; v7(92.61,19.65) 92.61,20.25 RD3.2 ; JSATA1.54 176.82,42.77 178.24,41.35 v7(178.62,41.35) JWLAN1.35 ; CD5.2 87.86,20.26 v7(87.86,19.66) ; RD11.2 43.73,42.26 43.94,42.47 v7(43.94,43.21) ; D90.2 v7(156.9,77.28) ; v7(24.49,44.82) 24.49,44.79 ; JFAN1.6 v7(4.51,21.04) ; JBATT9.10 132.47,26.33 v7(133.03,26.89) ; H20.1 211.4,54.61 v7(212.02,55.23) ; CH6.2 v7(125.99,85.12) ; JBATT9.11 116.44,26.33 v7(116.77,26) ; JBL1.5 v7(176.75,25.34) ; v7(98.41,19.39) 98.61,19.39 99.05,19.83 CD33.2 ; v7(167.75,33.87) 167.44,33.87 166.87,33.3 C1153.2 ; C1206.2 v6(176.58,74.42) ; v7(127.49,72.07) 127.49,72.59 125.85,74.23 RH339.1 ; JWLAN1.9 v7(178.16,27.75) ; RD15.2 24.81,42.37 v7(23.71,41.26) ; 104.15,51.64 103.88,51.9 103.88,52.15 RH337.2 ; JRTC1.2 v7(21.43,50.3) ; PC906.2 v7(130.36,18.43) ; CD62.2 79.97,39.76 v7(80.19,39.99) ; PC405.2 95.38,46.94 v7(95.38,47.41) ; v7(86.85,40.32) 87.54,39.64 CD4.2 ; v7(11.9,20.84) JIOL1.38 ; RH125.1 v7(93.55,62.81) ; v6(75.78,45.77) 75.82,45.81 CC217.2 ; CH95.2 v6(26.65,47.69) ; CH94.2 v6(142.2,80.48) ; v7(166.22,58.97) 166.48,59.22 JSATA1.18 ; v6(68.51,38.62) RD7.2 ; JTP1.8 v7(147.57,24.51)
  vias: v2(16.95,63.79) v2(17.13,67.88) v2(17.79,84.19) v2(18.68,84.19) v2(23.72,67.63) v2(23.72,66.36) v2(23.72,65.09) v2(25.03,23.58) v2(25.05,24.46) v2(26.64,69.05) v2(26.64,67.78) v2(26.64,66.51) v2(28.18,22.31) v2(28.37,25.82) v2(28.48,72.63) v2(31.78,58.1) v2(31.78,57.21) v2(36.69,81.38) v2(43.9,19.65) v2(45.24,19.28) v2(47.02,19.28) v2(50.44,80.1) v2(51.37,19.72) v2(51.67,20.1) v2(51.67,19.34) v2(51.67,18.94) v2(52.15,18.94) v2(52.81,18.95) v2(53.47,18.95) v2(57.89,58.53) v2(58.33,58.53) v2(59.54,56.88) v2(100.13,53.49) v2(109.56,40.4) v2(110.45,40.4) v2(111.76,39.79) v2(113.46,39.79) v2(118.68,49.09) v2(118.68,48.6) v2(118.68,48.12) v2(119.95,49.08) v2(119.95,48.6) v2(119.95,48.12) v2(121.22,49.08) v2(121.22,48.6) v2(121.22,48.12) v2(122.54,42.63) v2(124.72,37.35) v2(127.25,66.26) v2(127.76,55.59) v2(129.98,37.43) v2(130.41,71.84) v2(131.63,34.35) v2(131.6,33.46) v2(131.99,37.4) v2(137.55,75.55) v2(139.12,30.59) v2(139.12,29.32) v2(139.12,28.05) v2(147.25,42.99) v2(147.25,42.09) v2(150.41,42.69) v2(156.97,57.37) v2(168.71,56.16) v2(174.17,70.76) v2(175.06,70.76) v2(177.15,76.97) v2(178.92,76.97) v2(178.98,35.12) v2(180.25,76.53) v2(182.83,66.37) v2(182.86,76.54) v2(183.06,78.5) v2(183.06,77.61) v2(183.88,78.04) v2(185.07,76.8) v2(185.2,80.56) v2(186.49,80.2) v2(186.72,61.43) v2(187.17,77.85) v2(187.34,61.43) v2(187.37,67.34) v2(187.38,60.77) v2(187.37,60.1) v2(187.79,61.43) v2(187.83,60.76) v2(187.84,60.08) v2(188.41,61.49) v2(188.45,60.82) v2(188.46,60.15) v2(189.29,68.75) v2(190.42,80.9) v2(191.19,67.45) v2(191.38,76.92) v2(192.02,76.92) v2(192.31,69.01) v2(192.4,65.37) v2(194.01,64.3) v2(194.98,66.46) v2(194.98,65.57) v2(202.69,66.13) v2(203.55,75.01) v2(204.53,62.01) v2(204.54,61.35) v2(204.57,60.69) v2(204.58,60.06) v2(204.95,62.01) v2(204.9,56.81) v2(204.96,61.35) v2(204.99,60.69) v2(205,60.06) v2(205.37,62.01) v2(205.38,61.35) v2(205.39,60.69) v2(205.42,60.06) v2(205.95,56.58) v2(221.82,24.27) v2(223.72,22.97) v2(226.06,12.68) v2(226.06,10.26) v2(226.06,7.85) v2(226.06,5.44) v2(227.96,11.38) v2(227.96,8.96) v2(227.96,6.55) v2(227.96,4.14) v4(49.44,79.9) v4(59.75,82.21) v6(27.26,23.18) v6(35.05,19.14) v6(37.4,21.04) v6(52.85,68.2) v6(53.54,68.18) v6(55.11,68.08) v6(55.75,68.08) v6(56.41,68.08) v6(57.05,68.08) v6(58.29,68.1) v6(59.03,68.13) v6(91.77,73.29) v6(114.31,50.7) v6(132.47,40.98) v6(132.47,39.08) v6(138.51,39.2) v6(138.56,41.11) v6(140.82,41.62) v6(140.82,40.86) v6(140.85,40.22) v6(146.72,41.87) v6(149.03,31.71) v6(153.52,38.77) v6(157.7,27.05) v6(160.14,27.65) v6(160.33,40.82) v6(162.11,40.82) v6(162.55,27.98) v6(184.39,83.59) v6(187.64,81.64) v6(212.73,72.68) v6(212.9,73.58) v6(216.46,27.32) v6(216.48,20.71) v7(0.77,27.9) v7(0.77,23.33) v7(0.77,18.76) v7(4.12,30.19) v7(6.05,23.91) v7(6.05,23.28) v7(6.44,18.88) v7(6.69,24.55) v7(6.69,23.91) v7(9.94,24.55) v7(9.94,23.91) v7(9.94,23.28) v7(9.94,22.64) v7(10.42,19.49) v7(10.47,36.28) v7(12.66,39.71) v7(14.41,43.4) v7(15.55,47.31) v7(16.19,51.35) v7(16.26,84.95) v7(16.26,60.49) v7(16.26,55.92) v7(16.69,62.7) v7(16.72,60.03) v7(16.72,58.41) v7(17.05,88.28) v7(17.79,21.53) v7(18.46,44.41) v7(19.06,38.06) v7(19.08,37.45) v7(19.08,28.92) v7(19.21,29.98) v7(19.36,26.63) v7(19.51,31.92) v7(19.61,31.29) v7(19.59,27.5) v7(20.02,33.31) v7(20.5,86.58) v7(21.1,45.58) v7(22.05,22.57) v7(22.33,46.6) v7(22.31,45.98) v7(22.41,82) v7(22.41,80.61) v7(22.41,79.08) v7(22.74,57.42) v7(22.94,86.58) v7(23.38,57.42) v7(23.48,68.24) v7(23.48,66.97) v7(23.48,65.72) v7(23.81,82) v7(23.81,80.61) v7(23.81,79.08) v7(24.11,86.58) v7(24.09,68.24) v7(24.11,66.97) v7(24.09,65.72) v7(24.57,80.61) v7(24.57,79.08) v7(24.7,82) v7(24.7,68.64) v7(24.7,68.03) v7(24.7,67.4) v7(24.7,66.76) v7(24.7,66.13) v7(24.82,45.35) v7(25.33,69.94) v7(25.33,69.3) v7(25.33,68.67) v7(25.33,68.03) v7(25.33,67.4) v7(25.33,66.76) v7(25.36,66.13) v7(25.97,69.94) v7(25.97,69.3) v7(25.97,68.67) v7(25.97,68.03) v7(25.97,67.4) v7(25.97,66.76) v7(25.99,66.13) v7(26.02,18.33) v7(30.46,18.33) v7(30.79,53.33) v7(31,22.34) v7(31,21.73) v7(31.06,79.78) v7(31.48,53.31) v7(31.68,79.59) v7(31.81,22.34) v7(31.81,21.73) v7(31.91,86.58) v7(32.42,83.68) v7(33.59,78.96) v7(34.07,79.48) v7(34.47,78.96) v7(35.07,79.51) v7(35.62,18.33) v7(35.72,78.96) v7(36.32,79.46) v7(36.76,70.7) v7(36.76,70.07) v7(36.76,69.43) v7(37.01,78.96) v7(37.4,70.7) v7(37.4,70.07) v7(37.4,69.43) v7(37.47,38.77) v7(37.61,79.43) v7(38.18,78.97) v7(39.81,73.75) v7(40.19,18.33) v7(40.44,73.75) v7(40.47,39.41) v7(40.95,38.21) v7(41.08,74) v7(41.43,53.38) v7(41.71,74) v7(41.71,73.37) v7(41.97,53.76) v7(42.54,65.94) v7(42.48,54.14) v7(42.96,54.6) v7(43.17,65.94) v7(43.81,65.94) v7(44.51,65.92) v7(44.76,18.33) v7(45.04,86.19) v7(45.14,65.92) v7(45.79,65.93) v7(46.24,86.04) v7(46.43,65.89) v7(46.64,74.89) v7(46.84,86.04) v7(47.06,65.89) v7(47.3,74.89) v7(47.45,86.04) v7(47.7,65.89) v7(47.94,74.89) v7(48.06,86.04) v7(48.32,65.87) v7(48.57,74.89) v7(49.21,74.89) v7(51.34,18.33) v7(51.62,82.13) v7(51.59,39.03) v7(51.75,81.22) v7(52.1,81.75) v7(53.96,38.44) v7(55.63,18.05) v7(56.88,39.36) v7(57.84,86.07) v7(57.97,19.01) v7(58.48,86.07) v7(58.48,39.26) v7(58.6,19.01) v7(59.11,86.07) v7(59.15,51.71) v7(59.19,46.01) v7(59.24,19.01) v7(59.52,39.36) v7(59.62,51.24) v7(59.75,86.07) v7(59.82,46.04) v7(59.87,19.01) v7(60.38,86.07) v7(60.51,20.28) v7(60.51,19.65) v7(60.51,19.01) v7(60.8,71.81) v7(61.02,86.07) v7(61.14,19.01) v7(61.65,86.07) v7(61.65,71.81) v7(61.78,19.01) v7(62.03,69.3) v7(62.16,70.07) v7(62.29,86.07) v7(62.67,71.81) v7(62.67,69.3) v7(62.92,86.07) v7(63.35,18.33) v7(63.56,71.81) v7(63.56,69.3) v7(63.81,61.56) v7(64.07,70.07) v7(64.57,71.81) v7(64.57,69.3) v7(65.44,33.04) v7(65.46,71.81) v7(65.46,69.3) v7(65.46,35.16) v7(65.97,70.07) v7(66.48,71.81) v7(66.48,69.3) v7(67.37,71.81) v7(67.37,69.3) v7(67.46,29.6) v7(67.6,27.44) v7(67.88,70.07) v7(68.38,71.81) v7(68.38,69.3) v7(69.07,69.3) v7(69.27,71.81) v7(69.63,18.33) v7(69.7,69.3) v7(69.78,70.07) v7(69.91,86.07) v7(69.91,71.81) v7(70.34,69.3) v7(70.54,86.07) v7(70.57,71.81) v7(71.18,86.07) v7(71.81,86.07) v7(72.45,86.07) v7(73.08,86.07) v7(74.2,18.33) v7(78.77,18.33) v7(81.85,86.07) v7(81.85,85.43) v7(81.85,84.8) v7(82.48,86.07) v7(82.58,34.25) v7(83.12,86.07) v7(83.34,18.33) v7(83.75,86.07) v7(84.18,60.92) v7(84.39,86.07) v7(84.39,85.43) v7(84.84,68.11) v7(84.87,86.58) v7(85.66,34.2) v7(87.94,66.33) v7(88.55,66.33) v7(88.58,38.9) v7(89.16,66.31) v7(89.44,86.58) v7(89.72,66.56) v7(91.43,41.12) v7(91.65,33.79) v7(92.18,40.2) v7(93.28,58.91) v7(93.66,79.46) v7(93.71,78.85) v7(93.71,48.93) v7(94.01,86.58) v7(94.47,79.49) v7(94.5,78.85) v7(94.5,56.98) v7(94.8,85.18) v7(95.1,79.08) v7(95.64,86) v7(95.77,73.72) v7(95.87,79.08) v7(96.27,86) v7(97.41,86) v7(98.05,86) v7(98.03,49.03) v7(98.36,18.33) v7(98.58,86.58) v7(98.94,47.99) v7(98.99,40.96) v7(99.07,44.64) v7(99.32,86) v7(99.83,34.38) v7(99.95,86) v7(100.16,39.81) v7(100.57,39.36) v7(101.1,86) v7(101.73,86) v7(102.14,39.81) v7(102.75,86) v7(102.8,39.71) v7(102.8,39.1) v7(102.93,18.33) v7(102.98,48.6) v7(103,40.3) v7(103.16,86.58) v7(103.49,39.08) v7(103.64,86) v7(103.59,48.6) v7(104.2,50.95) v7(104.2,49.49) v7(104.22,48.6) v7(104.71,50.25) v7(104.86,48.6) v7(105.09,50.95) v7(105.09,49.49) v7(106.74,33.92) v7(107.5,18.33) v7(109.23,82.45) v7(109.25,83.76) v7(110.11,83.21) v7(110.17,18.5) v7(110.8,86.58) v7(110.78,83.78) v7(111,82.45) v7(113.36,33.78) v7(113.52,30.23) v7(113.67,83.45) v7(114.31,83.49) v7(114.64,23) v7(114.66,22.24) v7(114.66,21.53) v7(114.66,20.82) v7(115.27,23) v7(115.3,22.24) v7(115.3,21.53) v7(115.3,20.82) v7(116.01,22.97) v7(116.03,22.21) v7(116.03,21.5) v7(116.03,20.79) v7(116.31,35.32) v7(116.64,18.33) v7(116.77,27.14) v7(116.87,24.83) v7(117.69,32.19) v7(117.84,24.83) v7(118.65,29.83) v7(118.96,27.17) v7(121.22,18.33) v7(121.85,47.97) v7(122.1,79.46) v7(123.81,84.44) v7(124.26,46.95) v7(124.26,45.94) v7(124.39,86.58) v7(125.15,78.14) v7(125.15,46.44) v7(125.79,18.33) v7(125.91,82.49) v7(126.04,46.95) v7(126.04,45.94) v7(127.39,86.58) v7(128,86.58) v7(129.03,86.35) v7(130.39,80.56) v7(132.39,86.58) v7(134.86,20.99) v7(135.44,73.13) v7(135.36,20.33) v7(136.23,85.48) v7(136.35,69.08) v7(138.3,29.93) v7(138.37,28.8) v7(139.75,29.98) v7(139.81,28.71) v7(139.94,20.33) v7(140.34,29.73) v7(140.34,29.08) v7(140.93,28.82) v7(143.21,86.58) v7(144.51,20.33) v7(147.5,36.72) v7(147.61,38.15) v7(147.58,37.4) v7(147.78,82) v7(148.32,38.16) v7(148.33,37.4) v7(148.39,78.25) v7(148.36,36.7) v7(149.13,38.18) v7(149.09,37.43) v7(149.12,36.69) v7(149.08,20.33) v7(151.77,86.58) v7(153.65,20.33) v7(154.26,32.09) v7(154.41,83.96) v7(154.92,60.57) v7(154.9,32.09) v7(155.05,83.96) v7(155,63.72) v7(155.38,80.73) v7(155.48,32.47) v7(156.34,86.58) v7(157.06,61.18) v7(158.15,66.57) v7(158.22,20.33) v7(159.47,72.62) v7(160.92,86.58) v7(161.68,53.2) v7(162.63,72.01) v7(162.67,55.18) v7(162.8,20.33) v7(163.18,53.3) v7(163.76,50.23) v7(164.04,72.47) v7(164.4,50.23) v7(165.02,72.09) v7(165.46,86.58) v7(165.97,72.33) v7(167.24,61.28) v7(167.37,20.33) v7(169.35,40.73) v7(169.35,38.82) v7(169.78,88.05) v7(169.84,66.21) v7(169.87,65.57) v7(169.86,39.71) v7(170.36,40.73) v7(170.36,38.82) v7(170.92,42.05) v7(171.41,41.67) v7(171.94,20.33) v7(172.63,55.05) v7(172.63,54.44) v7(173.06,56.86) v7(174.56,82.26) v7(174.56,81.6) v7(175.19,82.26) v7(175.19,81.6) v7(175.5,37.25) v7(176.51,20.33) v7(177.17,28.08) v7(177.35,66.38) v7(178.37,35.04) v7(180.63,18.33) v7(181.92,56.4) v7(182.75,52.72) v7(183.06,69.3) v7(183.06,68.67) v7(183.24,58.13) v7(183.7,69.3) v7(183.7,68.67) v7(183.88,58.13) v7(184.33,69.3) v7(184.33,68.67) v7(184.51,58.13) v7(185.2,18.33) v7(188.44,71.68) v7(188.44,70.98) v7(189.07,71.68) v7(189.07,70.98) v7(189.77,18.33) v7(190.94,72.03) v7(190.94,71.4) v7(191.62,85.56) v7(193.15,56.4) v7(193.14,55.64) v7(193.96,56.22) v7(193.96,55.61) v7(194.32,66) v7(194.32,65.37) v7(194.34,18.33) v7(194.8,64.94) v7(194.8,64.33) v7(197.21,84.01) v7(198.91,18.33) v7(200.07,70.93) v7(200.07,70.27) v7(200.87,81.78) v7(201.25,53.56) v7(202.18,71.5) v7(202.19,70.85) v7(202.19,70.15) v7(202.72,79.92) v7(202.93,53.35) v7(203.49,18.33) v7(208.08,61.81) v7(208.08,61.18) v7(208.06,18.33) v7(210.85,61) v7(212.27,78.27) v7(212.63,18.33) v7(212.99,56.73) v7(214.66,73.11) v7(215.2,65.75) v7(215.2,65.11) v7(215.2,64.48) v7(216.64,61.67) v7(217.2,18.33) v7(218.4,25.46) v7(220.31,18.42) v7(220.43,25.46) v7(220.63,50.25) v7(221.77,18.1) v7(222.03,22.01) v7(223.32,67.14) v7(223.83,76.29) v7(224.26,13.42) v7(224.26,9.11) v7(224.44,47.71) v7(224.67,63.46) v7(225.74,78.27) v7(226.14,3.26) v7(227.85,66.03) v7(228.65,76.56) v7(229.78,1.46) v7(230.31,78.27) v7(231.11,26.72) v7(231.93,20.08) v7(232.39,13.27) v7(232.39,2.48) v7(232.72,8.7) v9(5.63,24.73) v9(8.63,24.03) v9(11.2,23.25) v9(40.69,75.41) v9(40.71,74.57) v9(43.5,51.79) v9(48.05,53.01) v9(48.23,49.57) v9(48.37,63.78) v9(48.99,63.82) v9(58.06,59.27) v9(58.62,51.21) v9(59,52.78) v9(61.4,51.35) v9(63.62,45.9) v9(88.42,67.7) v9(95.6,78.33) v9(98.01,45.05) v9(98.28,47.12) v9(99.02,38.06) v9(99.55,39.4) v9(101.66,37.5) v9(104.05,37.83) v9(104.45,39.56) v9(113.51,21.76) v9(113.8,82) v9(114.92,84.02) v9(130.7,40.07) v9(154.9,85.92) v9(163.84,32.7) v9(168.55,32.89) v9(169.55,85.92) v9(186.14,61.82) v9(200.96,65.6) v9(206.27,60.4) v9(212.29,63.58) v10(24.06,37.3) v10(24.38,26.74) v10(24.57,33.67) v10(25,37.33) v10(26.36,31.35) v10(35.44,26.73) v10(35.6,33.67) v10(36.04,37.29) v10(37.38,31.35) v10(46.16,37.28) v10(46.49,26.74) v10(46.66,33.68) v10(47.09,37.29) v10(48.43,31.35) v10(57.21,37.24) v10(57.54,26.74) v10(57.7,33.67) v10(58.14,37.29) v10(59.48,31.35) v10(64.42,41.83) v10(66.53,39.22) v10(66.81,38.37) v10(69.1,35.78) v10(69.7,40.83) v10(72.7,32.2) v10(73.04,21.66) v10(73.2,28.58) v10(73.63,32.21) v10(74.98,26.27) v10(78.34,41.73) v10(83.75,32.2) v10(84.09,21.66) v10(84.25,28.58) v10(84.68,32.21) v10(86.03,26.27) v10(94.8,32.2) v10(95.13,21.66) v10(95.29,28.59) v10(95.73,32.26) v10(97.08,26.27) v10(105.85,32.2) v10(106.18,21.66) v10(106.35,28.6) v10(106.78,32.21) v10(108.12,26.27)
